$ Spice netlist generated by v2lvs
$ v2019.2_14.13    Tue Apr 9 20:08:58 PDT 2019
.INCLUDE "core.spi"
.INCLUDE "umc18_io_lvs.spi"
*.BUSDELIMITER [

.SUBCKT Domain_Transfer_1_DW01_sub_0 A[31] A[30] A[29] A[28] A[27] A[26] A[25]
+ A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12]
+ A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] CI DIFF[31] DIFF[30] DIFF[29] DIFF[28] DIFF[27] DIFF[26]
+ DIFF[25] DIFF[24] DIFF[23] DIFF[22] DIFF[21] DIFF[20] DIFF[19] DIFF[18]
+ DIFF[17] DIFF[16] DIFF[15] DIFF[14] DIFF[13] DIFF[12] DIFF[11] DIFF[10]
+ DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3] DIFF[2] DIFF[1]
+ DIFF[0] CO
XFE_OCPC465_carry_16 BUF1S $PINS O=FE_OCPN465_carry_16 I=carry[16]
XFE_OCPC370_carry_20 BUF1S $PINS O=FE_OCPN370_carry_20 I=carry[20]
XFE_OCPC353_carry_28 BUF1S $PINS O=FE_OCPN353_carry_28 I=carry[28]
XFE_OCPC297_carry_9 BUF1S $PINS O=FE_OCPN297_carry_9 I=carry[9]
XFE_OCPC291_carry_22 BUF1S $PINS O=FE_OCPN291_carry_22 I=carry[22]
XFE_OCPC224_carry_15 BUF1S $PINS O=FE_OCPN224_carry_15 I=carry[15]
XFE_OCPC165_carry_8 BUF1S $PINS O=FE_OCPN165_carry_8 I=carry[8]
XFE_RC_2012_0 ND2 $PINS O=FE_RN_1363_0 I1=A[22] I2=n82
XFE_RC_2011_0 AN2S $PINS O=FE_RN_1364_0 I1=FE_RN_1367_0 I2=FE_RN_1363_0
XFE_RC_2010_0 XNR2HS $PINS O=FE_RN_1365_0 I1=n82 I2=A[22]
XFE_RC_2009_0 MXL2HS $PINS OB=DIFF[22] S=FE_OCPN291_carry_22 A=FE_RN_1365_0
+ B=FE_RN_1364_0
XFE_RC_2008_0 ND2 $PINS O=FE_RN_1366_0 I1=A[22] I2=n82
XFE_RC_2007_0 OR2 $PINS O=FE_RN_1367_0 I1=n82 I2=A[22]
XFE_RC_2006_0 ND2 $PINS O=FE_RN_1368_0 I1=FE_RN_1367_0 I2=carry[22]
XFE_RC_2005_0 ND2P $PINS O=carry[23] I1=FE_RN_1368_0 I2=FE_RN_1366_0
XFE_RC_1877_0 ND3P $PINS O=carry[28] I1=n31 I2=n32 I3=n30
XFE_RC_1839_0 ND2 $PINS O=FE_RN_1232_0 I1=A[23] I2=n83
XFE_RC_1838_0 AN2S $PINS O=FE_RN_1233_0 I1=FE_RN_1236_0 I2=FE_RN_1232_0
XFE_RC_1837_0 XNR2HS $PINS O=FE_RN_1234_0 I1=n83 I2=A[23]
XFE_RC_1836_0 MXL2HS $PINS OB=DIFF[23] S=carry[23] A=FE_RN_1234_0
+ B=FE_RN_1233_0
XFE_RC_1835_0 ND2 $PINS O=FE_RN_1235_0 I1=A[23] I2=n83
XFE_RC_1834_0 OR2 $PINS O=FE_RN_1236_0 I1=n83 I2=A[23]
XFE_RC_1833_0 ND2 $PINS O=FE_RN_1237_0 I1=FE_RN_1236_0 I2=carry[23]
XFE_RC_1832_0 ND2P $PINS O=carry[24] I1=FE_RN_1237_0 I2=FE_RN_1235_0
XFE_RC_1723_0 INV1S $PINS O=FE_RN_1140_0 I=A[1]
XFE_RC_1722_0 INV1S $PINS O=FE_RN_1141_0 I=A[1]
XFE_RC_1721_0 ND2 $PINS O=FE_RN_1142_0 I1=FE_RN_1141_0 I2=n61
XFE_RC_1720_0 OAI12HS $PINS O=FE_RN_1143_0 A1=FE_RN_1142_0 B1=FE_RN_1140_0
+ B2=n61
XFE_RC_1719_0 ND2 $PINS O=FE_RN_1144_0 I1=FE_RN_1143_0 I2=DIFF[0]
XFE_RC_1718_0 INV1S $PINS O=FE_RN_1145_0 I=n61
XFE_RC_1717_0 INV1S $PINS O=FE_RN_1146_0 I=A[1]
XFE_RC_1716_0 OAI12HS $PINS O=FE_RN_1147_0 A1=FE_RN_1151_0 B1=FE_RN_1146_0
+ B2=FE_RN_1145_0
XFE_RC_1715_0 ND2 $PINS O=FE_RN_1148_0 I1=FE_RN_1147_0 I2=n60
XFE_RC_1714_0 ND2 $PINS O=DIFF[1] I1=FE_RN_1148_0 I2=FE_RN_1144_0
XFE_RC_1713_0 ND2 $PINS O=FE_RN_1149_0 I1=A[1] I2=n61
XFE_RC_1712_0 INV1S $PINS O=FE_RN_1150_0 I=A[1]
XFE_RC_1711_0 OR2B1 $PINS O=FE_RN_1151_0 I1=n61 B1=FE_RN_1150_0
XFE_RC_1710_0 ND2 $PINS O=FE_RN_1152_0 I1=FE_RN_1151_0 I2=n60
XFE_RC_1709_0 ND2P $PINS O=carry[2] I1=FE_RN_1152_0 I2=FE_RN_1149_0
XFE_RC_1708_0 ND3P $PINS O=carry[16] I1=n21 I2=n22 I3=n20
XFE_RC_1600_0 OR2 $PINS O=FE_RN_1061_0 I1=FE_RN_1050_0 I2=FE_RN_1057_0
XFE_RC_1599_0 ND2P $PINS O=carry[17] I1=FE_RN_1059_0 I2=FE_RN_1061_0
XFE_RC_1596_0 INV1S $PINS O=FE_RN_1050_0 I=n76
XFE_RC_1595_0 INV1S $PINS O=FE_RN_1051_0 I=A[16]
XFE_RC_1594_0 AOI22S $PINS O=FE_RN_1052_0 A1=FE_RN_1051_0 A2=n76 B1=A[16]
+ B2=FE_RN_1050_0
XFE_RC_1593_0 ND2S $PINS O=FE_RN_1053_0 I1=A[16] I2=n76
XFE_RC_1592_0 ND2S $PINS O=FE_RN_1054_0 I1=FE_RN_1058_0 I2=FE_RN_1053_0
XFE_RC_1591_0 ND2 $PINS O=FE_RN_1055_0 I1=FE_OCPN465_carry_16 I2=FE_RN_1054_0
XFE_RC_1590_0 OAI12HS $PINS O=DIFF[16] A1=FE_RN_1055_0 B1=FE_OCPN465_carry_16
+ B2=FE_RN_1052_0
XFE_RC_1588_0 INV1S $PINS O=FE_RN_1057_0 I=A[16]
XFE_RC_1587_0 OR2 $PINS O=FE_RN_1058_0 I1=n76 I2=A[16]
XFE_RC_1586_0 ND2 $PINS O=FE_RN_1059_0 I1=FE_RN_1058_0 I2=carry[16]
XFE_RC_1453_0 OR2 $PINS O=FE_RN_950_0 I1=FE_RN_830_0 I2=FE_RN_826_0
XFE_RC_1452_0 ND2P $PINS O=carry[10] I1=FE_RN_832_0 I2=FE_RN_950_0
XFE_RC_1291_0 INV1S $PINS O=FE_RN_824_0 I=FE_RN_831_0
XFE_RC_1290_0 AOI12HS $PINS O=FE_RN_825_0 A1=FE_RN_824_0 B1=A[9] B2=n69
XFE_RC_1289_0 INV1S $PINS O=FE_RN_826_0 I=n69
XFE_RC_1288_0 INV1S $PINS O=FE_RN_827_0 I=A[9]
XFE_RC_1287_0 AOI22S $PINS O=FE_RN_828_0 A1=FE_RN_827_0 A2=n69 B1=A[9]
+ B2=FE_RN_826_0
XFE_RC_1286_0 MXL2HS $PINS OB=DIFF[9] S=FE_OCPN297_carry_9 A=FE_RN_828_0
+ B=FE_RN_825_0
XFE_RC_1284_0 INV1S $PINS O=FE_RN_830_0 I=A[9]
XFE_RC_1283_0 OR2 $PINS O=FE_RN_831_0 I1=n69 I2=A[9]
XFE_RC_1282_0 ND2 $PINS O=FE_RN_832_0 I1=FE_RN_831_0 I2=carry[9]
XFE_RC_1084_0 ND2S $PINS O=FE_RN_681_0 I1=A[10] I2=n70
XFE_RC_1083_0 AN2 $PINS O=FE_RN_682_0 I1=FE_RN_685_0 I2=FE_RN_681_0
XFE_RC_1082_0 XNR2HS $PINS O=FE_RN_683_0 I1=n70 I2=A[10]
XFE_RC_1081_0 MXL2HS $PINS OB=DIFF[10] S=carry[10] A=FE_RN_683_0 B=FE_RN_682_0
XFE_RC_1079_0 OR2 $PINS O=FE_RN_685_0 I1=n70 I2=A[10]
XFE_RC_1078_0 ND2 $PINS O=FE_RN_686_0 I1=FE_RN_685_0 I2=carry[10]
XFE_RC_1077_0 ND2P $PINS O=carry[11] I1=FE_RN_686_0 I2=FE_RN_681_0
XFE_RC_906_0 ND2S $PINS O=FE_RN_547_0 I1=A[11] I2=n71
XFE_RC_905_0 AN2S $PINS O=FE_RN_548_0 I1=FE_RN_551_0 I2=FE_RN_547_0
XFE_RC_904_0 XNR2HS $PINS O=FE_RN_549_0 I1=n71 I2=A[11]
XFE_RC_903_0 MXL2HS $PINS OB=DIFF[11] S=carry[11] A=FE_RN_549_0 B=FE_RN_548_0
XFE_RC_901_0 OR2S $PINS O=FE_RN_551_0 I1=n71 I2=A[11]
XFE_RC_900_0 ND2 $PINS O=FE_RN_552_0 I1=FE_RN_551_0 I2=carry[11]
XFE_RC_899_0 ND2P $PINS O=carry[12] I1=FE_RN_552_0 I2=FE_RN_547_0
XFE_RC_714_0 ND3P $PINS O=carry[4] I1=n29 I2=n28 I3=n27
XFE_RC_713_0 INV1S $PINS O=FE_RN_413_0 I=n45
XFE_RC_712_0 ND3P $PINS O=carry[6] I1=n51 I2=n50 I3=FE_RN_413_0
XFE_RC_701_0 ND2S $PINS O=FE_RN_400_0 I1=A[17] I2=n77
XFE_RC_700_0 AN2 $PINS O=FE_RN_401_0 I1=FE_RN_404_0 I2=FE_RN_400_0
XFE_RC_699_0 XNR2HS $PINS O=FE_RN_402_0 I1=n77 I2=A[17]
XFE_RC_698_0 MXL2HS $PINS OB=DIFF[17] S=carry[17] A=FE_RN_402_0 B=FE_RN_401_0
XFE_RC_697_0 ND2S $PINS O=FE_RN_403_0 I1=A[17] I2=n77
XFE_RC_696_0 OR2 $PINS O=FE_RN_404_0 I1=n77 I2=A[17]
XFE_RC_695_0 ND2 $PINS O=FE_RN_405_0 I1=FE_RN_404_0 I2=carry[17]
XFE_RC_694_0 ND2P $PINS O=carry[18] I1=FE_RN_405_0 I2=FE_RN_403_0
XFE_RC_520_0 ND3P $PINS O=carry[3] I1=n24 I2=n25 I3=n23
XFE_RC_517_0 ND2 $PINS O=FE_RN_270_0 I1=A[18] I2=n78
XFE_RC_516_0 AN2 $PINS O=FE_RN_271_0 I1=FE_RN_274_0 I2=FE_RN_270_0
XFE_RC_515_0 XNR2HS $PINS O=FE_RN_272_0 I1=n78 I2=A[18]
XFE_RC_514_0 MXL2HS $PINS OB=DIFF[18] S=carry[18] A=FE_RN_272_0 B=FE_RN_271_0
XFE_RC_513_0 ND2 $PINS O=FE_RN_273_0 I1=A[18] I2=n78
XFE_RC_512_0 OR2 $PINS O=FE_RN_274_0 I1=n78 I2=A[18]
XFE_RC_511_0 ND2 $PINS O=FE_RN_275_0 I1=FE_RN_274_0 I2=carry[18]
XFE_RC_510_0 ND2P $PINS O=carry[19] I1=FE_RN_275_0 I2=FE_RN_273_0
XFE_RC_298_0 ND3P $PINS O=carry[20] I1=n10 I2=n11 I3=n9
XFE_RC_295_0 INV1S $PINS O=FE_RN_125_0 I=FE_RN_133_0
XFE_RC_294_0 AOI12HS $PINS O=FE_RN_126_0 A1=FE_RN_125_0 B1=A[6] B2=n66
XFE_RC_293_0 INV1S $PINS O=FE_RN_127_0 I=n66
XFE_RC_292_0 INV1S $PINS O=FE_RN_128_0 I=A[6]
XFE_RC_291_0 AOI22S $PINS O=FE_RN_129_0 A1=FE_RN_128_0 A2=n66 B1=A[6]
+ B2=FE_RN_127_0
XFE_RC_290_0 MXL2HS $PINS OB=DIFF[6] S=carry[6] A=FE_RN_129_0 B=FE_RN_126_0
XFE_RC_289_0 ND2 $PINS O=FE_RN_130_0 I1=A[6] I2=n66
XFE_RC_287_0 INV1S $PINS O=FE_RN_132_0 I=A[6]
XFE_RC_286_0 ND2 $PINS O=FE_RN_133_0 I1=FE_RN_132_0 I2=FE_RN_127_0
XFE_RC_285_0 ND2 $PINS O=FE_RN_134_0 I1=FE_RN_133_0 I2=carry[6]
XFE_RC_284_0 ND2P $PINS O=carry[7] I1=FE_RN_134_0 I2=FE_RN_130_0
XFE_RC_145_0 INV1S $PINS O=FE_RN_45_0 I=n37
XFE_RC_144_0 ND3 $PINS O=carry[9] I1=n43 I2=n44 I3=FE_RN_45_0
XFE_RC_129_0 ND3P $PINS O=carry[15] I1=n18 I2=n17 I3=n16
XFE_RC_128_0 ND3P $PINS O=carry[21] I1=n14 I2=n15 I3=n13
XFE_RC_119_0 ND3P $PINS O=carry[5] I1=n48 I2=n47 I3=n46
XFE_OFC285_raw_prime_3 INV1S $PINS O=n63 I=B[3]
XFE_OFC269_n310 INV1S $PINS O=n60 I=B[0]
XFE_OFC212_raw_prime_5 INV1S $PINS O=n65 I=B[5]
XFE_OFC197_raw_prime_9 INV1S $PINS O=n69 I=B[9]
XFE_OFC161_raw_prime_7 INV1S $PINS O=n67 I=B[7]
XFE_OFC147_raw_prime_6 INV1S $PINS O=n66 I=B[6]
XFE_OFC105_n312 INV2 $PINS O=n61 I=B[1]
XFE_OFC89_raw_prime_4 INV1S $PINS O=n64 I=B[4]
XU2_26 FA1 $PINS S=DIFF[26] CO=carry[27] A=A[26] B=n86 CI=carry[26]
XU2_25 FA1 $PINS S=DIFF[25] CO=carry[26] A=A[25] B=n85 CI=carry[25]
XU2_24 FA1 $PINS S=DIFF[24] CO=carry[25] A=A[24] B=n84 CI=carry[24]
XU2_21 FA1 $PINS S=DIFF[21] CO=carry[22] A=A[21] B=n81 CI=carry[21]
XU1 ND2 $PINS O=n8 I1=n73 I2=A[13]
XU3 XOR3 $PINS O=DIFF[14] I1=A[14] I2=n74 I3=carry[14]
XU4 XOR3 $PINS O=DIFF[12] I1=n72 I2=A[12] I3=carry[12]
XU5 ND2 $PINS O=n1 I1=carry[12] I2=n72
XU6 ND2 $PINS O=n2 I1=carry[12] I2=A[12]
XU7 ND2 $PINS O=n3 I1=n72 I2=A[12]
XU8 ND3P $PINS O=carry[13] I1=n1 I2=n2 I3=n3
XU9 ND2P $PINS O=n6 I1=carry[13] I2=n73
XU10 ND2P $PINS O=n4 I1=n6 I2=n8
XU11 ND2P $PINS O=carry[14] I1=n7 I2=n5
XU12 INV2CK $PINS O=n5 I=n4
XU13 ND2S $PINS O=n7 I1=carry[13] I2=A[13]
XU14 INV1S $PINS O=n38 I=A[31]
XU15 ND2 $PINS O=n9 I1=A[19] I2=n79
XU16 ND2 $PINS O=n23 I1=A[2] I2=B[2]
XU17 ND2 $PINS O=n39 I1=A[7] I2=n67
XU18 ND2 $PINS O=n16 I1=A[14] I2=n74
XU19 ND2 $PINS O=n30 I1=A[27] I2=n87
XU22 XOR3 $PINS O=DIFF[4] I1=A[4] I2=n64 I3=carry[4]
XU23 XOR3 $PINS O=DIFF[7] I1=A[7] I2=n67 I3=carry[7]
XU24 XOR3 $PINS O=DIFF[19] I1=A[19] I2=n79 I3=carry[19]
XU25 XOR3 $PINS O=DIFF[29] I1=A[29] I2=n89 I3=carry[29]
XU26 XOR3 $PINS O=DIFF[27] I1=A[27] I2=n87 I3=carry[27]
XU27 XOR3 $PINS O=DIFF[2] I1=A[2] I2=B[2] I3=carry[2]
XU28 XOR3 $PINS O=DIFF[13] I1=n73 I2=A[13] I3=carry[13]
XU31 ND3P $PINS O=carry[8] I1=n41 I2=n40 I3=n39
XU32 ND2 $PINS O=n10 I1=A[19] I2=carry[19]
XU33 ND2 $PINS O=n11 I1=n79 I2=carry[19]
XU35 XOR2HS $PINS O=n12 I1=A[20] I2=n80
XU36 XOR2HS $PINS O=DIFF[20] I1=n12 I2=FE_OCPN370_carry_20
XU37 ND2S $PINS O=n13 I1=A[20] I2=n80
XU38 ND2 $PINS O=n14 I1=A[20] I2=carry[20]
XU39 ND2 $PINS O=n15 I1=n80 I2=carry[20]
XU41 ND2 $PINS O=n17 I1=A[14] I2=carry[14]
XU42 ND2 $PINS O=n18 I1=n74 I2=carry[14]
XU44 XOR2HS $PINS O=n19 I1=A[15] I2=n75
XU45 XOR2HS $PINS O=DIFF[15] I1=n19 I2=FE_OCPN224_carry_15
XU46 ND2S $PINS O=n20 I1=A[15] I2=n75
XU47 ND2 $PINS O=n21 I1=A[15] I2=carry[15]
XU48 ND2 $PINS O=n22 I1=n75 I2=carry[15]
XU50 ND2 $PINS O=n24 I1=A[2] I2=carry[2]
XU51 ND2 $PINS O=n25 I1=B[2] I2=carry[2]
XU52 XOR2HS $PINS O=n26 I1=A[3] I2=n63
XU53 XOR2HS $PINS O=DIFF[3] I1=n26 I2=carry[3]
XU54 ND2 $PINS O=n27 I1=A[3] I2=n63
XU55 ND2 $PINS O=n28 I1=A[3] I2=carry[3]
XU56 ND2 $PINS O=n29 I1=n63 I2=carry[3]
XU58 ND2 $PINS O=n31 I1=A[27] I2=carry[27]
XU59 ND2 $PINS O=n32 I1=n87 I2=carry[27]
XU60 XOR2HS $PINS O=n33 I1=A[28] I2=n88
XU61 XOR2HS $PINS O=DIFF[28] I1=n33 I2=FE_OCPN353_carry_28
XU62 ND2S $PINS O=n34 I1=A[28] I2=n88
XU63 ND2 $PINS O=n35 I1=A[28] I2=carry[28]
XU64 ND2 $PINS O=n36 I1=n88 I2=carry[28]
XU65 ND3P $PINS O=carry[29] I1=n35 I2=n36 I3=n34
XU67 AN2 $PINS O=n37 I1=A[8] I2=B[8]
XU68 XOR3 $PINS O=DIFF[31] I1=n38 I2=B[31] I3=carry[31]
XU69 ND2 $PINS O=n40 I1=A[7] I2=carry[7]
XU70 ND2 $PINS O=n41 I1=n67 I2=carry[7]
XU71 XOR2HS $PINS O=n42 I1=A[8] I2=B[8]
XU72 XOR2HS $PINS O=DIFF[8] I1=n42 I2=FE_OCPN165_carry_8
XU73 ND2 $PINS O=n43 I1=A[8] I2=carry[8]
XU74 ND2 $PINS O=n44 I1=B[8] I2=carry[8]
XU76 AN2 $PINS O=n45 I1=A[5] I2=n65
XU77 ND2 $PINS O=n52 I1=A[29] I2=n89
XU78 ND2 $PINS O=n46 I1=A[4] I2=n64
XU79 ND2 $PINS O=n47 I1=carry[4] I2=A[4]
XU80 ND2 $PINS O=n48 I1=n64 I2=carry[4]
XU82 XOR2HS $PINS O=n49 I1=A[5] I2=n65
XU83 XOR2HS $PINS O=DIFF[5] I1=n49 I2=carry[5]
XU84 ND2 $PINS O=n50 I1=A[5] I2=carry[5]
XU85 ND2 $PINS O=n51 I1=n65 I2=carry[5]
XU86 ND2 $PINS O=n53 I1=carry[29] I2=A[29]
XU87 ND2 $PINS O=n54 I1=n89 I2=carry[29]
XU88 ND3P $PINS O=carry[30] I1=n54 I2=n53 I3=n52
XU89 XOR2HS $PINS O=n55 I1=A[30] I2=n90
XU90 XOR2HS $PINS O=DIFF[30] I1=n55 I2=carry[30]
XU91 ND2S $PINS O=n56 I1=A[30] I2=n90
XU92 ND2 $PINS O=n57 I1=A[30] I2=carry[30]
XU93 ND2 $PINS O=n58 I1=carry[30] I2=n90
XU94 ND3 $PINS O=carry[31] I1=n56 I2=n57 I3=n58
XU96 INV1S $PINS O=DIFF[0] I=n60
XU97 INV1S $PINS O=n81 I=B[21]
XU98 INV1S $PINS O=n73 I=B[13]
XU99 INV1S $PINS O=n89 I=B[29]
XU100 INV1S $PINS O=n77 I=B[17]
XU101 INV1S $PINS O=n83 I=B[23]
XU102 INV1S $PINS O=n79 I=B[19]
XU103 INV1S $PINS O=n75 I=B[15]
XU104 INV1S $PINS O=n87 I=B[27]
XU105 INV1S $PINS O=n85 I=B[25]
XU106 INV1S $PINS O=n71 I=B[11]
XU110 INV1S $PINS O=n88 I=B[28]
XU111 INV1S $PINS O=n86 I=B[26]
XU112 INV1S $PINS O=n84 I=B[24]
XU113 INV1S $PINS O=n82 I=B[22]
XU114 INV1S $PINS O=n80 I=B[20]
XU115 INV1S $PINS O=n78 I=B[18]
XU116 INV1S $PINS O=n76 I=B[16]
XU117 INV1S $PINS O=n74 I=B[14]
XU118 INV1S $PINS O=n72 I=B[12]
XU119 INV1S $PINS O=n90 I=B[30]
XU120 INV1S $PINS O=n70 I=B[10]
.ENDS

.SUBCKT Domain_Transfer_1_DW_cmp_0 A[32] A[31] A[30] A[29] A[28] A[27] A[26]
+ A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13]
+ A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[32]
+ B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19]
+ B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6]
+ B[5] B[4] B[3] B[2] B[1] B[0] TC GE_LT GE_GT_EQ GE_LT_GT_LE EQ_NE
XFE_RC_2390_0 AO12 $PINS O=n277 A1=n286 B1=n285 B2=n287
XU158 INV1S $PINS O=n241 I=B[18]
XU159 INV1S $PINS O=n256 I=n316
XU160 INV1S $PINS O=n261 I=n295
XU161 INV1S $PINS O=n253 I=n314
XU162 OR2 $PINS O=n340 I1=n338 I2=n229
XU163 AO22S $PINS O=n229 A1=B[1] A2=n249 B1=B[0] B2=n341
XU164 INV1S $PINS O=n247 I=B[29]
XU165 INV1S $PINS O=n238 I=B[13]
XU166 INV1S $PINS O=n234 I=B[5]
XU167 INV1S $PINS O=n233 I=B[3]
XU168 INV1S $PINS O=n235 I=B[7]
XU169 INV1S $PINS O=n239 I=B[15]
XU170 INV1S $PINS O=n248 I=B[31]
XU171 INV1S $PINS O=n237 I=B[11]
XU172 INV1S $PINS O=n236 I=B[9]
XU173 INV1S $PINS O=n245 I=B[25]
XU174 INV1S $PINS O=n246 I=B[27]
XU175 INV1S $PINS O=n244 I=B[23]
XU176 INV1S $PINS O=n242 I=B[19]
XU177 INV1S $PINS O=n243 I=B[21]
XU178 INV1S $PINS O=n240 I=B[17]
XU179 MAOI1 $PINS O=n321 A1=B[14] A2=n230 B1=A[15] B2=n239
XU180 AN2 $PINS O=n230 I1=n324 I2=n258
XU181 MAOI1 $PINS O=n304 A1=B[22] A2=n231 B1=A[23] B2=n244
XU182 AN2 $PINS O=n231 I1=n307 I2=n263
XU183 MAOI1 $PINS O=n281 A1=B[30] A2=n232 B1=A[31] B2=n248
XU184 AN2 $PINS O=n232 I1=n284 I2=n267
XU185 INV1S $PINS O=n258 I=A[14]
XU186 INV1S $PINS O=n265 I=A[26]
XU187 INV1S $PINS O=n264 I=A[24]
XU188 INV1S $PINS O=n255 I=A[10]
XU189 INV1S $PINS O=n254 I=A[8]
XU190 INV1S $PINS O=n250 I=A[2]
XU191 INV1S $PINS O=n249 I=A[1]
XU192 INV1S $PINS O=n257 I=A[12]
XU193 INV1S $PINS O=n262 I=A[20]
XU194 INV1S $PINS O=n260 I=A[18]
XU195 INV1S $PINS O=n266 I=A[28]
XU196 INV1S $PINS O=n259 I=A[16]
XU197 INV1S $PINS O=n267 I=A[30]
XU198 INV1S $PINS O=n263 I=A[22]
XU199 INV1S $PINS O=n251 I=A[4]
XU200 INV1S $PINS O=n252 I=A[6]
XU201 OR2 $PINS O=GE_LT_GT_LE I1=A[32] I2=n268
XU202 AOI13HS $PINS O=n268 A1=n272 B1=n269 B2=n270 B3=n271
XU203 AOI22S $PINS O=n272 A1=n273 A2=n274 B1=n274 B2=n275
XU204 AOI22S $PINS O=n274 A1=n276 A2=n277 B1=n278 B2=n279
XU205 OAI112HS $PINS O=n279 A1=n280 B1=n281 C1=A[29] C2=n247
XU206 ND3 $PINS O=n280 I1=n282 I2=n266 I3=B[28]
XU207 OR2B1S $PINS O=n278 I1=n283 B1=n281
XU209 MOAI1S $PINS O=n287 A1=A[25] A2=n245 B1=B[24] B2=n288
XU210 AN2 $PINS O=n288 I1=n289 I2=n264
XU211 MOAI1S $PINS O=n286 A1=A[27] A2=n246 B1=B[26] B2=n290
XU212 AN2 $PINS O=n290 I1=n291 I2=n265
XU213 AOI22S $PINS O=n273 A1=n292 A2=n293 B1=n294 B2=n261
XU214 AOI22S $PINS O=n294 A1=n296 A2=n297 B1=n297 B2=n298
XU215 OA22 $PINS O=n297 A1=A[19] A2=n242 B1=n241 B2=n299
XU216 ND2 $PINS O=n299 I1=n300 I2=n260
XU217 AOI13HS $PINS O=n296 A1=n302 B1=n301 B2=n259 B3=B[16]
XU218 NR2 $PINS O=n302 I1=A[17] I2=n240
XU219 OAI112HS $PINS O=n293 A1=n303 B1=n304 C1=A[21] C2=n243
XU220 ND3 $PINS O=n303 I1=n305 I2=n262 I3=B[20]
XU221 OR2B1S $PINS O=n292 I1=n306 B1=n304
XU222 NR3 $PINS O=n271 I1=n298 I2=n295 I3=n275
XU223 ND3 $PINS O=n275 I1=n285 I2=n276 I3=n308
XU224 OA12 $PINS O=n308 A1=n289 B1=B[24] B2=n264
XU225 ND2 $PINS O=n289 I1=A[25] I2=n245
XU226 OA112 $PINS O=n276 A1=n282 B1=n283 C1=B[28] C2=n266
XU227 OA12 $PINS O=n283 A1=n284 B1=B[30] B2=n267
XU228 ND2 $PINS O=n284 I1=A[31] I2=n248
XU229 ND2 $PINS O=n282 I1=A[29] I2=n247
XU230 OA12 $PINS O=n285 A1=n291 B1=B[26] B2=n265
XU231 ND2 $PINS O=n291 I1=A[27] I2=n246
XU232 OAI112HS $PINS O=n295 A1=n305 B1=n306 C1=B[20] C2=n262
XU233 OA12 $PINS O=n306 A1=n307 B1=B[22] B2=n263
XU234 ND2 $PINS O=n307 I1=A[23] I2=n244
XU235 ND2 $PINS O=n305 I1=A[21] I2=n243
XU236 OAI12HS $PINS O=n298 A1=n300 B1=B[18] B2=n260
XU237 ND2 $PINS O=n300 I1=A[19] I2=n242
XU238 OA12 $PINS O=n270 A1=n301 B1=B[16] B2=n259
XU239 ND2 $PINS O=n301 I1=A[17] I2=n240
XU240 AOI13HS $PINS O=n269 A1=n311 B1=n309 B2=n310 B3=n253
XU241 AOI13HS $PINS O=n311 A1=n314 B1=n312 B2=n256 B3=n313
XU242 OA12 $PINS O=n313 A1=n315 B1=B[8] B2=n254
XU243 MOAI1S $PINS O=n314 A1=n316 A2=n317 B1=n318 B2=n319
XU244 OAI112HS $PINS O=n319 A1=n320 B1=n321 C1=A[13] C2=n238
XU245 ND3 $PINS O=n320 I1=n322 I2=n257 I3=B[12]
XU246 OR2B1S $PINS O=n318 I1=n323 B1=n321
XU247 OAI22S $PINS O=n317 A1=n312 A2=n325 B1=n325 B2=n326
XU248 MOAI1S $PINS O=n326 A1=A[9] A2=n236 B1=B[8] B2=n327
XU249 AN2 $PINS O=n327 I1=n315 I2=n254
XU250 ND2 $PINS O=n315 I1=A[9] I2=n236
XU251 MOAI1S $PINS O=n325 A1=A[11] A2=n237 B1=B[10] B2=n328
XU252 AN2 $PINS O=n328 I1=n329 I2=n255
XU253 OA12 $PINS O=n312 A1=n329 B1=B[10] B2=n255
XU254 ND2 $PINS O=n329 I1=A[11] I2=n237
XU255 OAI112HS $PINS O=n316 A1=n322 B1=n323 C1=B[12] C2=n257
XU256 OA12 $PINS O=n323 A1=n324 B1=B[14] B2=n258
XU257 ND2 $PINS O=n324 I1=A[15] I2=n239
XU258 ND2 $PINS O=n322 I1=A[13] I2=n238
XU259 OAI22S $PINS O=n310 A1=n330 A2=n331 B1=n331 B2=n332
XU260 MOAI1S $PINS O=n332 A1=A[5] A2=n234 B1=B[4] B2=n333
XU261 AN2 $PINS O=n333 I1=n334 I2=n251
XU262 MOAI1S $PINS O=n331 A1=A[7] A2=n235 B1=B[6] B2=n335
XU263 AN2 $PINS O=n335 I1=n336 I2=n252
XU264 OAI112HS $PINS O=n309 A1=n330 B1=n339 C1=n337 C2=n338
XU265 OA112 $PINS O=n339 A1=n334 B1=n340 C1=B[4] C2=n251
XU266 OR2 $PINS O=n341 I1=n249 I2=B[1]
XU267 ND2 $PINS O=n334 I1=A[5] I2=n234
XU268 OA12 $PINS O=n330 A1=n336 B1=B[6] B2=n252
XU269 ND2 $PINS O=n336 I1=A[7] I2=n235
XU270 MOAI1S $PINS O=n338 A1=A[3] A2=n233 B1=B[2] B2=n342
XU271 AN2 $PINS O=n342 I1=n343 I2=n250
XU272 OA12 $PINS O=n337 A1=n343 B1=B[2] B2=n250
XU273 ND2 $PINS O=n343 I1=A[3] I2=n233
.ENDS

.SUBCKT Domain_Transfer_1_DW01_sub_1 A[31] A[30] A[29] A[28] A[27] A[26] A[25]
+ A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12]
+ A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] CI DIFF[31] DIFF[30] DIFF[29] DIFF[28] DIFF[27] DIFF[26]
+ DIFF[25] DIFF[24] DIFF[23] DIFF[22] DIFF[21] DIFF[20] DIFF[19] DIFF[18]
+ DIFF[17] DIFF[16] DIFF[15] DIFF[14] DIFF[13] DIFF[12] DIFF[11] DIFF[10]
+ DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3] DIFF[2] DIFF[1]
+ DIFF[0] CO
XFE_RC_2384_0 XNR2HS $PINS O=FE_RN_1497_0 I1=A[22] I2=n72
XFE_RC_2328_0 XOR3 $PINS O=DIFF[25] I1=A[25] I2=n75 I3=carry[25]
XFE_RC_2327_0 MAO222 $PINS O=carry[26] A1=A[25] B1=n75 C1=carry[25]
XFE_RC_2323_0 INV1S $PINS O=FE_RN_1566_0 I=n41
XFE_RC_2322_0 MXL2HS $PINS OB=DIFF[31] S=carry[31] A=n41 B=FE_RN_1566_0
XFE_RC_2316_0 ND3P $PINS O=carry[29] I1=n22 I2=n21 I3=n20
XFE_RC_2293_0 ND3P $PINS O=carry[28] I1=n17 I2=n18 I3=n16
XFE_RC_2245_0 OR2 $PINS O=FE_RN_1542_0 I1=FE_RN_1499_0 I2=FE_RN_1498_0
XFE_RC_2244_0 ND2P $PINS O=carry[23] I1=FE_RN_1501_0 I2=FE_RN_1542_0
XFE_RC_2190_0 INV1S $PINS O=FE_RN_1493_0 I=FE_RN_1500_0
XFE_RC_2189_0 AOI12HS $PINS O=FE_RN_1494_0 A1=FE_RN_1493_0 B1=A[22] B2=n72
XFE_RC_2185_0 MXL2HS $PINS OB=DIFF[22] S=carry[22] A=FE_RN_1497_0
+ B=FE_RN_1494_0
XFE_RC_2184_0 INV1S $PINS O=FE_RN_1498_0 I=n72
XFE_RC_2183_0 INV1S $PINS O=FE_RN_1499_0 I=A[22]
XFE_RC_2182_0 OR2 $PINS O=FE_RN_1500_0 I1=n72 I2=A[22]
XFE_RC_2181_0 ND2 $PINS O=FE_RN_1501_0 I1=FE_RN_1500_0 I2=carry[22]
XFE_RC_1925_0 ND2S $PINS O=FE_RN_1298_0 I1=A[26] I2=n76
XFE_RC_1924_0 AN2 $PINS O=FE_RN_1299_0 I1=FE_RN_1302_0 I2=FE_RN_1298_0
XFE_RC_1923_0 XNR2HS $PINS O=FE_RN_1300_0 I1=n76 I2=A[26]
XFE_RC_1922_0 MXL2HS $PINS OB=DIFF[26] S=carry[26] A=FE_RN_1300_0
+ B=FE_RN_1299_0
XFE_RC_1921_0 ND2S $PINS O=FE_RN_1301_0 I1=A[26] I2=n76
XFE_RC_1920_0 OR2 $PINS O=FE_RN_1302_0 I1=n76 I2=A[26]
XFE_RC_1919_0 ND2 $PINS O=FE_RN_1303_0 I1=FE_RN_1302_0 I2=carry[26]
XFE_RC_1918_0 ND2P $PINS O=carry[27] I1=FE_RN_1303_0 I2=FE_RN_1301_0
XFE_RC_1684_0 ND2 $PINS O=FE_RN_1116_0 I1=A[19] I2=n69
XFE_RC_1683_0 AN2 $PINS O=FE_RN_1117_0 I1=FE_RN_1120_0 I2=FE_RN_1116_0
XFE_RC_1682_0 XNR2HS $PINS O=FE_RN_1118_0 I1=n69 I2=A[19]
XFE_RC_1681_0 MXL2HS $PINS OB=DIFF[19] S=carry[19] A=FE_RN_1118_0
+ B=FE_RN_1117_0
XFE_RC_1680_0 ND2 $PINS O=FE_RN_1119_0 I1=A[19] I2=n69
XFE_RC_1679_0 OR2S $PINS O=FE_RN_1120_0 I1=n69 I2=A[19]
XFE_RC_1678_0 ND2 $PINS O=FE_RN_1121_0 I1=FE_RN_1120_0 I2=carry[19]
XFE_RC_1677_0 ND2P $PINS O=carry[20] I1=FE_RN_1121_0 I2=FE_RN_1119_0
XFE_RC_1477_0 ND2S $PINS O=FE_RN_963_0 I1=A[20] I2=n70
XFE_RC_1476_0 AN2 $PINS O=FE_RN_964_0 I1=FE_RN_967_0 I2=FE_RN_963_0
XFE_RC_1475_0 XNR2HS $PINS O=FE_RN_965_0 I1=n70 I2=A[20]
XFE_RC_1474_0 MXL2HS $PINS OB=DIFF[20] S=carry[20] A=FE_RN_965_0 B=FE_RN_964_0
XFE_RC_1473_0 ND2S $PINS O=FE_RN_966_0 I1=A[20] I2=n70
XFE_RC_1472_0 OR2 $PINS O=FE_RN_967_0 I1=n70 I2=A[20]
XFE_RC_1471_0 ND2 $PINS O=FE_RN_968_0 I1=FE_RN_967_0 I2=carry[20]
XFE_RC_1470_0 ND2P $PINS O=carry[21] I1=FE_RN_968_0 I2=FE_RN_966_0
XFE_RC_1255_0 ND2S $PINS O=FE_RN_801_0 I1=A[23] I2=n73
XFE_RC_1254_0 AN2 $PINS O=FE_RN_802_0 I1=FE_RN_805_0 I2=FE_RN_801_0
XFE_RC_1253_0 XNR2HS $PINS O=FE_RN_803_0 I1=n73 I2=A[23]
XFE_RC_1252_0 MXL2HS $PINS OB=DIFF[23] S=carry[23] A=FE_RN_803_0 B=FE_RN_802_0
XFE_RC_1251_0 ND2S $PINS O=FE_RN_804_0 I1=A[23] I2=n73
XFE_RC_1250_0 OR2S $PINS O=FE_RN_805_0 I1=n73 I2=A[23]
XFE_RC_1249_0 ND2 $PINS O=FE_RN_806_0 I1=FE_RN_805_0 I2=carry[23]
XFE_RC_1248_0 ND2P $PINS O=carry[24] I1=FE_RN_806_0 I2=FE_RN_804_0
XFE_RC_1036_0 AN2 $PINS O=FE_RN_645_0 I1=A[3] I2=n53
XFE_RC_1035_0 AN2B1S $PINS O=FE_RN_646_0 I1=FE_RN_649_0 B1=FE_RN_645_0
XFE_RC_1034_0 XNR2HS $PINS O=FE_RN_647_0 I1=n53 I2=A[3]
XFE_RC_1033_0 MXL2HS $PINS OB=DIFF[3] S=carry[3] A=FE_RN_647_0 B=FE_RN_646_0
XFE_RC_1032_0 ND2 $PINS O=FE_RN_648_0 I1=A[3] I2=n53
XFE_RC_1031_0 OR2 $PINS O=FE_RN_649_0 I1=n53 I2=A[3]
XFE_RC_1030_0 ND2 $PINS O=FE_RN_650_0 I1=FE_RN_649_0 I2=carry[3]
XFE_RC_1029_0 ND2 $PINS O=carry[4] I1=FE_RN_650_0 I2=FE_RN_648_0
XFE_RC_798_0 INV1S $PINS O=FE_RN_467_0 I=FE_RN_471_0
XFE_RC_797_0 AOI12HS $PINS O=FE_RN_468_0 A1=FE_RN_467_0 B1=A[9] B2=B[9]
XFE_RC_796_0 XNR2HS $PINS O=FE_RN_469_0 I1=B[9] I2=A[9]
XFE_RC_795_0 MXL2HS $PINS OB=DIFF[9] S=carry[9] A=FE_RN_469_0 B=FE_RN_468_0
XFE_RC_794_0 ND2 $PINS O=FE_RN_470_0 I1=A[9] I2=B[9]
XFE_RC_793_0 OR2 $PINS O=FE_RN_471_0 I1=B[9] I2=A[9]
XFE_RC_792_0 ND2 $PINS O=FE_RN_472_0 I1=FE_RN_471_0 I2=carry[9]
XFE_RC_791_0 ND2P $PINS O=carry[10] I1=FE_RN_472_0 I2=FE_RN_470_0
XFE_RC_580_0 ND3P $PINS O=carry[25] I1=n8 I2=n7 I3=n9
XFE_RC_579_0 ND2 $PINS O=FE_RN_311_0 I1=A[10] I2=n60
XFE_RC_578_0 AN2 $PINS O=FE_RN_312_0 I1=FE_RN_315_0 I2=FE_RN_311_0
XFE_RC_577_0 XNR2HS $PINS O=FE_RN_313_0 I1=n60 I2=A[10]
XFE_RC_576_0 MXL2HS $PINS OB=DIFF[10] S=carry[10] A=FE_RN_313_0 B=FE_RN_312_0
XFE_RC_575_0 ND2 $PINS O=FE_RN_314_0 I1=A[10] I2=n60
XFE_RC_574_0 OR2 $PINS O=FE_RN_315_0 I1=n60 I2=A[10]
XFE_RC_573_0 ND2 $PINS O=FE_RN_316_0 I1=FE_RN_315_0 I2=carry[10]
XFE_RC_572_0 ND2P $PINS O=carry[11] I1=FE_RN_316_0 I2=FE_RN_314_0
XFE_RC_374_0 INV1S $PINS O=FE_RN_170_0 I=FE_RN_174_0
XFE_RC_373_0 AOI12HS $PINS O=FE_RN_171_0 A1=FE_RN_170_0 B1=A[7] B2=n57
XFE_RC_372_0 XNR2HS $PINS O=FE_RN_172_0 I1=n57 I2=A[7]
XFE_RC_371_0 MXL2HS $PINS OB=DIFF[7] S=carry[7] A=FE_RN_172_0 B=FE_RN_171_0
XFE_RC_370_0 ND2S $PINS O=FE_RN_173_0 I1=A[7] I2=n57
XFE_RC_369_0 OR2 $PINS O=FE_RN_174_0 I1=n57 I2=A[7]
XFE_RC_368_0 ND2 $PINS O=FE_RN_175_0 I1=FE_RN_174_0 I2=carry[7]
XFE_RC_367_0 ND2P $PINS O=carry[8] I1=FE_RN_175_0 I2=FE_RN_173_0
XFE_RC_348_0 ND3P $PINS O=carry[13] I1=n32 I2=n33 I3=n31
XFE_RC_319_0 ND3P $PINS O=carry[6] I1=n43 I2=n44 I3=n42
XFE_RC_317_0 ND3P $PINS O=carry[9] I1=n28 I2=n29 I3=n30
XFE_RC_316_0 ND3P $PINS O=carry[12] I1=n14 I2=n13 I3=n15
XFE_RC_193_0 INV1S $PINS O=FE_RN_69_0 I=n23
XFE_RC_192_0 ND3P $PINS O=carry[14] I1=n35 I2=n36 I3=FE_RN_69_0
XFE_RC_184_0 ND3 $PINS O=carry[7] I1=n48 I2=n47 I3=n46
XFE_RC_137_0 ND3P $PINS O=carry[15] I1=n1 I2=n2 I3=n3
XFE_OFC277_raw_prime_3 INV1S $PINS O=n53 I=B[3]
XFE_OFC270_n310 INV1S $PINS O=n50 I=B[0]
XFE_OFC217_raw_prime_5 INV1S $PINS O=n55 I=B[5]
XFE_OFC168_raw_prime_7 INV1S $PINS O=n57 I=B[7]
XFE_OFC145_raw_prime_6 INV1S $PINS O=n56 I=B[6]
XFE_OFC130_raw_prime_2 INV1S $PINS O=n52 I=B[2]
XFE_OFC110_n312 INV1S $PINS O=n51 I=B[1]
XFE_OFC95_raw_prime_4 INV1S $PINS O=n54 I=B[4]
XU2_18 FA1 $PINS S=DIFF[18] CO=carry[19] A=A[18] B=n68 CI=carry[18]
XU2_16 FA1 $PINS S=DIFF[16] CO=carry[17] A=A[16] B=n66 CI=carry[16]
XU2_2 FA1 $PINS S=DIFF[2] CO=carry[3] A=A[2] B=n52 CI=carry[2]
XU2_17 FA1 $PINS S=DIFF[17] CO=carry[18] A=A[17] B=n67 CI=carry[17]
XU2_1 FA1 $PINS S=DIFF[1] CO=carry[2] A=A[1] B=n51 CI=n50
XU2_15 FA1 $PINS S=DIFF[15] CO=carry[16] A=A[15] B=n65 CI=carry[15]
XU2 XOR3 $PINS O=DIFF[5] I1=A[5] I2=n55 I3=carry[5]
XU3 ND3P $PINS O=carry[5] I1=n10 I2=n11 I3=n12
XU4 XOR3 $PINS O=DIFF[12] I1=A[12] I2=n62 I3=carry[12]
XU7 ND3P $PINS O=carry[22] I1=n4 I2=n5 I3=n6
XU9 XOR3 $PINS O=DIFF[14] I1=n64 I2=A[14] I3=carry[14]
XU10 ND2 $PINS O=n1 I1=carry[14] I2=n64
XU11 ND2 $PINS O=n2 I1=carry[14] I2=A[14]
XU12 ND2 $PINS O=n3 I1=n64 I2=A[14]
XU15 ND3P $PINS O=carry[30] I1=n25 I2=n26 I3=n27
XU17 ND2 $PINS O=n31 I1=A[12] I2=n62
XU18 ND2 $PINS O=n16 I1=A[27] I2=n77
XU19 INV1S $PINS O=n80 I=B[30]
XU20 INV1S $PINS O=n61 I=B[11]
XU21 INV1S $PINS O=n71 I=B[21]
XU22 ND2 $PINS O=n38 I1=carry[30] I2=n80
XU23 ND2 $PINS O=n39 I1=carry[30] I2=A[30]
XU24 XOR3 $PINS O=DIFF[4] I1=n54 I2=A[4] I3=carry[4]
XU26 XOR3 $PINS O=DIFF[8] I1=B[8] I2=A[8] I3=carry[8]
XU29 XOR3 $PINS O=DIFF[11] I1=n61 I2=A[11] I3=carry[11]
XU30 XOR3 $PINS O=DIFF[21] I1=n71 I2=A[21] I3=carry[21]
XU31 XOR3 $PINS O=DIFF[27] I1=A[27] I2=n77 I3=carry[27]
XU33 ND2 $PINS O=n4 I1=carry[21] I2=n71
XU34 ND2 $PINS O=n5 I1=carry[21] I2=A[21]
XU35 ND2S $PINS O=n6 I1=n71 I2=A[21]
XU36 XOR3 $PINS O=DIFF[24] I1=n74 I2=A[24] I3=carry[24]
XU37 ND2 $PINS O=n7 I1=carry[24] I2=n74
XU38 ND2 $PINS O=n8 I1=carry[24] I2=A[24]
XU39 ND2 $PINS O=n9 I1=n74 I2=A[24]
XU40 ND2 $PINS O=n10 I1=carry[4] I2=n54
XU41 ND2 $PINS O=n11 I1=carry[4] I2=A[4]
XU42 ND2S $PINS O=n12 I1=n54 I2=A[4]
XU43 ND2 $PINS O=n13 I1=carry[11] I2=n61
XU44 ND2 $PINS O=n14 I1=carry[11] I2=A[11]
XU45 ND2S $PINS O=n15 I1=n61 I2=A[11]
XU46 ND2 $PINS O=n17 I1=A[27] I2=carry[27]
XU47 ND2 $PINS O=n18 I1=n77 I2=carry[27]
XU49 XOR2HS $PINS O=n19 I1=A[28] I2=n78
XU50 XOR2HS $PINS O=DIFF[28] I1=n19 I2=carry[28]
XU51 ND2S $PINS O=n20 I1=A[28] I2=n78
XU52 ND2 $PINS O=n21 I1=A[28] I2=carry[28]
XU53 ND2 $PINS O=n22 I1=n78 I2=carry[28]
XU55 AN2 $PINS O=n23 I1=A[13] I2=n63
XU56 XOR2HS $PINS O=n24 I1=n79 I2=A[29]
XU57 XOR2HS $PINS O=DIFF[29] I1=carry[29] I2=n24
XU58 ND2 $PINS O=n25 I1=carry[29] I2=n79
XU59 ND2 $PINS O=n26 I1=carry[29] I2=A[29]
XU60 ND2 $PINS O=n27 I1=n79 I2=A[29]
XU61 ND2 $PINS O=n28 I1=carry[8] I2=B[8]
XU62 ND2 $PINS O=n29 I1=carry[8] I2=A[8]
XU63 ND2S $PINS O=n30 I1=B[8] I2=A[8]
XU64 ND2 $PINS O=n32 I1=A[12] I2=carry[12]
XU65 ND2 $PINS O=n33 I1=n62 I2=carry[12]
XU66 XOR2HS $PINS O=n34 I1=A[13] I2=n63
XU67 XOR2HS $PINS O=DIFF[13] I1=n34 I2=carry[13]
XU68 ND2 $PINS O=n35 I1=A[13] I2=carry[13]
XU69 ND2 $PINS O=n36 I1=n63 I2=carry[13]
XU70 XOR2HS $PINS O=n37 I1=n80 I2=A[30]
XU71 XOR2HS $PINS O=DIFF[30] I1=carry[30] I2=n37
XU72 ND2S $PINS O=n40 I1=n80 I2=A[30]
XU73 ND3 $PINS O=carry[31] I1=n39 I2=n38 I3=n40
XU75 XNR2HS $PINS O=n41 I1=n81 I2=A[31]
XU76 ND2 $PINS O=n42 I1=A[5] I2=n55
XU77 ND2 $PINS O=n43 I1=A[5] I2=carry[5]
XU78 ND2 $PINS O=n44 I1=n55 I2=carry[5]
XU80 XOR2HS $PINS O=n45 I1=A[6] I2=n56
XU81 XOR2HS $PINS O=DIFF[6] I1=n45 I2=carry[6]
XU82 ND2S $PINS O=n46 I1=A[6] I2=n56
XU83 ND2 $PINS O=n47 I1=A[6] I2=carry[6]
XU84 ND2 $PINS O=n48 I1=n56 I2=carry[6]
XU85 INV1S $PINS O=DIFF[0] I=n50
XU86 INV1S $PINS O=n63 I=B[13]
XU87 INV1S $PINS O=n79 I=B[29]
XU88 INV1S $PINS O=n67 I=B[17]
XU89 INV1S $PINS O=n73 I=B[23]
XU90 INV1S $PINS O=n69 I=B[19]
XU91 INV1S $PINS O=n65 I=B[15]
XU92 INV1S $PINS O=n77 I=B[27]
XU93 INV1S $PINS O=n75 I=B[25]
XU97 INV1S $PINS O=n78 I=B[28]
XU98 INV1S $PINS O=n76 I=B[26]
XU99 INV1S $PINS O=n74 I=B[24]
XU100 INV1S $PINS O=n72 I=B[22]
XU101 INV1S $PINS O=n70 I=B[20]
XU102 INV1S $PINS O=n68 I=B[18]
XU103 INV1S $PINS O=n66 I=B[16]
XU104 INV1S $PINS O=n64 I=B[14]
XU105 INV1S $PINS O=n62 I=B[12]
XU106 INV1S $PINS O=n60 I=B[10]
XU109 INV1S $PINS O=n81 I=B[31]
.ENDS

.SUBCKT Domain_Transfer_1_DW_cmp_1 A[32] A[31] A[30] A[29] A[28] A[27] A[26]
+ A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13]
+ A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[32]
+ B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19]
+ B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6]
+ B[5] B[4] B[3] B[2] B[1] B[0] TC GE_LT GE_GT_EQ GE_LT_GT_LE EQ_NE
+ FE_OFN267_FE_OFN32_raw_prime_30
XFE_RC_2403_0 AO12 $PINS O=n277 A1=n286 B1=n285 B2=n287
XU158 INV1S $PINS O=n241 I=B[18]
XU159 INV1S $PINS O=n256 I=n316
XU160 INV1S $PINS O=n261 I=n295
XU161 INV1S $PINS O=n253 I=n314
XU162 OR2 $PINS O=n340 I1=n338 I2=n229
XU163 AO22S $PINS O=n229 A1=B[1] A2=A[1] B1=B[0] B2=n341
XU164 INV1S $PINS O=n247 I=B[29]
XU165 INV1S $PINS O=n238 I=B[13]
XU166 INV1S $PINS O=n234 I=B[5]
XU167 INV1S $PINS O=n233 I=B[3]
XU168 INV1S $PINS O=n235 I=B[7]
XU169 INV1S $PINS O=n239 I=B[15]
XU170 INV1S $PINS O=n248 I=B[31]
XU171 INV1S $PINS O=n237 I=B[11]
XU172 INV1S $PINS O=n236 I=B[9]
XU173 INV1S $PINS O=n245 I=B[25]
XU174 INV1S $PINS O=n246 I=B[27]
XU175 INV1S $PINS O=n244 I=B[23]
XU176 INV1S $PINS O=n242 I=B[19]
XU177 INV1S $PINS O=n243 I=B[21]
XU178 INV1S $PINS O=n240 I=B[17]
XU179 MAOI1 $PINS O=n321 A1=B[14] A2=n230 B1=A[15] B2=n239
XU180 AN2 $PINS O=n230 I1=n324 I2=A[14]
XU181 MAOI1 $PINS O=n304 A1=B[22] A2=n231 B1=A[23] B2=n244
XU182 AN2 $PINS O=n231 I1=n307 I2=A[22]
XU183 MAOI1 $PINS O=n281 A1=B[30] A2=n232 B1=A[31] B2=n248
XU184 AN2 $PINS O=n232 I1=n284 I2=A[30]
XU201 OR2 $PINS O=GE_LT_GT_LE I1=A[32] I2=n268
XU202 AOI13HS $PINS O=n268 A1=n272 B1=n269 B2=n270 B3=n271
XU203 AOI22S $PINS O=n272 A1=n273 A2=n274 B1=n274 B2=n275
XU204 AOI22S $PINS O=n274 A1=n276 A2=n277 B1=n278 B2=n279
XU205 OAI112HS $PINS O=n279 A1=n280 B1=n281 C1=A[29] C2=n247
XU206 ND3 $PINS O=n280 I1=n282 I2=A[28] I3=B[28]
XU207 OR2B1S $PINS O=n278 I1=n283 B1=n281
XU209 MOAI1S $PINS O=n287 A1=A[25] A2=n245 B1=B[24] B2=n288
XU210 AN2 $PINS O=n288 I1=n289 I2=A[24]
XU211 MOAI1S $PINS O=n286 A1=A[27] A2=n246 B1=B[26] B2=n290
XU212 AN2 $PINS O=n290 I1=n291 I2=A[26]
XU213 AOI22S $PINS O=n273 A1=n292 A2=n293 B1=n294 B2=n261
XU214 AOI22S $PINS O=n294 A1=n296 A2=n297 B1=n297 B2=n298
XU215 OA22 $PINS O=n297 A1=A[19] A2=n242 B1=n241 B2=n299
XU216 ND2 $PINS O=n299 I1=n300 I2=A[18]
XU217 AOI13HS $PINS O=n296 A1=n302 B1=n301 B2=A[16] B3=B[16]
XU218 NR2 $PINS O=n302 I1=A[17] I2=n240
XU219 OAI112HS $PINS O=n293 A1=n303 B1=n304 C1=A[21] C2=n243
XU220 ND3 $PINS O=n303 I1=n305 I2=A[20] I3=B[20]
XU221 OR2B1S $PINS O=n292 I1=n306 B1=n304
XU222 NR3 $PINS O=n271 I1=n298 I2=n295 I3=n275
XU223 ND3 $PINS O=n275 I1=n285 I2=n276 I3=n308
XU224 OA12 $PINS O=n308 A1=n289 B1=B[24] B2=A[24]
XU225 ND2 $PINS O=n289 I1=A[25] I2=n245
XU226 OA112 $PINS O=n276 A1=n282 B1=n283 C1=B[28] C2=A[28]
XU227 OA12 $PINS O=n283 A1=n284 B1=FE_OFN267_FE_OFN32_raw_prime_30 B2=A[30]
XU228 ND2 $PINS O=n284 I1=A[31] I2=n248
XU229 ND2 $PINS O=n282 I1=A[29] I2=n247
XU230 OA12 $PINS O=n285 A1=n291 B1=B[26] B2=A[26]
XU231 ND2 $PINS O=n291 I1=A[27] I2=n246
XU232 OAI112HS $PINS O=n295 A1=n305 B1=n306 C1=B[20] C2=A[20]
XU233 OA12 $PINS O=n306 A1=n307 B1=B[22] B2=A[22]
XU234 ND2 $PINS O=n307 I1=A[23] I2=n244
XU235 ND2 $PINS O=n305 I1=A[21] I2=n243
XU236 OAI12HS $PINS O=n298 A1=n300 B1=B[18] B2=A[18]
XU237 ND2 $PINS O=n300 I1=A[19] I2=n242
XU238 OA12 $PINS O=n270 A1=n301 B1=B[16] B2=A[16]
XU239 ND2 $PINS O=n301 I1=A[17] I2=n240
XU240 AOI13HS $PINS O=n269 A1=n311 B1=n309 B2=n310 B3=n253
XU241 AOI13HS $PINS O=n311 A1=n314 B1=n312 B2=n256 B3=n313
XU242 OA12 $PINS O=n313 A1=n315 B1=B[8] B2=A[8]
XU243 MOAI1S $PINS O=n314 A1=n316 A2=n317 B1=n318 B2=n319
XU244 OAI112HS $PINS O=n319 A1=n320 B1=n321 C1=A[13] C2=n238
XU245 ND3 $PINS O=n320 I1=n322 I2=A[12] I3=B[12]
XU246 OR2B1S $PINS O=n318 I1=n323 B1=n321
XU247 OAI22S $PINS O=n317 A1=n312 A2=n325 B1=n325 B2=n326
XU248 MOAI1S $PINS O=n326 A1=A[9] A2=n236 B1=B[8] B2=n327
XU249 AN2 $PINS O=n327 I1=n315 I2=A[8]
XU250 ND2 $PINS O=n315 I1=A[9] I2=n236
XU251 MOAI1S $PINS O=n325 A1=A[11] A2=n237 B1=B[10] B2=n328
XU252 AN2 $PINS O=n328 I1=n329 I2=A[10]
XU253 OA12 $PINS O=n312 A1=n329 B1=B[10] B2=A[10]
XU254 ND2 $PINS O=n329 I1=A[11] I2=n237
XU255 OAI112HS $PINS O=n316 A1=n322 B1=n323 C1=B[12] C2=A[12]
XU256 OA12 $PINS O=n323 A1=n324 B1=B[14] B2=A[14]
XU257 ND2 $PINS O=n324 I1=A[15] I2=n239
XU258 ND2 $PINS O=n322 I1=A[13] I2=n238
XU259 OAI22S $PINS O=n310 A1=n330 A2=n331 B1=n331 B2=n332
XU260 MOAI1S $PINS O=n332 A1=A[5] A2=n234 B1=B[4] B2=n333
XU261 AN2 $PINS O=n333 I1=n334 I2=A[4]
XU262 MOAI1S $PINS O=n331 A1=A[7] A2=n235 B1=B[6] B2=n335
XU263 AN2 $PINS O=n335 I1=n336 I2=A[6]
XU264 OAI112HS $PINS O=n309 A1=n330 B1=n339 C1=n337 C2=n338
XU265 OA112 $PINS O=n339 A1=n334 B1=n340 C1=B[4] C2=A[4]
XU266 OR2 $PINS O=n341 I1=A[1] I2=B[1]
XU267 ND2 $PINS O=n334 I1=A[5] I2=n234
XU268 OA12 $PINS O=n330 A1=n336 B1=B[6] B2=A[6]
XU269 ND2 $PINS O=n336 I1=A[7] I2=n235
XU270 MOAI1S $PINS O=n338 A1=A[3] A2=n233 B1=B[2] B2=n342
XU271 AN2 $PINS O=n342 I1=n343 I2=A[2]
XU272 OA12 $PINS O=n337 A1=n343 B1=B[2] B2=A[2]
XU273 ND2 $PINS O=n343 I1=A[3] I2=n233
.ENDS

.SUBCKT Domain_Transfer_1_DW01_sub_2 A[31] A[30] A[29] A[28] A[27] A[26] A[25]
+ A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12]
+ A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] CI DIFF[31] DIFF[30] DIFF[29] DIFF[28] DIFF[27] DIFF[26]
+ DIFF[25] DIFF[24] DIFF[23] DIFF[22] DIFF[21] DIFF[20] DIFF[19] DIFF[18]
+ DIFF[17] DIFF[16] DIFF[15] DIFF[14] DIFF[13] DIFF[12] DIFF[11] DIFF[10]
+ DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3] DIFF[2] DIFF[1]
+ DIFF[0] CO
XFE_OCPC655_carry_22 BUF1S $PINS O=FE_OCPN655_carry_22 I=carry[22]
XFE_OFC638_FE_OFN59_raw_prime_3 INV1S $PINS O=n42 I=B[3]
XFE_OFC628_FE_OFN87_n312 INV1S $PINS O=n40 I=B[1]
XFE_OFC616_n310 INV1S $PINS O=n39 I=B[0]
XFE_RC_2284_0 ND3 $PINS O=carry[6] I1=n1 I2=n2 I3=n3
XFE_RC_2270_0 XOR2HS $PINS O=DIFF[31] I1=n37 I2=carry[31]
XFE_RC_2191_0 MOAI1 $PINS O=carry[26] A1=FE_RN_870_0 A2=FE_RN_867_0 B1=A[25]
+ B2=n64
XFE_RC_2179_0 INV1S $PINS O=FE_RN_1483_0 I=FE_RN_1491_0
XFE_RC_2178_0 AOI12HS $PINS O=FE_RN_1484_0 A1=FE_RN_1483_0 B1=A[22] B2=n61
XFE_RC_2177_0 INV1S $PINS O=FE_RN_1485_0 I=n61
XFE_RC_2176_0 INV1S $PINS O=FE_RN_1486_0 I=A[22]
XFE_RC_2175_0 AOI22S $PINS O=FE_RN_1487_0 A1=FE_RN_1486_0 A2=n61 B1=A[22]
+ B2=FE_RN_1485_0
XFE_RC_2174_0 MXL2HS $PINS OB=DIFF[22] S=FE_OCPN655_carry_22 A=FE_RN_1487_0
+ B=FE_RN_1484_0
XFE_RC_2173_0 ND2 $PINS O=FE_RN_1488_0 I1=A[22] I2=n61
XFE_RC_2171_0 INV1S $PINS O=FE_RN_1490_0 I=A[22]
XFE_RC_2170_0 ND2S $PINS O=FE_RN_1491_0 I1=FE_RN_1490_0 I2=FE_RN_1485_0
XFE_RC_2169_0 ND2 $PINS O=FE_RN_1492_0 I1=FE_RN_1491_0 I2=carry[22]
XFE_RC_2168_0 ND2P $PINS O=carry[23] I1=FE_RN_1492_0 I2=FE_RN_1488_0
XFE_RC_1962_0 ND2S $PINS O=FE_RN_1325_0 I1=A[23] I2=n62
XFE_RC_1961_0 AN2 $PINS O=FE_RN_1326_0 I1=FE_RN_1329_0 I2=FE_RN_1325_0
XFE_RC_1960_0 XNR2HS $PINS O=FE_RN_1327_0 I1=n62 I2=A[23]
XFE_RC_1959_0 MXL2HS $PINS OB=DIFF[23] S=carry[23] A=FE_RN_1327_0
+ B=FE_RN_1326_0
XFE_RC_1958_0 ND2S $PINS O=FE_RN_1328_0 I1=A[23] I2=n62
XFE_RC_1957_0 OR2 $PINS O=FE_RN_1329_0 I1=n62 I2=A[23]
XFE_RC_1956_0 ND2 $PINS O=FE_RN_1330_0 I1=FE_RN_1329_0 I2=carry[23]
XFE_RC_1955_0 ND2P $PINS O=carry[24] I1=FE_RN_1330_0 I2=FE_RN_1328_0
XFE_RC_1797_0 ND2S $PINS O=FE_RN_1201_0 I1=A[24] I2=n63
XFE_RC_1796_0 AN2 $PINS O=FE_RN_1202_0 I1=FE_RN_1205_0 I2=FE_RN_1201_0
XFE_RC_1795_0 XNR2HS $PINS O=FE_RN_1203_0 I1=n63 I2=A[24]
XFE_RC_1794_0 MXL2HS $PINS OB=DIFF[24] S=carry[24] A=FE_RN_1203_0
+ B=FE_RN_1202_0
XFE_RC_1793_0 ND2S $PINS O=FE_RN_1204_0 I1=A[24] I2=n63
XFE_RC_1792_0 OR2S $PINS O=FE_RN_1205_0 I1=n63 I2=A[24]
XFE_RC_1791_0 ND2 $PINS O=FE_RN_1206_0 I1=FE_RN_1205_0 I2=carry[24]
XFE_RC_1790_0 ND2P $PINS O=carry[25] I1=FE_RN_1206_0 I2=FE_RN_1204_0
XFE_RC_1755_0 MOAI1 $PINS O=carry[22] A1=FE_RN_1012_0 A2=FE_RN_1009_0 B1=n60
+ B2=A[21]
XFE_RC_1535_0 INV1S $PINS O=FE_RN_1009_0 I=FE_RN_1013_0
XFE_RC_1534_0 AOI12HS $PINS O=FE_RN_1010_0 A1=FE_RN_1009_0 B1=A[21] B2=n60
XFE_RC_1533_0 XNR2HS $PINS O=FE_RN_1011_0 I1=n60 I2=A[21]
XFE_RC_1532_0 MXL2HS $PINS OB=DIFF[21] S=carry[21] A=FE_RN_1011_0
+ B=FE_RN_1010_0
XFE_RC_1531_0 INV1S $PINS O=FE_RN_1012_0 I=carry[21]
XFE_RC_1530_0 OR2 $PINS O=FE_RN_1013_0 I1=n60 I2=A[21]
XFE_RC_1349_0 INV1S $PINS O=FE_RN_867_0 I=FE_RN_871_0
XFE_RC_1348_0 AOI12HS $PINS O=FE_RN_868_0 A1=FE_RN_867_0 B1=A[25] B2=n64
XFE_RC_1347_0 XNR2HS $PINS O=FE_RN_869_0 I1=n64 I2=A[25]
XFE_RC_1346_0 MXL2HS $PINS OB=DIFF[25] S=carry[25] A=FE_RN_869_0 B=FE_RN_868_0
XFE_RC_1345_0 INV1S $PINS O=FE_RN_870_0 I=carry[25]
XFE_RC_1344_0 OR2 $PINS O=FE_RN_871_0 I1=n64 I2=A[25]
XFE_RC_1294_0 MOAI1 $PINS O=carry[4] A1=FE_RN_715_0 A2=FE_RN_717_0 B1=n42
+ B2=A[3]
XFE_RC_1128_0 ND3P $PINS O=carry[9] I1=n22 I2=n23 I3=n21
XFE_RC_1127_0 AN2 $PINS O=FE_RN_712_0 I1=A[3] I2=n42
XFE_RC_1126_0 AN2B1S $PINS O=FE_RN_713_0 I1=FE_RN_716_0 B1=FE_RN_712_0
XFE_RC_1125_0 XNR2HS $PINS O=FE_RN_714_0 I1=n42 I2=A[3]
XFE_RC_1124_0 MXL2HS $PINS OB=DIFF[3] S=carry[3] A=FE_RN_714_0 B=FE_RN_713_0
XFE_RC_1123_0 INV1S $PINS O=FE_RN_715_0 I=carry[3]
XFE_RC_1122_0 OR2 $PINS O=FE_RN_716_0 I1=n42 I2=A[3]
XFE_RC_1121_0 INV1S $PINS O=FE_RN_717_0 I=FE_RN_716_0
XFE_RC_1012_0 XNR2HS $PINS O=FE_RN_626_0 I1=n48 I2=A[9]
XFE_RC_1011_0 ND2S $PINS O=FE_RN_627_0 I1=A[9] I2=n48
XFE_RC_1010_0 ND2S $PINS O=FE_RN_628_0 I1=FE_RN_631_0 I2=FE_RN_627_0
XFE_RC_1009_0 ND2 $PINS O=FE_RN_629_0 I1=carry[9] I2=FE_RN_628_0
XFE_RC_1008_0 OAI12HS $PINS O=DIFF[9] A1=FE_RN_629_0 B1=carry[9] B2=FE_RN_626_0
XFE_RC_1007_0 ND2S $PINS O=FE_RN_630_0 I1=A[9] I2=n48
XFE_RC_1006_0 OR2 $PINS O=FE_RN_631_0 I1=n48 I2=A[9]
XFE_RC_1005_0 ND2 $PINS O=FE_RN_632_0 I1=FE_RN_631_0 I2=carry[9]
XFE_RC_1004_0 ND2P $PINS O=carry[10] I1=FE_RN_632_0 I2=FE_RN_630_0
XFE_RC_807_0 AN2 $PINS O=FE_RN_473_0 I1=A[4] I2=n43
XFE_RC_806_0 AN2B1S $PINS O=FE_RN_474_0 I1=FE_RN_477_0 B1=FE_RN_473_0
XFE_RC_805_0 XNR2HS $PINS O=FE_RN_475_0 I1=n43 I2=A[4]
XFE_RC_804_0 MXL2HS $PINS OB=DIFF[4] S=carry[4] A=FE_RN_475_0 B=FE_RN_474_0
XFE_RC_803_0 ND2S $PINS O=FE_RN_476_0 I1=A[4] I2=n43
XFE_RC_802_0 OR2 $PINS O=FE_RN_477_0 I1=n43 I2=A[4]
XFE_RC_801_0 ND2 $PINS O=FE_RN_478_0 I1=FE_RN_477_0 I2=carry[4]
XFE_RC_800_0 ND2P $PINS O=carry[5] I1=FE_RN_478_0 I2=FE_RN_476_0
XFE_RC_799_0 MOAI1 $PINS O=carry[27] A1=FE_RN_372_0 A2=FE_RN_369_0 B1=n65
+ B2=A[26]
XFE_RC_659_0 INV1S $PINS O=FE_RN_369_0 I=FE_RN_373_0
XFE_RC_658_0 AOI12HS $PINS O=FE_RN_370_0 A1=FE_RN_369_0 B1=A[26] B2=n65
XFE_RC_657_0 XNR2HS $PINS O=FE_RN_371_0 I1=n65 I2=A[26]
XFE_RC_656_0 MXL2HS $PINS OB=DIFF[26] S=carry[26] A=FE_RN_371_0 B=FE_RN_370_0
XFE_RC_655_0 INV1S $PINS O=FE_RN_372_0 I=carry[26]
XFE_RC_654_0 OR2 $PINS O=FE_RN_373_0 I1=n65 I2=A[26]
XFE_RC_449_0 ND2S $PINS O=FE_RN_220_0 I1=A[10] I2=n49
XFE_RC_448_0 AN2 $PINS O=FE_RN_221_0 I1=FE_RN_224_0 I2=FE_RN_220_0
XFE_RC_447_0 XNR2HS $PINS O=FE_RN_222_0 I1=n49 I2=A[10]
XFE_RC_446_0 MXL2HS $PINS OB=DIFF[10] S=carry[10] A=FE_RN_222_0 B=FE_RN_221_0
XFE_RC_445_0 ND2S $PINS O=FE_RN_223_0 I1=A[10] I2=n49
XFE_RC_444_0 OR2 $PINS O=FE_RN_224_0 I1=n49 I2=A[10]
XFE_RC_443_0 ND2 $PINS O=FE_RN_225_0 I1=FE_RN_224_0 I2=carry[10]
XFE_RC_442_0 ND2P $PINS O=carry[11] I1=FE_RN_225_0 I2=FE_RN_223_0
XFE_RC_249_0 ND2S $PINS O=FE_RN_98_0 I1=A[11] I2=n50
XFE_RC_248_0 AN2 $PINS O=FE_RN_99_0 I1=FE_RN_102_0 I2=FE_RN_98_0
XFE_RC_247_0 XNR2HS $PINS O=FE_RN_100_0 I1=n50 I2=A[11]
XFE_RC_246_0 MXL2HS $PINS OB=DIFF[11] S=carry[11] A=FE_RN_100_0 B=FE_RN_99_0
XFE_RC_245_0 ND2S $PINS O=FE_RN_101_0 I1=A[11] I2=n50
XFE_RC_244_0 OR2S $PINS O=FE_RN_102_0 I1=n50 I2=A[11]
XFE_RC_243_0 ND2 $PINS O=FE_RN_103_0 I1=FE_RN_102_0 I2=carry[11]
XFE_RC_242_0 ND2P $PINS O=carry[12] I1=FE_RN_103_0 I2=FE_RN_101_0
XFE_RC_195_0 ND3P $PINS O=carry[13] I1=n31 I2=n32 I3=n33
XFE_RC_194_0 ND3P $PINS O=carry[8] I1=n19 I2=n18 I3=n17
XFE_RC_186_0 ND3P $PINS O=carry[15] I1=n30 I2=n29 I3=n28
XFE_OFC219_raw_prime_5 INV1S $PINS O=n44 I=B[5]
XFE_OFC196_raw_prime_9 INV1S $PINS O=n48 I=B[9]
XFE_OFC167_raw_prime_7 INV1S $PINS O=n46 I=B[7]
XFE_OFC146_raw_prime_6 INV1S $PINS O=n45 I=B[6]
XFE_OFC132_raw_prime_2 INV1S $PINS O=n41 I=B[2]
XFE_OFC121_raw_prime_8 INV1S $PINS O=n47 I=B[8]
XFE_OFC96_raw_prime_4 INV1S $PINS O=n43 I=B[4]
XU2_20 FA1 $PINS S=DIFF[20] CO=carry[21] A=A[20] B=n59 CI=carry[20]
XU2_19 FA1 $PINS S=DIFF[19] CO=carry[20] A=A[19] B=n58 CI=carry[19]
XU2_18 FA1 $PINS S=DIFF[18] CO=carry[19] A=A[18] B=n57 CI=carry[18]
XU2_17 FA1 $PINS S=DIFF[17] CO=carry[18] A=A[17] B=n56 CI=carry[17]
XU2_16 FA1 $PINS S=DIFF[16] CO=carry[17] A=A[16] B=n55 CI=carry[16]
XU2_15 FA1 $PINS S=DIFF[15] CO=carry[16] A=A[15] B=n54 CI=carry[15]
XU2_2 FA1 $PINS S=DIFF[2] CO=carry[3] A=A[2] B=n41 CI=carry[2]
XU2_1 FA1 $PINS S=DIFF[1] CO=carry[2] A=A[1] B=n39 CI=n40
XU1 ND3 $PINS O=carry[7] I1=n15 I2=n14 I3=n16
XU3 XOR3 $PINS O=DIFF[6] I1=n45 I2=A[6] I3=carry[6]
XU6 XOR3 $PINS O=DIFF[30] I1=n69 I2=A[30] I3=carry[30]
XU7 XOR3 $PINS O=DIFF[5] I1=n44 I2=A[5] I3=carry[5]
XU8 XOR3 $PINS O=DIFF[7] I1=A[7] I2=n46 I3=carry[7]
XU9 XOR3 $PINS O=DIFF[12] I1=n51 I2=A[12] I3=carry[12]
XU10 XOR3 $PINS O=DIFF[13] I1=A[13] I2=n52 I3=carry[13]
XU11 XOR3 $PINS O=DIFF[28] I1=A[28] I2=n67 I3=carry[28]
XU12 XOR3 $PINS O=DIFF[27] I1=n66 I2=A[27] I3=carry[27]
XU15 ND2 $PINS O=n14 I1=carry[6] I2=n45
XU16 ND2 $PINS O=n15 I1=carry[6] I2=A[6]
XU18 ND3 $PINS O=carry[31] I1=n35 I2=n34 I3=n36
XU19 ND3P $PINS O=carry[28] I1=n5 I2=n4 I3=n6
XU21 ND2 $PINS O=n7 I1=A[28] I2=n67
XU22 ND2 $PINS O=n17 I1=A[7] I2=n46
XU24 ND2 $PINS O=n24 I1=A[13] I2=n52
XU25 INV1S $PINS O=n69 I=B[30]
XU27 INV1S $PINS O=n66 I=B[27]
XU28 ND3P $PINS O=carry[14] I1=n26 I2=n25 I3=n24
XU29 ND2 $PINS O=n1 I1=carry[5] I2=n44
XU30 ND2 $PINS O=n2 I1=carry[5] I2=A[5]
XU31 ND2S $PINS O=n3 I1=n44 I2=A[5]
XU33 ND2 $PINS O=n4 I1=carry[27] I2=n66
XU34 ND2 $PINS O=n5 I1=carry[27] I2=A[27]
XU35 ND2S $PINS O=n6 I1=n66 I2=A[27]
XU36 ND2 $PINS O=n8 I1=carry[28] I2=A[28]
XU37 ND2 $PINS O=n9 I1=n67 I2=carry[28]
XU38 ND3P $PINS O=carry[29] I1=n7 I2=n8 I3=n9
XU39 XOR2HS $PINS O=n10 I1=A[29] I2=n68
XU40 XOR2HS $PINS O=DIFF[29] I1=n10 I2=carry[29]
XU41 ND2S $PINS O=n11 I1=A[29] I2=n68
XU42 ND2 $PINS O=n12 I1=A[29] I2=carry[29]
XU43 ND2 $PINS O=n13 I1=n68 I2=carry[29]
XU44 ND3P $PINS O=carry[30] I1=n11 I2=n12 I3=n13
XU45 ND2 $PINS O=n16 I1=n45 I2=A[6]
XU46 ND2 $PINS O=n18 I1=A[7] I2=carry[7]
XU47 ND2 $PINS O=n19 I1=n46 I2=carry[7]
XU49 XOR2HS $PINS O=n20 I1=A[8] I2=n47
XU50 XOR2HS $PINS O=DIFF[8] I1=n20 I2=carry[8]
XU51 ND2S $PINS O=n21 I1=A[8] I2=n47
XU52 ND2 $PINS O=n22 I1=A[8] I2=carry[8]
XU53 ND2 $PINS O=n23 I1=n47 I2=carry[8]
XU54 ND2 $PINS O=n25 I1=A[13] I2=carry[13]
XU55 ND2 $PINS O=n26 I1=n52 I2=carry[13]
XU56 XOR2HS $PINS O=n27 I1=A[14] I2=n53
XU57 XOR2HS $PINS O=DIFF[14] I1=n27 I2=carry[14]
XU58 ND2S $PINS O=n28 I1=A[14] I2=n53
XU59 ND2 $PINS O=n29 I1=A[14] I2=carry[14]
XU60 ND2 $PINS O=n30 I1=n53 I2=carry[14]
XU61 ND2 $PINS O=n31 I1=carry[12] I2=n51
XU62 ND2 $PINS O=n32 I1=carry[12] I2=A[12]
XU63 ND2S $PINS O=n33 I1=n51 I2=A[12]
XU64 ND2 $PINS O=n34 I1=carry[30] I2=n69
XU65 ND2 $PINS O=n35 I1=carry[30] I2=A[30]
XU66 ND2S $PINS O=n36 I1=n69 I2=A[30]
XU67 XOR2HS $PINS O=n37 I1=n70 I2=A[31]
XU68 INV1S $PINS O=n68 I=B[29]
XU69 INV1S $PINS O=n60 I=B[21]
XU70 INV1S $PINS O=n52 I=B[13]
XU71 INV1S $PINS O=n56 I=B[17]
XU72 INV1S $PINS O=n62 I=B[23]
XU73 INV1S $PINS O=n58 I=B[19]
XU74 INV1S $PINS O=n54 I=B[15]
XU75 INV1S $PINS O=n64 I=B[25]
XU76 INV1S $PINS O=n50 I=B[11]
XU80 INV1S $PINS O=n67 I=B[28]
XU81 INV1S $PINS O=n65 I=B[26]
XU82 INV1S $PINS O=n63 I=B[24]
XU83 INV1S $PINS O=n61 I=B[22]
XU84 INV1S $PINS O=n59 I=B[20]
XU85 INV1S $PINS O=n57 I=B[18]
XU86 INV1S $PINS O=n55 I=B[16]
XU87 INV1S $PINS O=n53 I=B[14]
XU88 INV1S $PINS O=n51 I=B[12]
XU89 INV1S $PINS O=n49 I=B[10]
XU93 INV1S $PINS O=n70 I=B[31]
.ENDS

.SUBCKT Domain_Transfer_1_DW_cmp_2 A[32] A[31] A[30] A[29] A[28] A[27] A[26]
+ A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13]
+ A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[32]
+ B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19]
+ B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6]
+ B[5] B[4] B[3] B[2] B[1] B[0] TC GE_LT GE_GT_EQ GE_LT_GT_LE EQ_NE
+ FE_OFN188_FE_OFN85_raw_prime_4 FE_OFN231_FE_OFN42_raw_prime_20
XFE_RC_2391_0 AO12 $PINS O=n277 A1=n286 B1=n285 B2=n287
XU158 INV1S $PINS O=n241 I=B[18]
XU159 INV1S $PINS O=n256 I=n316
XU160 INV1S $PINS O=n261 I=n295
XU161 INV1S $PINS O=n253 I=n314
XU162 OR2 $PINS O=n340 I1=n338 I2=n229
XU163 AO22S $PINS O=n229 A1=B[1] A2=A[1] B1=B[0] B2=n341
XU164 INV1S $PINS O=n238 I=B[13]
XU165 INV1S $PINS O=n234 I=B[5]
XU166 INV1S $PINS O=n233 I=B[3]
XU167 INV1S $PINS O=n235 I=B[7]
XU168 INV1S $PINS O=n239 I=B[15]
XU169 INV1S $PINS O=n248 I=B[31]
XU170 INV1S $PINS O=n237 I=B[11]
XU171 INV1S $PINS O=n236 I=B[9]
XU172 INV1S $PINS O=n245 I=B[25]
XU173 INV1S $PINS O=n246 I=B[27]
XU174 INV1S $PINS O=n244 I=B[23]
XU175 INV1S $PINS O=n242 I=B[19]
XU176 INV1S $PINS O=n247 I=B[29]
XU177 INV1S $PINS O=n243 I=B[21]
XU178 INV1S $PINS O=n240 I=B[17]
XU179 MAOI1 $PINS O=n321 A1=B[14] A2=n230 B1=A[15] B2=n239
XU180 AN2 $PINS O=n230 I1=n324 I2=A[14]
XU181 MAOI1 $PINS O=n281 A1=B[30] A2=n231 B1=A[31] B2=n248
XU182 AN2 $PINS O=n231 I1=n284 I2=A[30]
XU184 MAOI1 $PINS O=n304 A1=B[22] A2=n232 B1=A[23] B2=n244
XU185 AN2 $PINS O=n232 I1=n307 I2=A[22]
XU201 OR2 $PINS O=GE_LT_GT_LE I1=A[32] I2=n268
XU202 AOI13HS $PINS O=n268 A1=n272 B1=n269 B2=n270 B3=n271
XU203 AOI22S $PINS O=n272 A1=n273 A2=n274 B1=n274 B2=n275
XU204 AOI22S $PINS O=n274 A1=n276 A2=n277 B1=n278 B2=n279
XU205 OAI112HS $PINS O=n279 A1=n280 B1=n281 C1=A[29] C2=n247
XU206 ND3 $PINS O=n280 I1=n282 I2=A[28] I3=B[28]
XU207 OR2B1S $PINS O=n278 I1=n283 B1=n281
XU209 MOAI1S $PINS O=n287 A1=A[25] A2=n245 B1=B[24] B2=n288
XU210 AN2 $PINS O=n288 I1=n289 I2=A[24]
XU211 MOAI1S $PINS O=n286 A1=A[27] A2=n246 B1=B[26] B2=n290
XU212 AN2 $PINS O=n290 I1=n291 I2=A[26]
XU213 AOI22S $PINS O=n273 A1=n292 A2=n293 B1=n294 B2=n261
XU214 AOI22S $PINS O=n294 A1=n296 A2=n297 B1=n297 B2=n298
XU215 OA22 $PINS O=n297 A1=A[19] A2=n242 B1=n241 B2=n299
XU216 ND2 $PINS O=n299 I1=n300 I2=A[18]
XU217 AOI13HS $PINS O=n296 A1=n302 B1=n301 B2=A[16] B3=B[16]
XU218 NR2 $PINS O=n302 I1=A[17] I2=n240
XU219 OAI112HS $PINS O=n293 A1=n303 B1=n304 C1=A[21] C2=n243
XU220 ND3 $PINS O=n303 I1=n305 I2=A[20] I3=B[20]
XU221 OR2B1S $PINS O=n292 I1=n306 B1=n304
XU222 NR3 $PINS O=n271 I1=n298 I2=n295 I3=n275
XU223 ND3 $PINS O=n275 I1=n285 I2=n276 I3=n308
XU224 OA12 $PINS O=n308 A1=n289 B1=B[24] B2=A[24]
XU225 ND2 $PINS O=n289 I1=A[25] I2=n245
XU226 OA112 $PINS O=n276 A1=n282 B1=n283 C1=B[28] C2=A[28]
XU227 OA12 $PINS O=n283 A1=n284 B1=B[30] B2=A[30]
XU228 ND2 $PINS O=n284 I1=A[31] I2=n248
XU229 ND2 $PINS O=n282 I1=A[29] I2=n247
XU230 OA12 $PINS O=n285 A1=n291 B1=B[26] B2=A[26]
XU231 ND2 $PINS O=n291 I1=A[27] I2=n246
XU232 OAI112HS $PINS O=n295 A1=n305 B1=n306 C1=FE_OFN231_FE_OFN42_raw_prime_20
+ C2=A[20]
XU233 OA12 $PINS O=n306 A1=n307 B1=B[22] B2=A[22]
XU234 ND2 $PINS O=n307 I1=A[23] I2=n244
XU235 ND2 $PINS O=n305 I1=A[21] I2=n243
XU236 OAI12HS $PINS O=n298 A1=n300 B1=B[18] B2=A[18]
XU237 ND2 $PINS O=n300 I1=A[19] I2=n242
XU238 OA12 $PINS O=n270 A1=n301 B1=B[16] B2=A[16]
XU239 ND2 $PINS O=n301 I1=A[17] I2=n240
XU240 AOI13HS $PINS O=n269 A1=n311 B1=n309 B2=n310 B3=n253
XU241 AOI13HS $PINS O=n311 A1=n314 B1=n312 B2=n256 B3=n313
XU242 OA12 $PINS O=n313 A1=n315 B1=B[8] B2=A[8]
XU243 MOAI1S $PINS O=n314 A1=n316 A2=n317 B1=n318 B2=n319
XU244 OAI112HS $PINS O=n319 A1=n320 B1=n321 C1=A[13] C2=n238
XU245 ND3 $PINS O=n320 I1=n322 I2=A[12] I3=B[12]
XU246 OR2B1S $PINS O=n318 I1=n323 B1=n321
XU247 OAI22S $PINS O=n317 A1=n312 A2=n325 B1=n325 B2=n326
XU248 MOAI1S $PINS O=n326 A1=A[9] A2=n236 B1=B[8] B2=n327
XU249 AN2 $PINS O=n327 I1=n315 I2=A[8]
XU250 ND2 $PINS O=n315 I1=A[9] I2=n236
XU251 MOAI1S $PINS O=n325 A1=A[11] A2=n237 B1=B[10] B2=n328
XU252 AN2 $PINS O=n328 I1=n329 I2=A[10]
XU253 OA12 $PINS O=n312 A1=n329 B1=B[10] B2=A[10]
XU254 ND2 $PINS O=n329 I1=A[11] I2=n237
XU255 OAI112HS $PINS O=n316 A1=n322 B1=n323 C1=B[12] C2=A[12]
XU256 OA12 $PINS O=n323 A1=n324 B1=B[14] B2=A[14]
XU257 ND2 $PINS O=n324 I1=A[15] I2=n239
XU258 ND2 $PINS O=n322 I1=A[13] I2=n238
XU259 OAI22S $PINS O=n310 A1=n330 A2=n331 B1=n331 B2=n332
XU260 MOAI1S $PINS O=n332 A1=A[5] A2=n234 B1=B[4] B2=n333
XU261 AN2 $PINS O=n333 I1=n334 I2=A[4]
XU262 MOAI1S $PINS O=n331 A1=A[7] A2=n235 B1=B[6] B2=n335
XU263 AN2 $PINS O=n335 I1=n336 I2=A[6]
XU264 OAI112HS $PINS O=n309 A1=n330 B1=n339 C1=n337 C2=n338
XU265 OA112 $PINS O=n339 A1=n334 B1=n340 C1=FE_OFN188_FE_OFN85_raw_prime_4
+ C2=A[4]
XU266 OR2 $PINS O=n341 I1=A[1] I2=B[1]
XU267 ND2 $PINS O=n334 I1=A[5] I2=n234
XU268 OA12 $PINS O=n330 A1=n336 B1=B[6] B2=A[6]
XU269 ND2 $PINS O=n336 I1=A[7] I2=n235
XU270 MOAI1S $PINS O=n338 A1=A[3] A2=n233 B1=B[2] B2=n342
XU271 AN2 $PINS O=n342 I1=n343 I2=A[2]
XU272 OA12 $PINS O=n337 A1=n343 B1=B[2] B2=A[2]
XU273 ND2 $PINS O=n343 I1=A[3] I2=n233
.ENDS

.SUBCKT Domain_Transfer_1_DW01_sub_3 A[31] A[30] A[29] A[28] A[27] A[26] A[25]
+ A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12]
+ A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] CI DIFF[31] DIFF[30] DIFF[29] DIFF[28] DIFF[27] DIFF[26]
+ DIFF[25] DIFF[24] DIFF[23] DIFF[22] DIFF[21] DIFF[20] DIFF[19] DIFF[18]
+ DIFF[17] DIFF[16] DIFF[15] DIFF[14] DIFF[13] DIFF[12] DIFF[11] DIFF[10]
+ DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3] DIFF[2] DIFF[1]
+ DIFF[0] CO
XFE_RC_2373_0 ND3P $PINS O=carry[6] I1=n44 I2=n43 I3=FE_RN_104_0
XFE_OCPC663_FE_OFN86_n312 INV2 $PINS O=n47 I=B[1]
XFE_RC_2110_0 ND2S $PINS O=FE_RN_1437_0 I1=A[23] I2=n69
XFE_RC_2109_0 AN2 $PINS O=FE_RN_1438_0 I1=FE_RN_1441_0 I2=FE_RN_1437_0
XFE_RC_2108_0 XNR2HS $PINS O=FE_RN_1439_0 I1=n69 I2=A[23]
XFE_RC_2107_0 MXL2HS $PINS OB=DIFF[23] S=carry[23] A=FE_RN_1439_0
+ B=FE_RN_1438_0
XFE_RC_2105_0 OR2 $PINS O=FE_RN_1441_0 I1=n69 I2=A[23]
XFE_RC_2104_0 ND2 $PINS O=FE_RN_1442_0 I1=FE_RN_1441_0 I2=carry[23]
XFE_RC_2103_0 ND2P $PINS O=carry[24] I1=FE_RN_1442_0 I2=FE_RN_1437_0
XFE_RC_1909_0 ND2S $PINS O=FE_RN_1286_0 I1=A[24] I2=n70
XFE_RC_1908_0 AN2 $PINS O=FE_RN_1287_0 I1=FE_RN_1290_0 I2=FE_RN_1286_0
XFE_RC_1907_0 XNR2HS $PINS O=FE_RN_1288_0 I1=n70 I2=A[24]
XFE_RC_1906_0 MXL2HS $PINS OB=DIFF[24] S=carry[24] A=FE_RN_1288_0
+ B=FE_RN_1287_0
XFE_RC_1904_0 OR2 $PINS O=FE_RN_1290_0 I1=n70 I2=A[24]
XFE_RC_1903_0 ND2 $PINS O=FE_RN_1291_0 I1=FE_RN_1290_0 I2=carry[24]
XFE_RC_1902_0 ND2P $PINS O=carry[25] I1=FE_RN_1291_0 I2=FE_RN_1286_0
XFE_RC_1815_0 OR2 $PINS O=FE_RN_1219_0 I1=FE_RN_1124_0 I2=FE_RN_1127_0
XFE_RC_1814_0 ND2P $PINS O=carry[14] I1=FE_RN_1131_0 I2=FE_RN_1219_0
XFE_RC_1696_0 INV1S $PINS O=FE_RN_1122_0 I=FE_RN_1130_0
XFE_RC_1695_0 AOI12HS $PINS O=FE_RN_1123_0 A1=FE_RN_1122_0 B1=A[13] B2=n59
XFE_RC_1694_0 INV1S $PINS O=FE_RN_1124_0 I=A[13]
XFE_RC_1692_0 MAOI1 $PINS O=FE_RN_1126_0 A1=FE_RN_1124_0 A2=n59 B1=n59
+ B2=FE_RN_1124_0
XFE_RC_1691_0 MXL2HS $PINS OB=DIFF[13] S=carry[13] A=FE_RN_1126_0
+ B=FE_RN_1123_0
XFE_RC_1690_0 INV1S $PINS O=FE_RN_1127_0 I=n59
XFE_RC_1687_0 OR2B1S $PINS O=FE_RN_1130_0 I1=n59 B1=FE_RN_1124_0
XFE_RC_1686_0 ND2 $PINS O=FE_RN_1131_0 I1=FE_RN_1130_0 I2=carry[13]
XFE_RC_1668_0 ND3P $PINS O=carry[9] I1=n28 I2=n29 I3=n30
XFE_RC_1556_0 OR2 $PINS O=FE_RN_1028_0 I1=FE_RN_972_0 I2=FE_RN_971_0
XFE_RC_1555_0 ND2P $PINS O=carry[10] I1=FE_RN_978_0 I2=FE_RN_1028_0
XFE_RC_1489_0 INV1S $PINS O=FE_RN_969_0 I=FE_RN_977_0
XFE_RC_1488_0 AOI12HS $PINS O=FE_RN_970_0 A1=FE_RN_969_0 B1=A[9] B2=n55
XFE_RC_1487_0 INV1S $PINS O=FE_RN_971_0 I=n55
XFE_RC_1486_0 INV1S $PINS O=FE_RN_972_0 I=A[9]
XFE_RC_1485_0 AOI22S $PINS O=FE_RN_973_0 A1=FE_RN_972_0 A2=n55 B1=A[9]
+ B2=FE_RN_971_0
XFE_RC_1484_0 MXL2HS $PINS OB=DIFF[9] S=carry[9] A=FE_RN_973_0 B=FE_RN_970_0
XFE_RC_1480_0 OR2B1S $PINS O=FE_RN_977_0 I1=n55 B1=FE_RN_972_0
XFE_RC_1479_0 ND2 $PINS O=FE_RN_978_0 I1=FE_RN_977_0 I2=carry[9]
XFE_RC_1279_0 INV1S $PINS O=FE_RN_818_0 I=FE_RN_822_0
XFE_RC_1278_0 AOI12HS $PINS O=FE_RN_819_0 A1=FE_RN_818_0 B1=A[6] B2=n52
XFE_RC_1277_0 XNR2HS $PINS O=FE_RN_820_0 I1=n52 I2=A[6]
XFE_RC_1276_0 MXL2HS $PINS OB=DIFF[6] S=carry[6] A=FE_RN_820_0 B=FE_RN_819_0
XFE_RC_1275_0 ND2 $PINS O=FE_RN_821_0 I1=A[6] I2=n52
XFE_RC_1274_0 OR2 $PINS O=FE_RN_822_0 I1=n52 I2=A[6]
XFE_RC_1273_0 ND2 $PINS O=FE_RN_823_0 I1=FE_RN_822_0 I2=carry[6]
XFE_RC_1272_0 ND2P $PINS O=carry[7] I1=FE_RN_823_0 I2=FE_RN_821_0
XFE_RC_1054_0 ND2S $PINS O=FE_RN_658_0 I1=A[25] I2=n71
XFE_RC_1053_0 AN2 $PINS O=FE_RN_659_0 I1=FE_RN_662_0 I2=FE_RN_658_0
XFE_RC_1052_0 XNR2HS $PINS O=FE_RN_660_0 I1=n71 I2=A[25]
XFE_RC_1051_0 MXL2HS $PINS OB=DIFF[25] S=carry[25] A=FE_RN_660_0 B=FE_RN_659_0
XFE_RC_1049_0 OR2 $PINS O=FE_RN_662_0 I1=n71 I2=A[25]
XFE_RC_1048_0 ND2 $PINS O=FE_RN_663_0 I1=FE_RN_662_0 I2=carry[25]
XFE_RC_1047_0 ND2P $PINS O=carry[26] I1=FE_RN_663_0 I2=FE_RN_658_0
XFE_RC_898_0 ND2S $PINS O=FE_RN_541_0 I1=A[7] I2=n53
XFE_RC_897_0 AN2 $PINS O=FE_RN_542_0 I1=FE_RN_545_0 I2=FE_RN_541_0
XFE_RC_896_0 XNR2HS $PINS O=FE_RN_543_0 I1=n53 I2=A[7]
XFE_RC_895_0 MXL2HS $PINS OB=DIFF[7] S=carry[7] A=FE_RN_543_0 B=FE_RN_542_0
XFE_RC_893_0 OR2 $PINS O=FE_RN_545_0 I1=n53 I2=A[7]
XFE_RC_892_0 ND2 $PINS O=FE_RN_546_0 I1=FE_RN_545_0 I2=carry[7]
XFE_RC_891_0 ND2P $PINS O=carry[8] I1=FE_RN_546_0 I2=FE_RN_541_0
XFE_RC_693_0 ND2 $PINS O=FE_RN_394_0 I1=A[14] I2=n60
XFE_RC_692_0 AN2 $PINS O=FE_RN_395_0 I1=FE_RN_398_0 I2=FE_RN_394_0
XFE_RC_691_0 XNR2HS $PINS O=FE_RN_396_0 I1=n60 I2=A[14]
XFE_RC_690_0 MXL2HS $PINS OB=DIFF[14] S=carry[14] A=FE_RN_396_0 B=FE_RN_395_0
XFE_RC_688_0 OR2S $PINS O=FE_RN_398_0 I1=n60 I2=A[14]
XFE_RC_687_0 ND2 $PINS O=FE_RN_399_0 I1=FE_RN_398_0 I2=carry[14]
XFE_RC_686_0 ND2P $PINS O=carry[15] I1=FE_RN_399_0 I2=FE_RN_394_0
XFE_RC_551_0 ND3P $PINS O=carry[12] I1=n16 I2=n17 I3=n15
XFE_RC_536_0 ND2 $PINS O=FE_RN_282_0 I1=A[15] I2=n61
XFE_RC_535_0 AN2 $PINS O=FE_RN_283_0 I1=FE_RN_286_0 I2=FE_RN_282_0
XFE_RC_534_0 XNR2HS $PINS O=FE_RN_284_0 I1=n61 I2=A[15]
XFE_RC_533_0 MXL2HS $PINS OB=DIFF[15] S=carry[15] A=FE_RN_284_0 B=FE_RN_283_0
XFE_RC_531_0 OR2S $PINS O=FE_RN_286_0 I1=n61 I2=A[15]
XFE_RC_530_0 ND2 $PINS O=FE_RN_287_0 I1=FE_RN_286_0 I2=carry[15]
XFE_RC_529_0 ND2P $PINS O=carry[16] I1=FE_RN_287_0 I2=FE_RN_282_0
XFE_RC_315_0 ND3P $PINS O=carry[27] I1=n23 I2=n24 I3=n22
XFE_RC_309_0 ND3P $PINS O=carry[30] I1=n9 I2=n8 I3=n7
XFE_RC_308_0 ND2S $PINS O=FE_RN_135_0 I1=A[10] I2=n56
XFE_RC_307_0 AN2 $PINS O=FE_RN_136_0 I1=FE_RN_139_0 I2=FE_RN_135_0
XFE_RC_306_0 XNR2HS $PINS O=FE_RN_137_0 I1=n56 I2=A[10]
XFE_RC_305_0 MXL2HS $PINS OB=DIFF[10] S=carry[10] A=FE_RN_137_0 B=FE_RN_136_0
XFE_RC_303_0 OR2 $PINS O=FE_RN_139_0 I1=n56 I2=A[10]
XFE_RC_302_0 ND2 $PINS O=FE_RN_140_0 I1=FE_RN_139_0 I2=carry[10]
XFE_RC_301_0 ND2P $PINS O=carry[11] I1=FE_RN_140_0 I2=FE_RN_135_0
XFE_RC_254_0 ND3P $PINS O=carry[17] I1=n5 I2=n4 I3=n6
XFE_RC_251_0 INV1S $PINS O=FE_RN_104_0 I=n38
XFE_RC_196_0 ND3P $PINS O=carry[5] I1=n41 I2=n40 I3=n39
XFE_RC_188_0 INV1S $PINS O=FE_RN_66_0 I=n14
XFE_RC_187_0 ND3P $PINS O=carry[28] I1=n26 I2=n27 I3=FE_RN_66_0
XFE_RC_183_0 ND3P $PINS O=carry[13] I1=n21 I2=n20 I3=n19
XFE_RC_158_0 ND3P $PINS O=carry[19] I1=n37 I2=n36 I3=n35
XFE_OFC284_raw_prime_3 INV1S $PINS O=n49 I=B[3]
XFE_OFC211_raw_prime_5 INV1S $PINS O=n51 I=B[5]
XFE_OFC160_raw_prime_7 INV1S $PINS O=n53 I=B[7]
XFE_OFC149_raw_prime_6 INV1S $PINS O=n52 I=B[6]
XFE_OFC88_raw_prime_4 INV1S $PINS O=n50 I=B[4]
XU2_22 FA1 $PINS S=DIFF[22] CO=carry[23] A=A[22] B=n68 CI=carry[22]
XU2_21 FA1 $PINS S=DIFF[21] CO=carry[22] A=A[21] B=n67 CI=carry[21]
XU2_20 FA1 $PINS S=DIFF[20] CO=carry[21] A=A[20] B=n66 CI=carry[20]
XU2_19 FA1 $PINS S=DIFF[19] CO=carry[20] A=A[19] B=n65 CI=carry[19]
XU2_3 FA1 $PINS S=DIFF[3] CO=carry[4] A=A[3] B=n49 CI=carry[3]
XU2_2 FA1 $PINS S=DIFF[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU2_1 FA1 $PINS S=DIFF[1] CO=carry[2] A=A[1] B=n47 CI=carry[1]
XU2_31 XOR3 $PINS O=DIFF[31] I1=A[31] I2=n77 I3=carry[31]
XU1 ND3P $PINS O=carry[29] I1=n1 I2=n2 I3=n3
XU5 ND2 $PINS O=n15 I1=A[11] I2=n57
XU6 ND2 $PINS O=n39 I1=A[4] I2=n50
XU8 INV1S $PINS O=n62 I=B[16]
XU9 ND2 $PINS O=n31 I1=A[17] I2=n63
XU10 ND2 $PINS O=n7 I1=A[29] I2=n75
XU11 ND2 $PINS O=n22 I1=A[26] I2=n72
XU12 XOR3 $PINS O=DIFF[4] I1=A[4] I2=n50 I3=carry[4]
XU13 XOR3 $PINS O=DIFF[8] I1=B[8] I2=A[8] I3=carry[8]
XU14 XOR3 $PINS O=DIFF[11] I1=A[11] I2=n57 I3=carry[11]
XU15 XOR3 $PINS O=DIFF[16] I1=n62 I2=A[16] I3=carry[16]
XU16 XOR3 $PINS O=DIFF[17] I1=A[17] I2=n63 I3=carry[17]
XU17 XOR3 $PINS O=DIFF[26] I1=A[26] I2=n72 I3=carry[26]
XU18 INV1S $PINS O=n45 I=A[0]
XU19 XOR3 $PINS O=DIFF[28] I1=n74 I2=A[28] I3=carry[28]
XU20 ND2 $PINS O=n1 I1=carry[28] I2=n74
XU21 ND2 $PINS O=n2 I1=carry[28] I2=A[28]
XU22 ND2 $PINS O=n3 I1=n74 I2=A[28]
XU23 XOR3 $PINS O=DIFF[29] I1=A[29] I2=n75 I3=carry[29]
XU25 ND2 $PINS O=n43 I1=carry[5] I2=A[5]
XU27 INV1S $PINS O=n46 I=B[0]
XU28 ND2P $PINS O=n4 I1=carry[16] I2=n62
XU29 ND2 $PINS O=n5 I1=carry[16] I2=A[16]
XU30 ND2S $PINS O=n6 I1=n62 I2=A[16]
XU32 ND2S $PINS O=n26 I1=carry[27] I2=A[27]
XU34 ND2 $PINS O=n8 I1=A[29] I2=carry[29]
XU35 ND2 $PINS O=n9 I1=n75 I2=carry[29]
XU37 XOR2HS $PINS O=n10 I1=A[30] I2=n76
XU38 XOR2HS $PINS O=DIFF[30] I1=n10 I2=carry[30]
XU39 ND2S $PINS O=n11 I1=A[30] I2=n76
XU40 ND2 $PINS O=n12 I1=A[30] I2=carry[30]
XU41 ND2 $PINS O=n13 I1=carry[30] I2=n76
XU42 ND3 $PINS O=carry[31] I1=n11 I2=n12 I3=n13
XU44 AN2 $PINS O=n14 I1=A[27] I2=n73
XU45 ND2 $PINS O=n16 I1=A[11] I2=carry[11]
XU46 ND2 $PINS O=n17 I1=n57 I2=carry[11]
XU48 XOR2HS $PINS O=n18 I1=A[12] I2=n58
XU49 XOR2HS $PINS O=DIFF[12] I1=n18 I2=carry[12]
XU50 ND2S $PINS O=n19 I1=A[12] I2=n58
XU51 ND2 $PINS O=n20 I1=A[12] I2=carry[12]
XU52 ND2 $PINS O=n21 I1=n58 I2=carry[12]
XU53 ND2 $PINS O=n23 I1=A[26] I2=carry[26]
XU54 ND2 $PINS O=n24 I1=n72 I2=carry[26]
XU55 XOR2HS $PINS O=n25 I1=A[27] I2=n73
XU56 XOR2HS $PINS O=DIFF[27] I1=n25 I2=carry[27]
XU57 ND2 $PINS O=n27 I1=n73 I2=carry[27]
XU58 ND2 $PINS O=n28 I1=carry[8] I2=B[8]
XU59 ND2 $PINS O=n29 I1=carry[8] I2=A[8]
XU60 ND2S $PINS O=n30 I1=B[8] I2=A[8]
XU61 ND2 $PINS O=n32 I1=A[17] I2=carry[17]
XU62 ND2 $PINS O=n33 I1=n63 I2=carry[17]
XU63 ND3P $PINS O=carry[18] I1=n33 I2=n32 I3=n31
XU64 XOR2HS $PINS O=n34 I1=A[18] I2=n64
XU65 XOR2HS $PINS O=DIFF[18] I1=n34 I2=carry[18]
XU66 ND2S $PINS O=n35 I1=A[18] I2=n64
XU67 ND2 $PINS O=n36 I1=A[18] I2=carry[18]
XU68 ND2 $PINS O=n37 I1=n64 I2=carry[18]
XU70 AN2 $PINS O=n38 I1=A[5] I2=n51
XU71 ND2 $PINS O=n40 I1=A[4] I2=carry[4]
XU72 ND2 $PINS O=n41 I1=n50 I2=carry[4]
XU73 XOR2HS $PINS O=n42 I1=A[5] I2=n51
XU74 XOR2HS $PINS O=DIFF[5] I1=n42 I2=carry[5]
XU75 ND2 $PINS O=n44 I1=n51 I2=carry[5]
XU79 INV1S $PINS O=n60 I=B[14]
XU80 INV1S $PINS O=n76 I=B[30]
XU82 INV1S $PINS O=n74 I=B[28]
XU83 INV1S $PINS O=n58 I=B[12]
XU84 INV1S $PINS O=n66 I=B[20]
XU85 INV1S $PINS O=n72 I=B[26]
XU86 INV1S $PINS O=n70 I=B[24]
XU87 INV1S $PINS O=n68 I=B[22]
XU88 INV1S $PINS O=n64 I=B[18]
XU89 INV1S $PINS O=n56 I=B[10]
XU90 INV1S $PINS O=n75 I=B[29]
XU91 INV1S $PINS O=n73 I=B[27]
XU92 INV1S $PINS O=n71 I=B[25]
XU93 INV1S $PINS O=n69 I=B[23]
XU94 INV1S $PINS O=n67 I=B[21]
XU95 INV1S $PINS O=n65 I=B[19]
XU96 INV1S $PINS O=n63 I=B[17]
XU97 INV1S $PINS O=n61 I=B[15]
XU98 INV1S $PINS O=n59 I=B[13]
XU99 INV1S $PINS O=n57 I=B[11]
XU100 INV1S $PINS O=n55 I=B[9]
XU103 INV1S $PINS O=n77 I=B[31]
XU104 XNR2HS $PINS O=DIFF[0] I1=n46 I2=A[0]
XU105 ND2P $PINS O=carry[1] I1=B[0] I2=n45
.ENDS

.SUBCKT Domain_Transfer_1_DW_cmp_3 A[31] A[30] A[29] A[28] A[27] A[26] A[25]
+ A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12]
+ A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] TC GE_LT GE_GT_EQ GE_LT_GT_LE EQ_NE
XFE_RC_2393_0 AO12 $PINS O=n331 A1=n339 B1=n327 B2=n340
XFE_RC_2392_0 AO12 $PINS O=n292 A1=n301 B1=n300 B2=n302
XU161 INV1S $PINS O=n242 I=B[18]
XU162 INV1S $PINS O=n240 I=B[14]
XU163 INV1S $PINS O=n248 I=B[30]
XU164 INV1S $PINS O=n244 I=B[22]
XU165 INV1S $PINS O=n252 I=n317
XU166 INV1S $PINS O=n239 I=B[12]
XU167 INV1S $PINS O=n234 I=B[2]
XU168 INV1S $PINS O=n236 I=B[6]
XU169 INV1S $PINS O=n235 I=B[4]
XU170 INV1S $PINS O=n243 I=B[20]
XU171 INV1S $PINS O=n238 I=B[10]
XU172 INV1S $PINS O=n237 I=B[8]
XU173 INV1S $PINS O=n246 I=B[26]
XU174 INV1S $PINS O=n245 I=B[24]
XU175 INV1S $PINS O=n241 I=B[16]
XU176 INV1S $PINS O=n247 I=B[28]
XU177 INV1S $PINS O=n266 I=n283
XU178 INV1S $PINS O=n260 I=A[1]
XU179 MAOI1S $PINS O=n323 A1=A[2] A2=n230 B1=B[3] B2=n259
XU180 AN2 $PINS O=n230 I1=n325 I2=n234
XU181 INV1S $PINS O=n255 I=A[13]
XU182 MAOI1 $PINS O=n335 A1=A[14] A2=n231 B1=B[15] B2=n256
XU183 AN2 $PINS O=n231 I1=n338 I2=n240
XU184 MAOI1 $PINS O=n296 A1=A[30] A2=n232 B1=B[31] B2=n257
XU185 AN2 $PINS O=n232 I1=n299 I2=n248
XU186 INV1S $PINS O=n249 I=A[11]
XU187 INV1S $PINS O=n250 I=A[9]
XU188 INV1S $PINS O=n267 I=A[19]
XU189 INV1S $PINS O=n262 I=A[27]
XU190 INV1S $PINS O=n261 I=A[25]
XU191 INV1S $PINS O=n259 I=A[3]
XU192 INV1S $PINS O=n256 I=A[15]
XU193 INV1S $PINS O=n254 I=A[7]
XU194 INV1S $PINS O=n257 I=A[31]
XU195 INV1S $PINS O=n251 I=A[6]
XU196 INV1S $PINS O=n265 I=A[17]
XU197 INV1S $PINS O=n258 I=A[29]
XU198 INV1S $PINS O=n253 I=A[5]
XU199 INV1S $PINS O=n263 I=A[21]
XU200 INV1S $PINS O=n264 I=A[23]
XU201 INV1S $PINS O=n233 I=B[0]
XU202 MOAI1S $PINS O=GE_LT_GT_LE A1=n268 A2=n269 B1=n270 B2=n271
XU203 ND3 $PINS O=n271 I1=n272 I2=n273 I3=n274
XU204 OAI22S $PINS O=n273 A1=n275 A2=n276 B1=n276 B2=n277
XU205 MOAI1S $PINS O=n277 A1=B[21] A2=n263 B1=A[20] B2=n278
XU206 AN2 $PINS O=n278 I1=n279 I2=n243
XU207 MOAI1S $PINS O=n276 A1=B[23] A2=n264 B1=A[22] B2=n280
XU208 AN2 $PINS O=n280 I1=n281 I2=n244
XU209 OAI112HS $PINS O=n272 A1=n284 B1=n285 C1=n282 C2=n283
XU210 OAI112HS $PINS O=n284 A1=n286 B1=n266 C1=B[17] C2=n265
XU211 ND3 $PINS O=n286 I1=n287 I2=n241 I3=A[16]
XU212 MOAI1S $PINS O=n283 A1=B[19] A2=n267 B1=A[18] B2=n288
XU213 AN2 $PINS O=n288 I1=n289 I2=n242
XU214 ND2 $PINS O=n270 I1=n274 I2=n290
XU215 AOI22S $PINS O=n274 A1=n291 A2=n292 B1=n293 B2=n294
XU216 OAI112HS $PINS O=n294 A1=n295 B1=n296 C1=B[29] C2=n258
XU217 ND3 $PINS O=n295 I1=n297 I2=n247 I3=A[28]
XU218 OR2B1S $PINS O=n293 I1=n298 B1=n296
XU220 MOAI1S $PINS O=n302 A1=B[25] A2=n261 B1=A[24] B2=n303
XU221 AN2 $PINS O=n303 I1=n304 I2=n245
XU222 MOAI1S $PINS O=n301 A1=B[27] A2=n262 B1=A[26] B2=n305
XU223 AN2 $PINS O=n305 I1=n306 I2=n246
XU224 OR3B2 $PINS O=n269 I1=n290 B1=n285 B2=n282
XU225 OA12 $PINS O=n282 A1=n289 B1=A[18] B2=n242
XU226 ND2 $PINS O=n289 I1=B[19] I2=n267
XU227 OA112 $PINS O=n285 A1=n279 B1=n275 C1=A[20] C2=n243
XU228 OA12 $PINS O=n275 A1=n281 B1=A[22] B2=n244
XU229 ND2 $PINS O=n281 I1=B[23] I2=n264
XU230 ND2 $PINS O=n279 I1=B[21] I2=n263
XU231 ND3 $PINS O=n290 I1=n300 I2=n291 I3=n307
XU232 OA12 $PINS O=n307 A1=n304 B1=A[24] B2=n245
XU233 ND2 $PINS O=n304 I1=B[25] I2=n261
XU234 OA112 $PINS O=n291 A1=n297 B1=n298 C1=A[28] C2=n247
XU235 OA12 $PINS O=n298 A1=n299 B1=A[30] B2=n248
XU236 ND2 $PINS O=n299 I1=B[31] I2=n257
XU237 ND2 $PINS O=n297 I1=B[29] I2=n258
XU238 OA12 $PINS O=n300 A1=n306 B1=A[26] B2=n246
XU239 ND2 $PINS O=n306 I1=B[27] I2=n262
XU240 OAI112HS $PINS O=n268 A1=n287 B1=n308 C1=A[16] C2=n241
XU241 AOI22S $PINS O=n308 A1=n309 A2=n310 B1=n311 B2=n309
XU242 AOI13HS $PINS O=n311 A1=n314 B1=n252 B2=n312 B3=n313
XU243 AOI22S $PINS O=n314 A1=n315 A2=n316 B1=n316 B2=n317
XU244 OA22 $PINS O=n316 A1=B[7] A2=n254 B1=n251 B2=n318
XU245 ND2 $PINS O=n318 I1=n319 I2=n236
XU246 AOI13HS $PINS O=n315 A1=n321 B1=n320 B2=n235 B3=A[4]
XU247 NR2 $PINS O=n321 I1=B[5] I2=n253
XU248 OA112 $PINS O=n313 A1=n320 B1=n322 C1=A[4] C2=n235
XU249 ND2 $PINS O=n322 I1=n323 I2=n324
XU250 OAI12HS $PINS O=n324 A1=n325 B1=A[2] B2=n234
XU251 ND2 $PINS O=n320 I1=B[5] I2=n253
XU252 OAI112HS $PINS O=n312 A1=n326 B1=n323 C1=B[1] C2=n260
XU253 ND2 $PINS O=n325 I1=B[3] I2=n259
XU254 MOAI1S $PINS O=n326 A1=A[0] A2=n233 B1=n260 B2=B[1]
XU255 OAI12HS $PINS O=n317 A1=n319 B1=A[6] B2=n236
XU256 ND2 $PINS O=n319 I1=B[7] I2=n254
XU257 ND3 $PINS O=n310 I1=n327 I2=n328 I3=n329
XU258 OA12 $PINS O=n329 A1=n330 B1=A[8] B2=n237
XU259 AOI22S $PINS O=n309 A1=n328 A2=n331 B1=n332 B2=n333
XU260 OAI112HS $PINS O=n333 A1=n334 B1=n335 C1=B[13] C2=n255
XU261 ND3 $PINS O=n334 I1=n336 I2=n239 I3=A[12]
XU262 OR2B1S $PINS O=n332 I1=n337 B1=n335
XU264 MOAI1S $PINS O=n340 A1=B[9] A2=n250 B1=A[8] B2=n341
XU265 AN2 $PINS O=n341 I1=n330 I2=n237
XU266 ND2 $PINS O=n330 I1=B[9] I2=n250
XU267 MOAI1S $PINS O=n339 A1=B[11] A2=n249 B1=A[10] B2=n342
XU268 AN2 $PINS O=n342 I1=n343 I2=n238
XU269 OA12 $PINS O=n327 A1=n343 B1=A[10] B2=n238
XU270 ND2 $PINS O=n343 I1=B[11] I2=n249
XU271 OA112 $PINS O=n328 A1=n336 B1=n337 C1=A[12] C2=n239
XU272 OA12 $PINS O=n337 A1=n338 B1=A[14] B2=n240
XU273 ND2 $PINS O=n338 I1=B[15] I2=n256
XU274 ND2 $PINS O=n336 I1=B[13] I2=n255
XU275 ND2 $PINS O=n287 I1=B[17] I2=n265
.ENDS

.SUBCKT Domain_Transfer_1_DW01_sub_4 A[31] A[30] A[29] A[28] A[27] A[26] A[25]
+ A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12]
+ A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] CI DIFF[31] DIFF[30] DIFF[29] DIFF[28] DIFF[27] DIFF[26]
+ DIFF[25] DIFF[24] DIFF[23] DIFF[22] DIFF[21] DIFF[20] DIFF[19] DIFF[18]
+ DIFF[17] DIFF[16] DIFF[15] DIFF[14] DIFF[13] DIFF[12] DIFF[11] DIFF[10]
+ DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3] DIFF[2] DIFF[1]
+ DIFF[0] CO FE_OFN97_raw_prime_9 FE_OCPN352_n310
XFE_OCPC657_carry_24 BUF1S $PINS O=FE_OCPN657_carry_24 I=carry[24]
XFE_RC_2320_0 XOR3 $PINS O=DIFF[20] I1=A[20] I2=n63 I3=carry[20]
XFE_RC_2319_0 MAO222 $PINS O=carry[21] A1=A[20] B1=n63 C1=carry[20]
XFE_RC_2281_0 XOR3 $PINS O=DIFF[27] I1=A[27] I2=n70 I3=carry[27]
XFE_RC_2280_0 MAO222P $PINS O=carry[28] A1=A[27] B1=n70 C1=carry[27]
XFE_RC_2129_0 ND3P $PINS O=carry[27] I1=n26 I2=n25 I3=n27
XFE_RC_2102_0 ND2 $PINS O=FE_RN_1431_0 I1=A[21] I2=n64
XFE_RC_2101_0 AN2S $PINS O=FE_RN_1432_0 I1=FE_RN_1435_0 I2=FE_RN_1431_0
XFE_RC_2100_0 XNR2HS $PINS O=FE_RN_1433_0 I1=n64 I2=A[21]
XFE_RC_2099_0 MXL2HS $PINS OB=DIFF[21] S=carry[21] A=FE_RN_1433_0
+ B=FE_RN_1432_0
XFE_RC_2097_0 OR2S $PINS O=FE_RN_1435_0 I1=n64 I2=A[21]
XFE_RC_2096_0 ND2 $PINS O=FE_RN_1436_0 I1=FE_RN_1435_0 I2=carry[21]
XFE_RC_2095_0 ND2P $PINS O=carry[22] I1=FE_RN_1436_0 I2=FE_RN_1431_0
XFE_RC_1840_0 ND3 $PINS O=carry[10] I1=n12 I2=n13 I3=n11
XFE_RC_1823_0 AN2 $PINS O=FE_RN_1220_0 I1=A[3] I2=n46
XFE_RC_1822_0 AN2B1S $PINS O=FE_RN_1221_0 I1=FE_RN_1224_0 B1=FE_RN_1220_0
XFE_RC_1821_0 XNR2HS $PINS O=FE_RN_1222_0 I1=n46 I2=A[3]
XFE_RC_1820_0 MXL2HS $PINS OB=DIFF[3] S=carry[3] A=FE_RN_1222_0 B=FE_RN_1221_0
XFE_RC_1819_0 ND2S $PINS O=FE_RN_1223_0 I1=A[3] I2=n46
XFE_RC_1818_0 OR2 $PINS O=FE_RN_1224_0 I1=n46 I2=A[3]
XFE_RC_1817_0 ND2 $PINS O=FE_RN_1225_0 I1=FE_RN_1224_0 I2=carry[3]
XFE_RC_1816_0 ND2P $PINS O=carry[4] I1=FE_RN_1225_0 I2=FE_RN_1223_0
XFE_RC_1567_0 INV1S $PINS O=FE_RN_1029_0 I=FE_RN_1036_0
XFE_RC_1566_0 AOI12HS $PINS O=FE_RN_1030_0 A1=FE_RN_1029_0 B1=A[10] B2=n53
XFE_RC_1565_0 INV1S $PINS O=FE_RN_1031_0 I=A[10]
XFE_RC_1563_0 MAOI1 $PINS O=FE_RN_1033_0 A1=FE_RN_1031_0 A2=n53 B1=n53
+ B2=FE_RN_1031_0
XFE_RC_1562_0 MXL2HS $PINS OB=DIFF[10] S=carry[10] A=FE_RN_1033_0
+ B=FE_RN_1030_0
XFE_RC_1561_0 ND2 $PINS O=FE_RN_1034_0 I1=A[10] I2=n53
XFE_RC_1559_0 OR2B1S $PINS O=FE_RN_1036_0 I1=n53 B1=FE_RN_1031_0
XFE_RC_1558_0 ND2 $PINS O=FE_RN_1037_0 I1=FE_RN_1036_0 I2=carry[10]
XFE_RC_1557_0 ND2P $PINS O=carry[11] I1=FE_RN_1037_0 I2=FE_RN_1034_0
XFE_RC_1312_0 ND2S $PINS O=FE_RN_839_0 I1=A[11] I2=n54
XFE_RC_1311_0 AN2S $PINS O=FE_RN_840_0 I1=FE_RN_843_0 I2=FE_RN_839_0
XFE_RC_1310_0 XNR2HS $PINS O=FE_RN_841_0 I1=n54 I2=A[11]
XFE_RC_1309_0 MXL2HS $PINS OB=DIFF[11] S=carry[11] A=FE_RN_841_0 B=FE_RN_840_0
XFE_RC_1307_0 OR2 $PINS O=FE_RN_843_0 I1=n54 I2=A[11]
XFE_RC_1306_0 ND2 $PINS O=FE_RN_844_0 I1=FE_RN_843_0 I2=carry[11]
XFE_RC_1305_0 ND2P $PINS O=carry[12] I1=FE_RN_844_0 I2=FE_RN_839_0
XFE_RC_1304_0 MOAI1 $PINS O=carry[24] A1=FE_RN_759_0 A2=FE_RN_756_0 B1=n66
+ B2=A[23]
XFE_RC_1188_0 INV1S $PINS O=FE_RN_756_0 I=FE_RN_760_0
XFE_RC_1187_0 AOI12HS $PINS O=FE_RN_757_0 A1=FE_RN_756_0 B1=A[23] B2=n66
XFE_RC_1186_0 XNR2HS $PINS O=FE_RN_758_0 I1=n66 I2=A[23]
XFE_RC_1185_0 MXL2HS $PINS OB=DIFF[23] S=carry[23] A=FE_RN_758_0 B=FE_RN_757_0
XFE_RC_1184_0 INV1S $PINS O=FE_RN_759_0 I=carry[23]
XFE_RC_1183_0 OR2S $PINS O=FE_RN_760_0 I1=n66 I2=A[23]
XFE_RC_967_0 AN2 $PINS O=FE_RN_593_0 I1=A[4] I2=n47
XFE_RC_966_0 AN2B1S $PINS O=FE_RN_594_0 I1=FE_RN_597_0 B1=FE_RN_593_0
XFE_RC_965_0 XNR2HS $PINS O=FE_RN_595_0 I1=n47 I2=A[4]
XFE_RC_964_0 MXL2HS $PINS OB=DIFF[4] S=carry[4] A=FE_RN_595_0 B=FE_RN_594_0
XFE_RC_963_0 ND2S $PINS O=FE_RN_596_0 I1=A[4] I2=n47
XFE_RC_962_0 OR2 $PINS O=FE_RN_597_0 I1=n47 I2=A[4]
XFE_RC_961_0 ND2 $PINS O=FE_RN_598_0 I1=FE_RN_597_0 I2=carry[4]
XFE_RC_960_0 ND2P $PINS O=carry[5] I1=FE_RN_598_0 I2=FE_RN_596_0
XFE_RC_767_0 ND3P $PINS O=n14 I1=n18 I2=n19 I3=n20
XFE_RC_749_0 ND2S $PINS O=FE_RN_432_0 I1=A[5] I2=n48
XFE_RC_748_0 AN2 $PINS O=FE_RN_433_0 I1=FE_RN_436_0 I2=FE_RN_432_0
XFE_RC_747_0 XNR2HS $PINS O=FE_RN_434_0 I1=n48 I2=A[5]
XFE_RC_746_0 MXL2HS $PINS OB=DIFF[5] S=carry[5] A=FE_RN_434_0 B=FE_RN_433_0
XFE_RC_744_0 OR2 $PINS O=FE_RN_436_0 I1=n48 I2=A[5]
XFE_RC_743_0 ND2 $PINS O=FE_RN_437_0 I1=FE_RN_436_0 I2=carry[5]
XFE_RC_742_0 ND2P $PINS O=carry[6] I1=FE_RN_437_0 I2=FE_RN_432_0
XFE_RC_528_0 ND2S $PINS O=FE_RN_276_0 I1=A[12] I2=n55
XFE_RC_527_0 AN2 $PINS O=FE_RN_277_0 I1=FE_RN_280_0 I2=FE_RN_276_0
XFE_RC_526_0 XNR2HS $PINS O=FE_RN_278_0 I1=n55 I2=A[12]
XFE_RC_525_0 MXL2HS $PINS OB=DIFF[12] S=carry[12] A=FE_RN_278_0 B=FE_RN_277_0
XFE_RC_523_0 OR2S $PINS O=FE_RN_280_0 I1=n55 I2=A[12]
XFE_RC_522_0 ND2 $PINS O=FE_RN_281_0 I1=FE_RN_280_0 I2=carry[12]
XFE_RC_521_0 ND2P $PINS O=carry[13] I1=FE_RN_281_0 I2=FE_RN_276_0
XFE_RC_337_0 ND2 $PINS O=FE_RN_147_0 I1=A[6] I2=n49
XFE_RC_336_0 AN2 $PINS O=FE_RN_148_0 I1=FE_RN_151_0 I2=FE_RN_147_0
XFE_RC_335_0 XNR2HS $PINS O=FE_RN_149_0 I1=n49 I2=A[6]
XFE_RC_334_0 MXL2HS $PINS OB=DIFF[6] S=carry[6] A=FE_RN_149_0 B=FE_RN_148_0
XFE_RC_332_0 OR2 $PINS O=FE_RN_151_0 I1=n49 I2=A[6]
XFE_RC_331_0 ND2 $PINS O=FE_RN_152_0 I1=FE_RN_151_0 I2=carry[6]
XFE_RC_330_0 ND2P $PINS O=carry[7] I1=FE_RN_152_0 I2=FE_RN_147_0
XFE_RC_95_0 ND3P $PINS O=carry[18] I1=n41 I2=n40 I3=n39
XFE_RC_70_0 ND2S $PINS O=FE_RN_20_0 I1=A[7] I2=n50
XFE_RC_69_0 AN2 $PINS O=FE_RN_21_0 I1=FE_RN_24_0 I2=FE_RN_20_0
XFE_RC_68_0 XNR2HS $PINS O=FE_RN_22_0 I1=n50 I2=A[7]
XFE_RC_67_0 MXL2HS $PINS OB=DIFF[7] S=carry[7] A=FE_RN_22_0 B=FE_RN_21_0
XFE_RC_65_0 OR2 $PINS O=FE_RN_24_0 I1=n50 I2=A[7]
XFE_RC_64_0 ND2 $PINS O=FE_RN_25_0 I1=FE_RN_24_0 I2=carry[7]
XFE_RC_63_0 ND2P $PINS O=carry[8] I1=FE_RN_25_0 I2=FE_RN_20_0
XFE_OFC276_raw_prime_3 INV1S $PINS O=n46 I=B[3]
XFE_OFC216_raw_prime_5 INV1S $PINS O=n48 I=B[5]
XFE_OFC166_raw_prime_7 INV1S $PINS O=n50 I=B[7]
XFE_OFC144_raw_prime_6 INV1S $PINS O=n49 I=B[6]
XFE_OFC129_raw_prime_2 INV1S $PINS O=n45 I=B[2]
XFE_OFC102_n312 INV1S $PINS O=n44 I=B[1]
XFE_OFC94_raw_prime_4 INV1S $PINS O=n47 I=B[4]
XU2_30 FA1 $PINS S=DIFF[30] CO=carry[31] A=A[30] B=n73 CI=carry[30]
XU2_22 FA1 $PINS S=DIFF[22] CO=carry[23] A=A[22] B=n65 CI=carry[22]
XU2_19 FA1 $PINS S=DIFF[19] CO=carry[20] A=A[19] B=n62 CI=carry[19]
XU2_18 FA1 $PINS S=DIFF[18] CO=carry[19] A=A[18] B=n61 CI=carry[18]
XU2_2 FA1 $PINS S=DIFF[2] CO=carry[3] A=A[2] B=n45 CI=carry[2]
XU2_1 FA1 $PINS S=DIFF[1] CO=carry[2] A=A[1] B=n44 CI=carry[1]
XU2_31 XOR3 $PINS O=DIFF[31] I1=A[31] I2=n74 I3=carry[31]
XU1 XOR3 $PINS O=DIFF[25] I1=n68 I2=A[25] I3=carry[25]
XU2 XOR3 $PINS O=DIFF[26] I1=n69 I2=A[26] I3=n14
XU3 XOR3 $PINS O=DIFF[14] I1=A[14] I2=n57 I3=carry[14]
XU4 XOR3 $PINS O=DIFF[16] I1=A[16] I2=n59 I3=carry[16]
XU5 ND2 $PINS O=n19 I1=carry[25] I2=A[25]
XU6 ND2 $PINS O=n18 I1=carry[25] I2=n68
XU7 ND3P $PINS O=carry[25] I1=n4 I2=n5 I3=n6
XU8 ND2 $PINS O=n26 I1=n14 I2=A[26]
XU9 ND2 $PINS O=n25 I1=n14 I2=n69
XU10 ND3P $PINS O=carry[30] I1=n22 I2=n23 I3=n24
XU11 XOR3 $PINS O=DIFF[28] I1=n71 I2=A[28] I3=carry[28]
XU12 ND2 $PINS O=n1 I1=carry[28] I2=n71
XU13 ND2 $PINS O=n2 I1=carry[28] I2=A[28]
XU14 ND2 $PINS O=n3 I1=n71 I2=A[28]
XU15 ND3P $PINS O=carry[29] I1=n1 I2=n2 I3=n3
XU16 ND3P $PINS O=carry[14] I1=n16 I2=n15 I3=n17
XU17 ND3P $PINS O=carry[16] I1=n34 I2=n33 I3=n32
XU18 ND2 $PINS O=n28 I1=A[14] I2=n57
XU19 ND2 $PINS O=n7 I1=A[8] I2=B[8]
XU20 ND2 $PINS O=n35 I1=A[16] I2=n59
XU22 INV1S $PINS O=n56 I=B[13]
XU23 INV1S $PINS O=n68 I=B[25]
XU24 INV1S $PINS O=n72 I=B[29]
XU25 INV1S $PINS O=n69 I=B[26]
XU26 XOR3 $PINS O=DIFF[8] I1=A[8] I2=B[8] I3=carry[8]
XU28 XOR3 $PINS O=DIFF[13] I1=n56 I2=A[13] I3=carry[13]
XU32 INV1S $PINS O=n42 I=A[0]
XU33 XOR3 $PINS O=DIFF[24] I1=n67 I2=A[24] I3=FE_OCPN657_carry_24
XU34 ND2 $PINS O=n4 I1=carry[24] I2=n67
XU35 ND2 $PINS O=n5 I1=carry[24] I2=A[24]
XU36 ND2 $PINS O=n6 I1=n67 I2=A[24]
XU37 INV1S $PINS O=n43 I=FE_OCPN352_n310
XU38 ND2 $PINS O=n8 I1=A[8] I2=carry[8]
XU39 ND2 $PINS O=n9 I1=B[8] I2=carry[8]
XU40 ND3P $PINS O=carry[9] I1=n9 I2=n8 I3=n7
XU41 XOR2HS $PINS O=n10 I1=A[9] I2=FE_OFN97_raw_prime_9
XU42 XOR2HS $PINS O=DIFF[9] I1=n10 I2=carry[9]
XU43 ND2S $PINS O=n11 I1=A[9] I2=FE_OFN97_raw_prime_9
XU44 ND2 $PINS O=n12 I1=A[9] I2=carry[9]
XU45 ND2 $PINS O=n13 I1=FE_OFN97_raw_prime_9 I2=carry[9]
XU46 ND2 $PINS O=n15 I1=carry[13] I2=n56
XU47 ND2 $PINS O=n16 I1=carry[13] I2=A[13]
XU48 ND2S $PINS O=n17 I1=n56 I2=A[13]
XU49 ND2S $PINS O=n20 I1=n68 I2=A[25]
XU50 XOR2HS $PINS O=n21 I1=n72 I2=A[29]
XU51 XOR2HS $PINS O=DIFF[29] I1=carry[29] I2=n21
XU52 ND2 $PINS O=n22 I1=carry[29] I2=n72
XU53 ND2 $PINS O=n23 I1=carry[29] I2=A[29]
XU54 ND2 $PINS O=n24 I1=n72 I2=A[29]
XU55 ND2S $PINS O=n27 I1=n69 I2=A[26]
XU56 ND2 $PINS O=n29 I1=A[14] I2=carry[14]
XU57 ND2 $PINS O=n30 I1=n57 I2=carry[14]
XU58 ND3P $PINS O=carry[15] I1=n30 I2=n29 I3=n28
XU59 XOR2HS $PINS O=n31 I1=A[15] I2=n58
XU60 XOR2HS $PINS O=DIFF[15] I1=n31 I2=carry[15]
XU61 ND2S $PINS O=n32 I1=A[15] I2=n58
XU62 ND2 $PINS O=n33 I1=A[15] I2=carry[15]
XU63 ND2 $PINS O=n34 I1=n58 I2=carry[15]
XU64 ND2 $PINS O=n36 I1=A[16] I2=carry[16]
XU65 ND2 $PINS O=n37 I1=n59 I2=carry[16]
XU66 ND3P $PINS O=carry[17] I1=n37 I2=n36 I3=n35
XU67 XOR2HS $PINS O=n38 I1=A[17] I2=n60
XU68 XOR2HS $PINS O=DIFF[17] I1=n38 I2=carry[17]
XU69 ND2S $PINS O=n39 I1=A[17] I2=n60
XU70 ND2 $PINS O=n40 I1=A[17] I2=carry[17]
XU71 ND2 $PINS O=n41 I1=n60 I2=carry[17]
XU74 INV1S $PINS O=n74 I=B[31]
XU76 INV1S $PINS O=n57 I=B[14]
XU77 INV1S $PINS O=n73 I=B[30]
XU78 INV1S $PINS O=n59 I=B[16]
XU80 INV1S $PINS O=n71 I=B[28]
XU81 INV1S $PINS O=n55 I=B[12]
XU82 INV1S $PINS O=n63 I=B[20]
XU83 INV1S $PINS O=n67 I=B[24]
XU84 INV1S $PINS O=n65 I=B[22]
XU85 INV1S $PINS O=n61 I=B[18]
XU86 INV1S $PINS O=n53 I=B[10]
XU88 INV1S $PINS O=n70 I=B[27]
XU89 INV1S $PINS O=n66 I=B[23]
XU90 INV1S $PINS O=n64 I=B[21]
XU91 INV1S $PINS O=n62 I=B[19]
XU92 INV1S $PINS O=n60 I=B[17]
XU93 INV1S $PINS O=n58 I=B[15]
XU94 INV1S $PINS O=n54 I=B[11]
XU98 XNR2HS $PINS O=DIFF[0] I1=n43 I2=A[0]
XU99 ND2 $PINS O=carry[1] I1=B[0] I2=n42
.ENDS

.SUBCKT Domain_Transfer_1_DW_cmp_4 A[31] A[30] A[29] A[28] A[27] A[26] A[25]
+ A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12]
+ A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] TC GE_LT GE_GT_EQ GE_LT_GT_LE EQ_NE FE_OFN134_n312
+ FE_OFN315_raw_prime_15 p1
XFE_RC_2400_0 AO12 $PINS O=n331 A1=n339 B1=n327 B2=n340
XFE_RC_2394_0 AO12 $PINS O=n292 A1=n301 B1=n300 B2=n302
XFE_OFC126_raw_prime_8 INV1S $PINS O=FE_OFN92_raw_prime_8 I=B[8]
XU161 INV1S $PINS O=n242 I=B[18]
XU162 INV1S $PINS O=n240 I=B[14]
XU163 INV1S $PINS O=n248 I=B[30]
XU164 INV1S $PINS O=n244 I=B[22]
XU165 INV1S $PINS O=n251 I=n317
XU166 INV1S $PINS O=n239 I=B[12]
XU167 INV1S $PINS O=n234 I=B[2]
XU168 INV1S $PINS O=n236 I=B[6]
XU169 INV1S $PINS O=n235 I=B[4]
XU170 INV1S $PINS O=n243 I=B[20]
XU171 INV1S $PINS O=n238 I=B[10]
XU172 INV1S $PINS O=n237 I=FE_OFN92_raw_prime_8
XU173 INV1S $PINS O=n246 I=B[26]
XU174 INV1S $PINS O=n245 I=B[24]
XU175 INV1S $PINS O=n241 I=B[16]
XU176 INV1S $PINS O=n247 I=B[28]
XU177 INV1S $PINS O=n260 I=A[1]
XU178 INV1S $PINS O=n265 I=n283
XU179 MAOI1S $PINS O=n323 A1=A[2] A2=n230 B1=B[3] B2=n259
XU180 AN2 $PINS O=n230 I1=n325 I2=n234
XU181 MAOI1 $PINS O=n335 A1=A[14] A2=n231 B1=B[15] B2=n256
XU182 AN2 $PINS O=n231 I1=n338 I2=n240
XU183 MAOI1 $PINS O=n296 A1=A[30] A2=n232 B1=B[31] B2=n257
XU184 AN2 $PINS O=n232 I1=n299 I2=n248
XU185 INV1S $PINS O=n250 I=A[11]
XU186 INV1S $PINS O=n249 I=A[9]
XU187 INV1S $PINS O=n262 I=A[27]
XU188 INV1S $PINS O=n261 I=A[25]
XU189 INV1S $PINS O=n259 I=A[3]
XU190 INV1S $PINS O=n256 I=A[15]
XU191 INV1S $PINS O=n252 I=A[7]
XU192 INV1S $PINS O=n266 I=A[17]
XU193 INV1S $PINS O=n255 I=A[13]
XU194 INV1S $PINS O=n258 I=A[29]
XU195 INV1S $PINS O=n254 I=A[5]
XU196 INV1S $PINS O=n267 I=A[19]
XU197 INV1S $PINS O=n263 I=A[21]
XU198 INV1S $PINS O=n264 I=A[23]
XU199 INV1S $PINS O=n257 I=A[31]
XU200 INV1S $PINS O=n253 I=A[6]
XU201 INV1S $PINS O=n233 I=B[0]
XU202 MOAI1S $PINS O=GE_LT_GT_LE A1=n268 A2=n269 B1=n270 B2=n271
XU203 ND3 $PINS O=n271 I1=n272 I2=n273 I3=n274
XU204 OAI22S $PINS O=n273 A1=n275 A2=n276 B1=n276 B2=n277
XU205 MOAI1S $PINS O=n277 A1=B[21] A2=n263 B1=A[20] B2=n278
XU206 AN2 $PINS O=n278 I1=n279 I2=n243
XU207 MOAI1S $PINS O=n276 A1=B[23] A2=n264 B1=A[22] B2=n280
XU208 AN2 $PINS O=n280 I1=n281 I2=n244
XU209 OAI112HS $PINS O=n272 A1=n284 B1=n285 C1=n282 C2=n283
XU210 OAI112HS $PINS O=n284 A1=n286 B1=n265 C1=B[17] C2=n266
XU211 ND3 $PINS O=n286 I1=n287 I2=n241 I3=A[16]
XU212 MOAI1S $PINS O=n283 A1=B[19] A2=n267 B1=A[18] B2=n288
XU213 AN2 $PINS O=n288 I1=n289 I2=n242
XU214 ND2 $PINS O=n270 I1=n274 I2=n290
XU215 AOI22S $PINS O=n274 A1=n291 A2=n292 B1=n293 B2=n294
XU216 OAI112HS $PINS O=n294 A1=n295 B1=n296 C1=B[29] C2=n258
XU217 ND3 $PINS O=n295 I1=n297 I2=n247 I3=A[28]
XU218 OR2B1S $PINS O=n293 I1=n298 B1=n296
XU220 MOAI1S $PINS O=n302 A1=B[25] A2=n261 B1=A[24] B2=n303
XU221 AN2 $PINS O=n303 I1=n304 I2=n245
XU222 MOAI1S $PINS O=n301 A1=B[27] A2=n262 B1=A[26] B2=n305
XU223 AN2 $PINS O=n305 I1=n306 I2=n246
XU224 OR3B2 $PINS O=n269 I1=n290 B1=n285 B2=n282
XU225 OA12 $PINS O=n282 A1=n289 B1=A[18] B2=n242
XU226 ND2 $PINS O=n289 I1=B[19] I2=n267
XU227 OA112 $PINS O=n285 A1=n279 B1=n275 C1=A[20] C2=n243
XU228 OA12 $PINS O=n275 A1=n281 B1=A[22] B2=n244
XU229 ND2 $PINS O=n281 I1=B[23] I2=n264
XU230 ND2 $PINS O=n279 I1=B[21] I2=n263
XU231 ND3 $PINS O=n290 I1=n300 I2=n291 I3=n307
XU232 OA12 $PINS O=n307 A1=n304 B1=A[24] B2=n245
XU233 ND2 $PINS O=n304 I1=B[25] I2=n261
XU234 OA112 $PINS O=n291 A1=n297 B1=n298 C1=A[28] C2=n247
XU235 OA12 $PINS O=n298 A1=n299 B1=A[30] B2=n248
XU236 ND2 $PINS O=n299 I1=B[31] I2=n257
XU237 ND2 $PINS O=n297 I1=B[29] I2=n258
XU238 OA12 $PINS O=n300 A1=n306 B1=A[26] B2=n246
XU239 ND2 $PINS O=n306 I1=B[27] I2=n262
XU240 OAI112HS $PINS O=n268 A1=n287 B1=n308 C1=A[16] C2=n241
XU241 AOI22S $PINS O=n308 A1=n309 A2=n310 B1=n311 B2=n309
XU242 AOI13HS $PINS O=n311 A1=n314 B1=n251 B2=n312 B3=n313
XU243 AOI22S $PINS O=n314 A1=n315 A2=n316 B1=n316 B2=n317
XU244 OA22 $PINS O=n316 A1=B[7] A2=n252 B1=n253 B2=n318
XU245 ND2 $PINS O=n318 I1=n319 I2=n236
XU246 AOI13HS $PINS O=n315 A1=n321 B1=n320 B2=n235 B3=A[4]
XU247 NR2 $PINS O=n321 I1=B[5] I2=n254
XU248 OA112 $PINS O=n313 A1=n320 B1=n322 C1=p1 C2=n235
XU249 ND2 $PINS O=n322 I1=n323 I2=n324
XU250 OAI12HS $PINS O=n324 A1=n325 B1=A[2] B2=n234
XU251 ND2 $PINS O=n320 I1=B[5] I2=n254
XU252 OAI112HS $PINS O=n312 A1=n326 B1=n323 C1=FE_OFN134_n312 C2=n260
XU253 ND2 $PINS O=n325 I1=B[3] I2=n259
XU254 MOAI1S $PINS O=n326 A1=A[0] A2=n233 B1=n260 B2=FE_OFN134_n312
XU255 OAI12HS $PINS O=n317 A1=n319 B1=A[6] B2=n236
XU256 ND2 $PINS O=n319 I1=B[7] I2=n252
XU257 ND3 $PINS O=n310 I1=n327 I2=n328 I3=n329
XU258 OA12 $PINS O=n329 A1=n330 B1=A[8] B2=n237
XU259 AOI22S $PINS O=n309 A1=n328 A2=n331 B1=n332 B2=n333
XU260 OAI112HS $PINS O=n333 A1=n334 B1=n335 C1=B[13] C2=n255
XU261 ND3 $PINS O=n334 I1=n336 I2=n239 I3=A[12]
XU262 OR2B1S $PINS O=n332 I1=n337 B1=n335
XU264 MOAI1S $PINS O=n340 A1=B[9] A2=n249 B1=A[8] B2=n341
XU265 AN2 $PINS O=n341 I1=n330 I2=n237
XU266 ND2 $PINS O=n330 I1=B[9] I2=n249
XU267 MOAI1S $PINS O=n339 A1=B[11] A2=n250 B1=A[10] B2=n342
XU268 AN2 $PINS O=n342 I1=n343 I2=n238
XU269 OA12 $PINS O=n327 A1=n343 B1=A[10] B2=n238
XU270 ND2 $PINS O=n343 I1=B[11] I2=n250
XU271 OA112 $PINS O=n328 A1=n336 B1=n337 C1=A[12] C2=n239
XU272 OA12 $PINS O=n337 A1=n338 B1=A[14] B2=n240
XU273 ND2 $PINS O=n338 I1=FE_OFN315_raw_prime_15 I2=n256
XU274 ND2 $PINS O=n336 I1=B[13] I2=n255
XU275 ND2 $PINS O=n287 I1=B[17] I2=n266
.ENDS

.SUBCKT Domain_Transfer_1_DW01_sub_5 A[31] A[30] A[29] A[28] A[27] A[26] A[25]
+ A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12]
+ A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] CI DIFF[31] DIFF[30] DIFF[29] DIFF[28] DIFF[27] DIFF[26]
+ DIFF[25] DIFF[24] DIFF[23] DIFF[22] DIFF[21] DIFF[20] DIFF[19] DIFF[18]
+ DIFF[17] DIFF[16] DIFF[15] DIFF[14] DIFF[13] DIFF[12] DIFF[11] DIFF[10]
+ DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3] DIFF[2] DIFF[1]
+ DIFF[0] CO p1
XFE_OCPC658_carry_21 BUF1S $PINS O=FE_OCPN658_carry_21 I=carry[21]
XFE_OCPC458_carry_27 BUF1S $PINS O=FE_OCPN458_carry_27 I=carry[27]
XFE_RC_2260_0 OR2 $PINS O=FE_RN_1551_0 I1=FE_RN_1517_0 I2=FE_RN_1516_0
XFE_RC_2259_0 ND2P $PINS O=carry[9] I1=FE_RN_1522_0 I2=FE_RN_1551_0
XFE_RC_2218_0 INV1S $PINS O=FE_RN_1514_0 I=FE_RN_1521_0
XFE_RC_2217_0 AOI12HS $PINS O=FE_RN_1515_0 A1=FE_RN_1514_0 B1=A[8] B2=n61
XFE_RC_2216_0 INV1S $PINS O=FE_RN_1516_0 I=A[8]
XFE_RC_2215_0 INV1S $PINS O=FE_RN_1517_0 I=n61
XFE_RC_2214_0 AOI22S $PINS O=FE_RN_1518_0 A1=A[8] A2=FE_RN_1517_0
+ B1=FE_RN_1516_0 B2=n61
XFE_RC_2213_0 MXL2HS $PINS OB=DIFF[8] S=carry[8] A=FE_RN_1518_0 B=FE_RN_1515_0
XFE_RC_2210_0 OR2 $PINS O=FE_RN_1521_0 I1=n61 I2=A[8]
XFE_RC_2209_0 ND2 $PINS O=FE_RN_1522_0 I1=FE_RN_1521_0 I2=carry[8]
XFE_RC_2147_0 OR2 $PINS O=FE_RN_1469_0 I1=FE_RN_1381_0 I2=FE_RN_1380_0
XFE_RC_2146_0 ND2P $PINS O=carry[19] I1=FE_RN_1386_0 I2=FE_RN_1469_0
XFE_RC_2035_0 INV1S $PINS O=FE_RN_1378_0 I=FE_RN_1385_0
XFE_RC_2034_0 AOI12HS $PINS O=FE_RN_1379_0 A1=FE_RN_1378_0 B1=A[18] B2=n71
XFE_RC_2033_0 INV1S $PINS O=FE_RN_1380_0 I=n71
XFE_RC_2032_0 INV1S $PINS O=FE_RN_1381_0 I=A[18]
XFE_RC_2031_0 AOI22S $PINS O=FE_RN_1382_0 A1=FE_RN_1381_0 A2=n71 B1=A[18]
+ B2=FE_RN_1380_0
XFE_RC_2030_0 MXL2HS $PINS OB=DIFF[18] S=carry[18] A=FE_RN_1382_0
+ B=FE_RN_1379_0
XFE_RC_2027_0 OR2 $PINS O=FE_RN_1385_0 I1=n71 I2=A[18]
XFE_RC_2026_0 ND2 $PINS O=FE_RN_1386_0 I1=FE_RN_1385_0 I2=carry[18]
XFE_RC_1831_0 ND2 $PINS O=FE_RN_1226_0 I1=A[19] I2=n72
XFE_RC_1830_0 AN2S $PINS O=FE_RN_1227_0 I1=FE_RN_1230_0 I2=FE_RN_1226_0
XFE_RC_1829_0 XNR2HS $PINS O=FE_RN_1228_0 I1=n72 I2=A[19]
XFE_RC_1828_0 MXL2HS $PINS OB=DIFF[19] S=carry[19] A=FE_RN_1228_0
+ B=FE_RN_1227_0
XFE_RC_1826_0 OR2 $PINS O=FE_RN_1230_0 I1=n72 I2=A[19]
XFE_RC_1825_0 ND2 $PINS O=FE_RN_1231_0 I1=FE_RN_1230_0 I2=carry[19]
XFE_RC_1824_0 ND2P $PINS O=carry[20] I1=FE_RN_1231_0 I2=FE_RN_1226_0
XFE_RC_1622_0 INV1S $PINS O=FE_RN_1073_0 I=carry[20]
XFE_RC_1621_0 XOR2HS $PINS O=FE_RN_1074_0 I1=n73 I2=A[20]
XFE_RC_1620_0 INV1S $PINS O=FE_RN_1075_0 I=FE_RN_1074_0
XFE_RC_1619_0 MXL2HS $PINS OB=DIFF[20] S=FE_RN_1075_0 A=carry[20]
+ B=FE_RN_1073_0
XFE_RC_1618_0 NR2 $PINS O=FE_RN_1076_0 I1=n73 I2=A[20]
XFE_RC_1616_0 MOAI1 $PINS O=carry[21] A1=FE_RN_1073_0 A2=FE_RN_1076_0 B1=A[20]
+ B2=n73
XFE_RC_1378_0 ND2 $PINS O=FE_RN_888_0 I1=A[21] I2=n74
XFE_RC_1377_0 AN2S $PINS O=FE_RN_889_0 I1=FE_RN_892_0 I2=FE_RN_888_0
XFE_RC_1376_0 XNR2HS $PINS O=FE_RN_890_0 I1=n74 I2=A[21]
XFE_RC_1375_0 MXL2HS $PINS OB=DIFF[21] S=FE_OCPN658_carry_21 A=FE_RN_890_0
+ B=FE_RN_889_0
XFE_RC_1373_0 OR2 $PINS O=FE_RN_892_0 I1=n74 I2=A[21]
XFE_RC_1372_0 ND2 $PINS O=FE_RN_893_0 I1=FE_RN_892_0 I2=carry[21]
XFE_RC_1371_0 ND2P $PINS O=carry[22] I1=FE_RN_893_0 I2=FE_RN_888_0
XFE_RC_1119_0 INV1S $PINS O=FE_RN_711_0 I=n36
XFE_RC_1118_0 ND3P $PINS O=carry[4] I1=n41 I2=n42 I3=FE_RN_711_0
XFE_RC_1117_0 ND2 $PINS O=FE_RN_705_0 I1=A[9] I2=n62
XFE_RC_1116_0 AN2S $PINS O=FE_RN_706_0 I1=FE_RN_709_0 I2=FE_RN_705_0
XFE_RC_1115_0 XNR2HS $PINS O=FE_RN_707_0 I1=n62 I2=A[9]
XFE_RC_1114_0 MXL2HS $PINS OB=DIFF[9] S=carry[9] A=FE_RN_707_0 B=FE_RN_706_0
XFE_RC_1112_0 OR2 $PINS O=FE_RN_709_0 I1=n62 I2=A[9]
XFE_RC_1111_0 ND2 $PINS O=FE_RN_710_0 I1=FE_RN_709_0 I2=carry[9]
XFE_RC_1110_0 ND2P $PINS O=carry[10] I1=FE_RN_710_0 I2=FE_RN_705_0
XFE_RC_924_0 INV1S $PINS O=FE_RN_559_0 I=FE_RN_560_0
XFE_RC_923_0 XOR2HS $PINS O=FE_RN_560_0 I1=n57 I2=A[4]
XFE_RC_921_0 ND2 $PINS O=FE_RN_562_0 I1=FE_RN_559_0 I2=carry[4]
XFE_RC_920_0 OAI12HS $PINS O=DIFF[4] A1=FE_RN_562_0 B1=FE_RN_559_0 B2=carry[4]
XFE_RC_919_0 ND2 $PINS O=FE_RN_563_0 I1=A[4] I2=n57
XFE_RC_918_0 OR2 $PINS O=FE_RN_564_0 I1=n57 I2=A[4]
XFE_RC_917_0 ND2 $PINS O=FE_RN_565_0 I1=carry[4] I2=FE_RN_564_0
XFE_RC_916_0 ND2P $PINS O=carry[5] I1=FE_RN_565_0 I2=FE_RN_563_0
XFE_RC_757_0 ND2 $PINS O=FE_RN_438_0 I1=A[10] I2=n63
XFE_RC_756_0 AN2 $PINS O=FE_RN_439_0 I1=FE_RN_442_0 I2=FE_RN_438_0
XFE_RC_755_0 XNR2HS $PINS O=FE_RN_440_0 I1=n63 I2=A[10]
XFE_RC_754_0 MXL2HS $PINS OB=DIFF[10] S=carry[10] A=FE_RN_440_0 B=FE_RN_439_0
XFE_RC_752_0 OR2 $PINS O=FE_RN_442_0 I1=n63 I2=A[10]
XFE_RC_751_0 ND2 $PINS O=FE_RN_443_0 I1=FE_RN_442_0 I2=carry[10]
XFE_RC_750_0 ND2P $PINS O=carry[11] I1=FE_RN_443_0 I2=FE_RN_438_0
XFE_RC_677_0 OR2 $PINS O=FE_RN_387_0 I1=FE_RN_290_0 I2=FE_RN_293_0
XFE_RC_676_0 ND2P $PINS O=carry[15] I1=FE_RN_297_0 I2=FE_RN_387_0
XFE_RC_550_0 ND3P $PINS O=carry[13] I1=n31 I2=n30 I3=n29
XFE_RC_549_0 INV1S $PINS O=FE_RN_288_0 I=FE_RN_296_0
XFE_RC_548_0 AOI12HS $PINS O=FE_RN_289_0 A1=FE_RN_288_0 B1=A[14] B2=n67
XFE_RC_547_0 INV1S $PINS O=FE_RN_290_0 I=A[14]
XFE_RC_545_0 MAOI1 $PINS O=FE_RN_292_0 A1=FE_RN_290_0 A2=n67 B1=n67
+ B2=FE_RN_290_0
XFE_RC_544_0 MXL2HS $PINS OB=DIFF[14] S=carry[14] A=FE_RN_292_0 B=FE_RN_289_0
XFE_RC_543_0 INV1S $PINS O=FE_RN_293_0 I=n67
XFE_RC_540_0 OR2B1S $PINS O=FE_RN_296_0 I1=n67 B1=FE_RN_290_0
XFE_RC_539_0 ND2 $PINS O=FE_RN_297_0 I1=FE_RN_296_0 I2=carry[14]
XFE_RC_376_0 ND3P $PINS O=carry[12] I1=n2 I2=n1 I3=n3
XFE_RC_365_0 ND2 $PINS O=FE_RN_164_0 I1=A[24] I2=n77
XFE_RC_364_0 AN2 $PINS O=FE_RN_165_0 I1=FE_RN_168_0 I2=FE_RN_164_0
XFE_RC_363_0 XNR2HS $PINS O=FE_RN_166_0 I1=n77 I2=A[24]
XFE_RC_362_0 MXL2HS $PINS OB=DIFF[24] S=carry[24] A=FE_RN_166_0 B=FE_RN_165_0
XFE_RC_360_0 OR2S $PINS O=FE_RN_168_0 I1=n77 I2=A[24]
XFE_RC_359_0 ND2 $PINS O=FE_RN_169_0 I1=FE_RN_168_0 I2=carry[24]
XFE_RC_358_0 ND2P $PINS O=carry[25] I1=FE_RN_169_0 I2=FE_RN_164_0
XFE_RC_314_0 ND3P $PINS O=carry[8] I1=n28 I2=n27 I3=n26
XFE_RC_310_0 ND3P $PINS O=carry[18] I1=n50 I2=n51 I3=n8
XFE_RC_238_0 ND3P $PINS O=carry[28] I1=n21 I2=n20 I3=n19
XFE_RC_236_0 ND3P $PINS O=carry[14] I1=n34 I2=n35 I3=n33
XFE_OFC297_raw1_0 INV1S $PINS O=n52 I=A[0]
XFE_OFC278_raw_prime_3 INV1S $PINS O=n56 I=B[3]
XFE_OFC218_raw_prime_5 INV1S $PINS O=n58 I=B[5]
XFE_OFC195_raw_prime_9 INV1S $PINS O=n62 I=B[9]
XFE_OFC174_raw_prime_10 INV1S $PINS O=n63 I=B[10]
XFE_OFC165_raw_prime_7 INV1S $PINS O=n60 I=B[7]
XFE_OFC143_raw_prime_6 INV1S $PINS O=n59 I=B[6]
XFE_OFC131_raw_prime_2 INV1S $PINS O=n55 I=B[2]
XFE_OFC116_raw_prime_8 INV1S $PINS O=n61 I=B[8]
XFE_OFC109_n312 INV1S $PINS O=n54 I=B[1]
XFE_OFC93_raw_prime_4 INV1S $PINS O=n57 I=B[4]
XU2_30 FA1 $PINS S=DIFF[30] CO=carry[31] A=A[30] B=n83 CI=carry[30]
XU2_29 FA1 $PINS S=DIFF[29] CO=carry[30] A=A[29] B=n82 CI=carry[29]
XU2_28 FA1 $PINS S=DIFF[28] CO=carry[29] A=A[28] B=n81 CI=carry[28]
XU2_23 FA1 $PINS S=DIFF[23] CO=carry[24] A=A[23] B=n76 CI=carry[23]
XU2_22 FA1 $PINS S=DIFF[22] CO=carry[23] A=A[22] B=n75 CI=carry[22]
XU2_31 XOR3S $PINS O=DIFF[31] I1=A[31] I2=n84 I3=carry[31]
XU1 XOR3 $PINS O=DIFF[11] I1=n64 I2=A[11] I3=carry[11]
XU2 ND2P $PINS O=n1 I1=carry[11] I2=n64
XU3 ND2 $PINS O=n2 I1=carry[11] I2=A[11]
XU4 ND2 $PINS O=n3 I1=n64 I2=A[11]
XU6 ND2P $PINS O=carry[1] I1=p1 I2=n52
XU7 ND2 $PINS O=n22 I1=A[6] I2=n59
XU8 ND2 $PINS O=n29 I1=A[12] I2=n65
XU9 ND2 $PINS O=n46 I1=A[16] I2=n69
XU10 ND2 $PINS O=n15 I1=A[26] I2=n79
XU12 ND2 $PINS O=n37 I1=A[2] I2=n55
XU13 INV1S $PINS O=n68 I=B[15]
XU14 INV1S $PINS O=n78 I=B[25]
XU16 XOR3 $PINS O=DIFF[5] I1=n58 I2=A[5] I3=carry[5]
XU18 XOR3 $PINS O=DIFF[6] I1=A[6] I2=n59 I3=carry[6]
XU19 XOR3 $PINS O=DIFF[12] I1=A[12] I2=n65 I3=carry[12]
XU21 XOR3 $PINS O=DIFF[15] I1=n68 I2=A[15] I3=carry[15]
XU22 XOR3 $PINS O=DIFF[16] I1=A[16] I2=n69 I3=carry[16]
XU24 XOR3 $PINS O=DIFF[26] I1=A[26] I2=n79 I3=carry[26]
XU25 XOR3 $PINS O=DIFF[25] I1=n78 I2=A[25] I3=carry[25]
XU27 XOR2HS $PINS O=n4 I1=carry[1] I2=A[1]
XU28 XOR2HS $PINS O=DIFF[1] I1=n54 I2=n4
XU29 ND2 $PINS O=n5 I1=n54 I2=carry[1]
XU30 ND2 $PINS O=n6 I1=n54 I2=A[1]
XU31 ND2 $PINS O=n7 I1=carry[1] I2=A[1]
XU32 ND3P $PINS O=carry[2] I1=n5 I2=n6 I3=n7
XU34 XOR3 $PINS O=DIFF[2] I1=A[2] I2=n55 I3=carry[2]
XU35 ND3P $PINS O=carry[16] I1=n43 I2=n44 I3=n45
XU36 ND2 $PINS O=n8 I1=A[17] I2=n70
XU37 ND2 $PINS O=n9 I1=carry[5] I2=n58
XU38 ND2 $PINS O=n10 I1=carry[5] I2=A[5]
XU39 ND2 $PINS O=n11 I1=n58 I2=A[5]
XU40 ND3P $PINS O=carry[6] I1=n9 I2=n10 I3=n11
XU41 INV1S $PINS O=n53 I=B[0]
XU42 ND2 $PINS O=n12 I1=carry[25] I2=n78
XU43 ND2 $PINS O=n13 I1=carry[25] I2=A[25]
XU44 ND2S $PINS O=n14 I1=n78 I2=A[25]
XU45 ND3P $PINS O=carry[26] I1=n13 I2=n12 I3=n14
XU46 ND2 $PINS O=n16 I1=A[26] I2=carry[26]
XU47 ND2 $PINS O=n17 I1=n79 I2=carry[26]
XU48 ND3P $PINS O=carry[27] I1=n17 I2=n16 I3=n15
XU49 XOR2HS $PINS O=n18 I1=A[27] I2=n80
XU50 XOR2HS $PINS O=DIFF[27] I1=n18 I2=FE_OCPN458_carry_27
XU51 ND2S $PINS O=n19 I1=A[27] I2=n80
XU52 ND2 $PINS O=n20 I1=A[27] I2=carry[27]
XU53 ND2 $PINS O=n21 I1=n80 I2=carry[27]
XU54 ND2 $PINS O=n23 I1=A[6] I2=carry[6]
XU55 ND2 $PINS O=n24 I1=n59 I2=carry[6]
XU56 ND3P $PINS O=carry[7] I1=n24 I2=n23 I3=n22
XU57 XOR2HS $PINS O=n25 I1=A[7] I2=n60
XU58 XOR2HS $PINS O=DIFF[7] I1=n25 I2=carry[7]
XU59 ND2S $PINS O=n26 I1=A[7] I2=n60
XU60 ND2 $PINS O=n27 I1=A[7] I2=carry[7]
XU61 ND2 $PINS O=n28 I1=n60 I2=carry[7]
XU62 ND2 $PINS O=n30 I1=A[12] I2=carry[12]
XU63 ND2 $PINS O=n31 I1=n65 I2=carry[12]
XU65 XOR2HS $PINS O=n32 I1=A[13] I2=n66
XU66 XOR2HS $PINS O=DIFF[13] I1=n32 I2=carry[13]
XU67 ND2S $PINS O=n33 I1=A[13] I2=n66
XU68 ND2 $PINS O=n34 I1=A[13] I2=carry[13]
XU69 ND2 $PINS O=n35 I1=n66 I2=carry[13]
XU71 AN2 $PINS O=n36 I1=A[3] I2=n56
XU72 ND2 $PINS O=n38 I1=A[2] I2=carry[2]
XU73 ND2 $PINS O=n39 I1=n55 I2=carry[2]
XU74 ND3P $PINS O=carry[3] I1=n39 I2=n38 I3=n37
XU75 XOR2HS $PINS O=n40 I1=A[3] I2=n56
XU76 XOR2HS $PINS O=DIFF[3] I1=n40 I2=carry[3]
XU77 ND2 $PINS O=n41 I1=A[3] I2=carry[3]
XU78 ND2 $PINS O=n42 I1=n56 I2=carry[3]
XU79 ND2 $PINS O=n43 I1=carry[15] I2=n68
XU80 ND2 $PINS O=n44 I1=carry[15] I2=A[15]
XU81 ND2S $PINS O=n45 I1=n68 I2=A[15]
XU83 ND2 $PINS O=n47 I1=carry[16] I2=A[16]
XU84 ND2 $PINS O=n48 I1=n69 I2=carry[16]
XU85 ND3P $PINS O=carry[17] I1=n48 I2=n47 I3=n46
XU86 XOR2HS $PINS O=n49 I1=A[17] I2=n70
XU87 XOR2HS $PINS O=DIFF[17] I1=n49 I2=carry[17]
XU88 ND2 $PINS O=n50 I1=A[17] I2=carry[17]
XU89 ND2 $PINS O=n51 I1=carry[17] I2=n70
XU91 INV1S $PINS O=n84 I=B[31]
XU93 INV1S $PINS O=n67 I=B[14]
XU94 INV1S $PINS O=n83 I=B[30]
XU95 INV1S $PINS O=n69 I=B[16]
XU97 INV1S $PINS O=n81 I=B[28]
XU98 INV1S $PINS O=n65 I=B[12]
XU99 INV1S $PINS O=n73 I=B[20]
XU100 INV1S $PINS O=n79 I=B[26]
XU101 INV1S $PINS O=n77 I=B[24]
XU102 INV1S $PINS O=n75 I=B[22]
XU103 INV1S $PINS O=n71 I=B[18]
XU106 INV1S $PINS O=n80 I=B[27]
XU107 INV1S $PINS O=n76 I=B[23]
XU108 INV1S $PINS O=n74 I=B[21]
XU109 INV1S $PINS O=n72 I=B[19]
XU110 INV1S $PINS O=n70 I=B[17]
XU111 INV1S $PINS O=n66 I=B[13]
XU112 INV1S $PINS O=n64 I=B[11]
XU115 INV1S $PINS O=n82 I=B[29]
XU116 XNR2HS $PINS O=DIFF[0] I1=n53 I2=A[0]
.ENDS

.SUBCKT Domain_Transfer_1_DW_cmp_5 A[31] A[30] A[29] A[28] A[27] A[26] A[25]
+ A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12]
+ A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] TC GE_LT GE_GT_EQ GE_LT_GT_LE EQ_NE
XFE_RC_2396_0 AO12 $PINS O=n331 A1=n339 B1=n327 B2=n340
XFE_RC_2395_0 AO12 $PINS O=n292 A1=n301 B1=n300 B2=n302
XU161 INV1S $PINS O=n242 I=B[18]
XU162 INV1S $PINS O=n240 I=B[14]
XU163 INV1S $PINS O=n248 I=B[30]
XU164 INV1S $PINS O=n244 I=B[22]
XU165 INV1S $PINS O=n251 I=n317
XU166 INV1S $PINS O=n239 I=B[12]
XU167 INV1S $PINS O=n234 I=B[2]
XU168 INV1S $PINS O=n236 I=B[6]
XU169 INV1S $PINS O=n247 I=B[28]
XU170 INV1S $PINS O=n235 I=B[4]
XU171 INV1S $PINS O=n243 I=B[20]
XU172 INV1S $PINS O=n238 I=B[10]
XU173 INV1S $PINS O=n237 I=B[8]
XU174 INV1S $PINS O=n246 I=B[26]
XU175 INV1S $PINS O=n245 I=B[24]
XU176 INV1S $PINS O=n241 I=B[16]
XU177 INV1S $PINS O=n260 I=A[1]
XU178 INV1S $PINS O=n265 I=n283
XU179 MAOI1S $PINS O=n323 A1=A[2] A2=n230 B1=B[3] B2=n259
XU180 AN2 $PINS O=n230 I1=n325 I2=n234
XU181 MAOI1 $PINS O=n335 A1=A[14] A2=n231 B1=B[15] B2=n256
XU182 AN2 $PINS O=n231 I1=n338 I2=n240
XU183 MAOI1 $PINS O=n296 A1=A[30] A2=n232 B1=B[31] B2=n257
XU184 AN2 $PINS O=n232 I1=n299 I2=n248
XU185 INV1S $PINS O=n250 I=A[11]
XU186 INV1S $PINS O=n249 I=A[9]
XU187 INV1S $PINS O=n262 I=A[27]
XU188 INV1S $PINS O=n261 I=A[25]
XU189 INV1S $PINS O=n259 I=A[3]
XU190 INV1S $PINS O=n256 I=A[15]
XU191 INV1S $PINS O=n252 I=A[7]
XU192 INV1S $PINS O=n266 I=A[17]
XU193 INV1S $PINS O=n255 I=A[13]
XU194 INV1S $PINS O=n258 I=A[29]
XU195 INV1S $PINS O=n254 I=A[5]
XU196 INV1S $PINS O=n267 I=A[19]
XU197 INV1S $PINS O=n263 I=A[21]
XU198 INV1S $PINS O=n264 I=A[23]
XU199 INV1S $PINS O=n257 I=A[31]
XU200 INV1S $PINS O=n253 I=A[6]
XU201 INV1S $PINS O=n233 I=B[0]
XU202 MOAI1S $PINS O=GE_LT_GT_LE A1=n268 A2=n269 B1=n270 B2=n271
XU203 ND3 $PINS O=n271 I1=n272 I2=n273 I3=n274
XU204 OAI22S $PINS O=n273 A1=n275 A2=n276 B1=n276 B2=n277
XU205 MOAI1S $PINS O=n277 A1=B[21] A2=n263 B1=A[20] B2=n278
XU206 AN2 $PINS O=n278 I1=n279 I2=n243
XU207 MOAI1S $PINS O=n276 A1=B[23] A2=n264 B1=A[22] B2=n280
XU208 AN2 $PINS O=n280 I1=n281 I2=n244
XU209 OAI112HS $PINS O=n272 A1=n284 B1=n285 C1=n282 C2=n283
XU210 OAI112HS $PINS O=n284 A1=n286 B1=n265 C1=B[17] C2=n266
XU211 ND3 $PINS O=n286 I1=n287 I2=n241 I3=A[16]
XU212 MOAI1S $PINS O=n283 A1=B[19] A2=n267 B1=A[18] B2=n288
XU213 AN2 $PINS O=n288 I1=n289 I2=n242
XU214 ND2 $PINS O=n270 I1=n274 I2=n290
XU215 AOI22S $PINS O=n274 A1=n291 A2=n292 B1=n293 B2=n294
XU216 OAI112HS $PINS O=n294 A1=n295 B1=n296 C1=B[29] C2=n258
XU217 ND3 $PINS O=n295 I1=n297 I2=n247 I3=A[28]
XU218 OR2B1S $PINS O=n293 I1=n298 B1=n296
XU220 MOAI1S $PINS O=n302 A1=B[25] A2=n261 B1=A[24] B2=n303
XU221 AN2 $PINS O=n303 I1=n304 I2=n245
XU222 MOAI1S $PINS O=n301 A1=B[27] A2=n262 B1=A[26] B2=n305
XU223 AN2 $PINS O=n305 I1=n306 I2=n246
XU224 OR3B2 $PINS O=n269 I1=n290 B1=n285 B2=n282
XU225 OA12 $PINS O=n282 A1=n289 B1=A[18] B2=n242
XU226 ND2 $PINS O=n289 I1=B[19] I2=n267
XU227 OA112 $PINS O=n285 A1=n279 B1=n275 C1=A[20] C2=n243
XU228 OA12 $PINS O=n275 A1=n281 B1=A[22] B2=n244
XU229 ND2 $PINS O=n281 I1=B[23] I2=n264
XU230 ND2 $PINS O=n279 I1=B[21] I2=n263
XU231 ND3 $PINS O=n290 I1=n300 I2=n291 I3=n307
XU232 OA12 $PINS O=n307 A1=n304 B1=A[24] B2=n245
XU233 ND2 $PINS O=n304 I1=B[25] I2=n261
XU234 OA112 $PINS O=n291 A1=n297 B1=n298 C1=A[28] C2=n247
XU235 OA12 $PINS O=n298 A1=n299 B1=A[30] B2=n248
XU236 ND2 $PINS O=n299 I1=B[31] I2=n257
XU237 ND2 $PINS O=n297 I1=B[29] I2=n258
XU238 OA12 $PINS O=n300 A1=n306 B1=A[26] B2=n246
XU239 ND2 $PINS O=n306 I1=B[27] I2=n262
XU240 OAI112HS $PINS O=n268 A1=n287 B1=n308 C1=A[16] C2=n241
XU241 AOI22S $PINS O=n308 A1=n309 A2=n310 B1=n311 B2=n309
XU242 AOI13HS $PINS O=n311 A1=n314 B1=n251 B2=n312 B3=n313
XU243 AOI22S $PINS O=n314 A1=n315 A2=n316 B1=n316 B2=n317
XU244 OA22 $PINS O=n316 A1=B[7] A2=n252 B1=n253 B2=n318
XU245 ND2 $PINS O=n318 I1=n319 I2=n236
XU246 AOI13HS $PINS O=n315 A1=n321 B1=n320 B2=n235 B3=A[4]
XU247 NR2 $PINS O=n321 I1=B[5] I2=n254
XU248 OA112 $PINS O=n313 A1=n320 B1=n322 C1=A[4] C2=n235
XU249 ND2 $PINS O=n322 I1=n323 I2=n324
XU250 OAI12HS $PINS O=n324 A1=n325 B1=A[2] B2=n234
XU251 ND2 $PINS O=n320 I1=B[5] I2=n254
XU252 OAI112HS $PINS O=n312 A1=n326 B1=n323 C1=B[1] C2=n260
XU253 ND2 $PINS O=n325 I1=B[3] I2=n259
XU254 MOAI1S $PINS O=n326 A1=A[0] A2=n233 B1=n260 B2=B[1]
XU255 OAI12HS $PINS O=n317 A1=n319 B1=A[6] B2=n236
XU256 ND2 $PINS O=n319 I1=B[7] I2=n252
XU257 ND3 $PINS O=n310 I1=n327 I2=n328 I3=n329
XU258 OA12 $PINS O=n329 A1=n330 B1=A[8] B2=n237
XU259 AOI22S $PINS O=n309 A1=n328 A2=n331 B1=n332 B2=n333
XU260 OAI112HS $PINS O=n333 A1=n334 B1=n335 C1=B[13] C2=n255
XU261 ND3 $PINS O=n334 I1=n336 I2=n239 I3=A[12]
XU262 OR2B1S $PINS O=n332 I1=n337 B1=n335
XU264 MOAI1S $PINS O=n340 A1=B[9] A2=n249 B1=A[8] B2=n341
XU265 AN2 $PINS O=n341 I1=n330 I2=n237
XU266 ND2 $PINS O=n330 I1=B[9] I2=n249
XU267 MOAI1S $PINS O=n339 A1=B[11] A2=n250 B1=A[10] B2=n342
XU268 AN2 $PINS O=n342 I1=n343 I2=n238
XU269 OA12 $PINS O=n327 A1=n343 B1=A[10] B2=n238
XU270 ND2 $PINS O=n343 I1=B[11] I2=n250
XU271 OA112 $PINS O=n328 A1=n336 B1=n337 C1=A[12] C2=n239
XU272 OA12 $PINS O=n337 A1=n338 B1=A[14] B2=n240
XU273 ND2 $PINS O=n338 I1=B[15] I2=n256
XU274 ND2 $PINS O=n336 I1=B[13] I2=n255
XU275 ND2 $PINS O=n287 I1=B[17] I2=n266
.ENDS

.SUBCKT Domain_Transfer_1_DW01_add_0 A[32] A[31] A[30] A[29] A[28] A[27] A[26]
+ A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13]
+ A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[32]
+ B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19]
+ B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6]
+ B[5] B[4] B[3] B[2] B[1] B[0] CI SUM[32] SUM[31] SUM[30] SUM[29] SUM[28]
+ SUM[27] SUM[26] SUM[25] SUM[24] SUM[23] SUM[22] SUM[21] SUM[20] SUM[19]
+ SUM[18] SUM[17] SUM[16] SUM[15] SUM[14] SUM[13] SUM[12] SUM[11] SUM[10]
+ SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2] SUM[1] SUM[0] CO
XFE_RC_2408_0 XOR2HS $PINS O=SUM[4] I1=FE_RN_266_0 I2=carry[4]
XFE_RC_2398_0 XOR2HS $PINS O=SUM[3] I1=FE_RN_536_0 I2=carry[3]
XFE_OFC651_carry_25 INV2CK $PINS O=FE_RN_1047_0 I=carry[25]
XFE_OCPC456_carry_30 BUF1S $PINS O=FE_OCPN456_carry_30 I=carry[30]
XFE_OCPC416_carry_26 BUF1S $PINS O=FE_OCPN416_carry_26 I=carry[26]
XFE_RC_2295_0 ND3P $PINS O=carry[13] I1=n44 I2=n45 I3=n46
XFE_OCPC310_carry_20 BUF1S $PINS O=FE_OCPN310_carry_20 I=carry[20]
XFE_OCPC283_carry_18 BUF1S $PINS O=FE_OCPN283_carry_18 I=carry[18]
XFE_OCPC249_carry_19 BUF1S $PINS O=FE_OCPN249_carry_19 I=carry[19]
XFE_RC_2243_0 ND2S $PINS O=FE_RN_1536_0 I1=B[24] I2=A[24]
XFE_RC_2242_0 AN2 $PINS O=FE_RN_1537_0 I1=FE_RN_1540_0 I2=FE_RN_1536_0
XFE_RC_2241_0 XNR2HS $PINS O=FE_RN_1538_0 I1=A[24] I2=B[24]
XFE_RC_2240_0 MXL2HS $PINS OB=SUM[24] S=carry[24] A=FE_RN_1538_0 B=FE_RN_1537_0
XFE_RC_2238_0 OR2S $PINS O=FE_RN_1540_0 I1=A[24] I2=B[24]
XFE_RC_2237_0 ND2 $PINS O=FE_RN_1541_0 I1=FE_RN_1540_0 I2=carry[24]
XFE_RC_2236_0 ND2P $PINS O=carry[25] I1=FE_RN_1541_0 I2=FE_RN_1536_0
XFE_RC_1988_0 INV1S $PINS O=FE_RN_1343_0 I=A[21]
XFE_RC_1987_0 AN2B1S $PINS O=FE_RN_1344_0 I1=B[21] B1=FE_RN_1343_0
XFE_RC_1986_0 AN2B1S $PINS O=FE_RN_1345_0 I1=FE_RN_1349_0 B1=FE_RN_1344_0
XFE_RC_1985_0 XNR2HS $PINS O=FE_RN_1346_0 I1=B[21] I2=A[21]
XFE_RC_1984_0 MXL2HS $PINS OB=SUM[21] S=carry[21] A=FE_RN_1346_0 B=FE_RN_1345_0
XFE_RC_1983_0 ND2 $PINS O=FE_RN_1347_0 I1=A[21] I2=B[21]
XFE_RC_1982_0 INV1S $PINS O=FE_RN_1348_0 I=A[21]
XFE_RC_1981_0 OR2B1S $PINS O=FE_RN_1349_0 I1=B[21] B1=FE_RN_1348_0
XFE_RC_1980_0 ND2 $PINS O=FE_RN_1350_0 I1=FE_RN_1349_0 I2=carry[21]
XFE_RC_1979_0 ND2P $PINS O=carry[22] I1=FE_RN_1350_0 I2=FE_RN_1347_0
XFE_RC_1758_0 INV1S $PINS O=FE_RN_1176_0 I=A[25]
XFE_RC_1757_0 INV1S $PINS O=FE_RN_1177_0 I=B[25]
XFE_RC_1756_0 OAI22H $PINS O=carry[26] A1=FE_RN_1044_0 A2=FE_RN_1047_0
+ B1=FE_RN_1177_0 B2=FE_RN_1176_0
XFE_RC_1742_0 ND2S $PINS O=FE_RN_1160_0 I1=A[22] I2=B[22]
XFE_RC_1741_0 AN2 $PINS O=FE_RN_1161_0 I1=FE_RN_1164_0 I2=FE_RN_1160_0
XFE_RC_1740_0 XNR2HS $PINS O=FE_RN_1162_0 I1=B[22] I2=A[22]
XFE_RC_1739_0 MXL2HS $PINS OB=SUM[22] S=carry[22] A=FE_RN_1162_0 B=FE_RN_1161_0
XFE_RC_1738_0 ND2S $PINS O=FE_RN_1163_0 I1=A[22] I2=B[22]
XFE_RC_1737_0 OR2S $PINS O=FE_RN_1164_0 I1=B[22] I2=A[22]
XFE_RC_1736_0 ND2 $PINS O=FE_RN_1165_0 I1=FE_RN_1164_0 I2=carry[22]
XFE_RC_1735_0 ND2P $PINS O=carry[23] I1=FE_RN_1165_0 I2=FE_RN_1163_0
XFE_RC_1583_0 INV1S $PINS O=FE_RN_1044_0 I=FE_RN_1048_0
XFE_RC_1582_0 AOI12HS $PINS O=FE_RN_1045_0 A1=FE_RN_1044_0 B1=A[25] B2=B[25]
XFE_RC_1581_0 XNR2HS $PINS O=FE_RN_1046_0 I1=B[25] I2=A[25]
XFE_RC_1580_0 MXL2HS $PINS OB=SUM[25] S=carry[25] A=FE_RN_1046_0 B=FE_RN_1045_0
XFE_RC_1578_0 OR2S $PINS O=FE_RN_1048_0 I1=B[25] I2=A[25]
XFE_RC_1328_0 AN2S $PINS O=FE_RN_851_0 I1=A[15] I2=B[15]
XFE_RC_1327_0 AN2B1S $PINS O=FE_RN_852_0 I1=FE_RN_855_0 B1=FE_RN_851_0
XFE_RC_1326_0 XNR2HS $PINS O=FE_RN_853_0 I1=B[15] I2=A[15]
XFE_RC_1325_0 MXL2HS $PINS OB=SUM[15] S=carry[15] A=FE_RN_853_0 B=FE_RN_852_0
XFE_RC_1324_0 ND2 $PINS O=FE_RN_854_0 I1=A[15] I2=B[15]
XFE_RC_1323_0 OR2 $PINS O=FE_RN_855_0 I1=B[15] I2=A[15]
XFE_RC_1322_0 ND2 $PINS O=FE_RN_856_0 I1=FE_RN_855_0 I2=carry[15]
XFE_RC_1321_0 ND2P $PINS O=carry[16] I1=FE_RN_856_0 I2=FE_RN_854_0
XFE_RC_1093_0 ND3HT $PINS O=carry[18] I1=n41 I2=n42 I3=n43
XFE_RC_1092_0 ND2S $PINS O=FE_RN_687_0 I1=A[26] I2=B[26]
XFE_RC_1091_0 AN2 $PINS O=FE_RN_688_0 I1=FE_RN_691_0 I2=FE_RN_687_0
XFE_RC_1090_0 XNR2HS $PINS O=FE_RN_689_0 I1=B[26] I2=A[26]
XFE_RC_1089_0 MXL2HS $PINS OB=SUM[26] S=FE_OCPN416_carry_26 A=FE_RN_689_0
+ B=FE_RN_688_0
XFE_RC_1088_0 ND2S $PINS O=FE_RN_690_0 I1=A[26] I2=B[26]
XFE_RC_1087_0 OR2S $PINS O=FE_RN_691_0 I1=B[26] I2=A[26]
XFE_RC_1086_0 ND2 $PINS O=FE_RN_692_0 I1=FE_RN_691_0 I2=carry[26]
XFE_RC_1085_0 ND2 $PINS O=carry[27] I1=FE_RN_692_0 I2=FE_RN_690_0
XFE_RC_889_0 XOR2HS $PINS O=FE_RN_536_0 I1=B[3] I2=A[3]
XFE_RC_886_0 ND2S $PINS O=FE_RN_538_0 I1=A[3] I2=B[3]
XFE_RC_885_0 OR2S $PINS O=FE_RN_539_0 I1=B[3] I2=A[3]
XFE_RC_884_0 ND2 $PINS O=FE_RN_540_0 I1=carry[3] I2=FE_RN_539_0
XFE_RC_883_0 ND2P $PINS O=carry[4] I1=FE_RN_540_0 I2=FE_RN_538_0
XFE_RC_733_0 OAI12H $PINS O=FE_RN_269_0 A1=carry[4] B1=B[4] B2=A[4]
XFE_RC_732_0 ND2S $PINS O=FE_RN_421_0 I1=A[27] I2=B[27]
XFE_RC_731_0 AN2 $PINS O=FE_RN_422_0 I1=FE_RN_425_0 I2=FE_RN_421_0
XFE_RC_730_0 XNR2HS $PINS O=FE_RN_423_0 I1=B[27] I2=A[27]
XFE_RC_729_0 MXL2HS $PINS OB=SUM[27] S=carry[27] A=FE_RN_423_0 B=FE_RN_422_0
XFE_RC_728_0 ND2S $PINS O=FE_RN_424_0 I1=A[27] I2=B[27]
XFE_RC_727_0 OR2S $PINS O=FE_RN_425_0 I1=B[27] I2=A[27]
XFE_RC_726_0 ND2 $PINS O=FE_RN_426_0 I1=FE_RN_425_0 I2=carry[27]
XFE_RC_725_0 ND2P $PINS O=carry[28] I1=FE_RN_426_0 I2=FE_RN_424_0
XFE_RC_508_0 XOR2HS $PINS O=FE_RN_266_0 I1=B[4] I2=A[4]
XFE_RC_505_0 ND2 $PINS O=FE_RN_268_0 I1=A[4] I2=B[4]
XFE_RC_503_0 ND2P $PINS O=carry[5] I1=FE_RN_269_0 I2=FE_RN_268_0
XFE_RC_347_0 ND3P $PINS O=carry[29] I1=n38 I2=n39 I3=n40
XFE_RC_346_0 ND3 $PINS O=carry[9] I1=n16 I2=n15 I3=n14
XFE_RC_344_0 INV2CK $PINS O=FE_RN_153_0 I=carry[11]
XFE_RC_343_0 XOR2HS $PINS O=FE_RN_154_0 I1=B[11] I2=A[11]
XFE_RC_342_0 INV1S $PINS O=FE_RN_155_0 I=FE_RN_154_0
XFE_RC_341_0 MXL2HS $PINS OB=SUM[11] S=FE_RN_155_0 A=carry[11] B=FE_RN_153_0
XFE_RC_340_0 NR2 $PINS O=FE_RN_156_0 I1=B[11] I2=A[11]
XFE_RC_338_0 MOAI1H $PINS O=carry[12] A1=FE_RN_153_0 A2=FE_RN_156_0 B1=A[11]
+ B2=B[11]
XFE_RC_237_0 ND3P $PINS O=carry[30] I1=n32 I2=n33 I3=n31
XFE_RC_172_0 ND3P $PINS O=carry[20] I1=n30 I2=n29 I3=n28
XFE_RC_171_0 ND3P $PINS O=carry[15] I1=n23 I2=n22 I3=n21
XFE_RC_161_0 ND3P $PINS O=carry[31] I1=n37 I2=n36 I3=n35
XFE_RC_143_0 ND3P $PINS O=carry[17] I1=n2 I2=n1 I3=n3
XFE_RC_134_0 ND3P $PINS O=carry[19] I1=n25 I2=n26 I3=n24
XU1_31 FA1 $PINS S=SUM[31] CO=SUM[32] A=A[31] B=B[31] CI=carry[31]
XU1_23 FA1 $PINS S=SUM[23] CO=carry[24] A=A[23] B=B[23] CI=carry[23]
XU1_10 FA1 $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_2 FA1 $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1_1 FA1 $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=carry[1]
XU1 ND2P $PINS O=n42 I1=carry[17] I2=A[17]
XU2 ND2P $PINS O=n41 I1=carry[17] I2=B[17]
XU3 ND3P $PINS O=carry[21] I1=n47 I2=n48 I3=n49
XU4 XOR3 $PINS O=SUM[13] I1=A[13] I2=B[13] I3=carry[13]
XU6 XOR3 $PINS O=SUM[7] I1=A[7] I2=B[7] I3=carry[7]
XU7 XOR3 $PINS O=SUM[18] I1=A[18] I2=B[18] I3=FE_OCPN283_carry_18
XU8 XOR3 $PINS O=SUM[29] I1=A[29] I2=B[29] I3=carry[29]
XU9 XOR3 $PINS O=SUM[16] I1=B[16] I2=A[16] I3=carry[16]
XU10 ND2 $PINS O=n1 I1=carry[16] I2=B[16]
XU11 ND2 $PINS O=n2 I1=carry[16] I2=A[16]
XU12 ND2 $PINS O=n3 I1=B[16] I2=A[16]
XU14 AN2 $PINS O=carry[1] I1=B[0] I2=A[0]
XU15 ND3P $PINS O=carry[7] I1=n7 I2=n8 I3=n9
XU18 ND2 $PINS O=n10 I1=A[7] I2=B[7]
XU19 ND2 $PINS O=n24 I1=A[18] I2=B[18]
XU20 ND2 $PINS O=n17 I1=A[13] I2=B[13]
XU21 ND2 $PINS O=n31 I1=A[29] I2=B[29]
XU22 XOR3 $PINS O=SUM[12] I1=B[12] I2=A[12] I3=carry[12]
XU23 XOR3 $PINS O=SUM[17] I1=B[17] I2=A[17] I3=carry[17]
XU24 XOR3 $PINS O=SUM[20] I1=B[20] I2=A[20] I3=FE_OCPN310_carry_20
XU25 XOR3 $PINS O=SUM[28] I1=B[28] I2=A[28] I3=carry[28]
XU26 XOR3 $PINS O=SUM[5] I1=B[5] I2=A[5] I3=carry[5]
XU27 ND2 $PINS O=n4 I1=carry[5] I2=B[5]
XU28 ND2 $PINS O=n5 I1=carry[5] I2=A[5]
XU29 ND2 $PINS O=n6 I1=B[5] I2=A[5]
XU30 ND3P $PINS O=carry[6] I1=n4 I2=n5 I3=n6
XU31 XOR3 $PINS O=SUM[6] I1=B[6] I2=A[6] I3=carry[6]
XU34 ND2 $PINS O=n7 I1=carry[6] I2=B[6]
XU35 ND2 $PINS O=n8 I1=carry[6] I2=A[6]
XU36 ND2S $PINS O=n9 I1=B[6] I2=A[6]
XU37 ND2 $PINS O=n11 I1=A[7] I2=carry[7]
XU38 ND2 $PINS O=n12 I1=B[7] I2=carry[7]
XU39 ND3P $PINS O=carry[8] I1=n12 I2=n11 I3=n10
XU40 XOR2HS $PINS O=n13 I1=A[8] I2=B[8]
XU41 XOR2HS $PINS O=SUM[8] I1=n13 I2=carry[8]
XU42 ND2S $PINS O=n14 I1=A[8] I2=B[8]
XU43 ND2 $PINS O=n15 I1=A[8] I2=carry[8]
XU44 ND2 $PINS O=n16 I1=B[8] I2=carry[8]
XU45 ND2 $PINS O=n18 I1=A[13] I2=carry[13]
XU46 ND2 $PINS O=n19 I1=B[13] I2=carry[13]
XU47 ND3P $PINS O=carry[14] I1=n19 I2=n18 I3=n17
XU48 XOR2HS $PINS O=n20 I1=A[14] I2=B[14]
XU49 XOR2HS $PINS O=SUM[14] I1=n20 I2=carry[14]
XU50 ND2S $PINS O=n21 I1=A[14] I2=B[14]
XU51 ND2 $PINS O=n22 I1=A[14] I2=carry[14]
XU52 ND2 $PINS O=n23 I1=B[14] I2=carry[14]
XU54 ND2 $PINS O=n25 I1=A[18] I2=carry[18]
XU55 ND2P $PINS O=n26 I1=B[18] I2=carry[18]
XU57 XOR2HS $PINS O=n27 I1=A[19] I2=B[19]
XU58 XOR2HS $PINS O=SUM[19] I1=n27 I2=FE_OCPN249_carry_19
XU59 ND2S $PINS O=n28 I1=A[19] I2=B[19]
XU60 ND2 $PINS O=n29 I1=A[19] I2=carry[19]
XU61 ND2 $PINS O=n30 I1=B[19] I2=carry[19]
XU62 ND2 $PINS O=n32 I1=A[29] I2=carry[29]
XU63 ND2 $PINS O=n33 I1=carry[29] I2=B[29]
XU64 XOR2HS $PINS O=n34 I1=A[30] I2=B[30]
XU65 XOR2HS $PINS O=SUM[30] I1=n34 I2=FE_OCPN456_carry_30
XU66 ND2S $PINS O=n35 I1=A[30] I2=B[30]
XU67 ND2 $PINS O=n36 I1=A[30] I2=carry[30]
XU68 ND2 $PINS O=n37 I1=B[30] I2=carry[30]
XU70 ND2 $PINS O=n38 I1=carry[28] I2=B[28]
XU71 ND2 $PINS O=n39 I1=carry[28] I2=A[28]
XU72 ND2S $PINS O=n40 I1=B[28] I2=A[28]
XU73 ND2S $PINS O=n43 I1=B[17] I2=A[17]
XU75 ND2 $PINS O=n44 I1=carry[12] I2=B[12]
XU76 ND2 $PINS O=n45 I1=carry[12] I2=A[12]
XU77 ND2S $PINS O=n46 I1=B[12] I2=A[12]
XU78 ND2 $PINS O=n47 I1=carry[20] I2=B[20]
XU79 ND2 $PINS O=n48 I1=carry[20] I2=A[20]
XU80 ND2S $PINS O=n49 I1=B[20] I2=A[20]
.ENDS

.SUBCKT Domain_Transfer_1_DW01_add_1 A[32] A[31] A[30] A[29] A[28] A[27] A[26]
+ A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13]
+ A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[32]
+ B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19]
+ B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6]
+ B[5] B[4] B[3] B[2] B[1] B[0] CI SUM[32] SUM[31] SUM[30] SUM[29] SUM[28]
+ SUM[27] SUM[26] SUM[25] SUM[24] SUM[23] SUM[22] SUM[21] SUM[20] SUM[19]
+ SUM[18] SUM[17] SUM[16] SUM[15] SUM[14] SUM[13] SUM[12] SUM[11] SUM[10]
+ SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2] SUM[1] SUM[0] CO
+ FE_OFN145_raw_prime_8 FE_OFN226_FE_OFN43_raw_prime_19
+ FE_OFN258_FE_OFN35_raw_prime_27
XFE_RC_2416_0 XOR2HS $PINS O=SUM[21] I1=FE_RN_159_0 I2=carry[21]
XFE_RC_2315_0 ND3P $PINS O=carry[6] I1=n30 I2=n31 I3=n32
XFE_RC_2258_0 ND3P $PINS O=carry[13] I1=n21 I2=n20 I3=n22
XFE_RC_2021_0 INV1S $PINS O=FE_RN_1369_0 I=FE_RN_1374_0
XFE_RC_2020_0 AOI12HS $PINS O=FE_RN_1370_0 A1=FE_RN_1369_0 B1=A[26] B2=B[26]
XFE_RC_2019_0 XNR2HS $PINS O=FE_RN_1371_0 I1=B[26] I2=A[26]
XFE_RC_2018_0 MXL2HS $PINS OB=SUM[26] S=carry[26] A=FE_RN_1371_0 B=FE_RN_1370_0
XFE_RC_2017_0 ND2 $PINS O=FE_RN_1372_0 I1=A[26] I2=B[26]
XFE_RC_2016_0 INV1S $PINS O=FE_RN_1373_0 I=A[26]
XFE_RC_2015_0 OR2B1S $PINS O=FE_RN_1374_0 I1=B[26] B1=FE_RN_1373_0
XFE_RC_2014_0 ND2 $PINS O=FE_RN_1375_0 I1=FE_RN_1374_0 I2=carry[26]
XFE_RC_2013_0 ND2P $PINS O=carry[27] I1=FE_RN_1375_0 I2=FE_RN_1372_0
XFE_RC_1813_0 ND2S $PINS O=FE_RN_1213_0 I1=A[27] I2=B[27]
XFE_RC_1812_0 AN2 $PINS O=FE_RN_1214_0 I1=FE_RN_1217_0 I2=FE_RN_1213_0
XFE_RC_1811_0 XNR2HS $PINS O=FE_RN_1215_0 I1=FE_OFN258_FE_OFN35_raw_prime_27
+ I2=A[27]
XFE_RC_1810_0 MXL2HS $PINS OB=SUM[27] S=carry[27] A=FE_RN_1215_0 B=FE_RN_1214_0
XFE_RC_1809_0 ND2S $PINS O=FE_RN_1216_0 I1=A[27] I2=B[27]
XFE_RC_1808_0 OR2S $PINS O=FE_RN_1217_0 I1=B[27] I2=A[27]
XFE_RC_1807_0 ND2 $PINS O=FE_RN_1218_0 I1=FE_RN_1217_0 I2=carry[27]
XFE_RC_1806_0 ND2P $PINS O=carry[28] I1=FE_RN_1218_0 I2=FE_RN_1216_0
XFE_RC_1607_0 INV1S $PINS O=FE_RN_1062_0 I=carry[28]
XFE_RC_1606_0 XOR2HS $PINS O=FE_RN_1063_0 I1=B[28] I2=A[28]
XFE_RC_1605_0 INV1S $PINS O=FE_RN_1064_0 I=FE_RN_1063_0
XFE_RC_1604_0 MXL2HS $PINS OB=SUM[28] S=FE_RN_1064_0 A=carry[28] B=FE_RN_1062_0
XFE_RC_1603_0 NR2 $PINS O=FE_RN_1065_0 I1=B[28] I2=A[28]
XFE_RC_1601_0 MOAI1 $PINS O=carry[29] A1=FE_RN_1062_0 A2=FE_RN_1065_0 B1=A[28]
+ B2=B[28]
XFE_RC_1339_0 INV1S $PINS O=FE_RN_857_0 I=FE_RN_864_0
XFE_RC_1338_0 AOI12HS $PINS O=FE_RN_858_0 A1=FE_RN_857_0 B1=A[16] B2=B[16]
XFE_RC_1337_0 INV1S $PINS O=FE_RN_859_0 I=A[16]
XFE_RC_1336_0 INV1S $PINS O=FE_RN_860_0 I=A[16]
XFE_RC_1335_0 NR2 $PINS O=FE_RN_861_0 I1=B[16] I2=FE_RN_860_0
XFE_RC_1334_0 AOI12HS $PINS O=FE_RN_862_0 A1=FE_RN_861_0 B1=FE_RN_859_0
+ B2=B[16]
XFE_RC_1333_0 MXL2HS $PINS OB=SUM[16] S=carry[16] A=FE_RN_862_0 B=FE_RN_858_0
XFE_RC_1332_0 ND2 $PINS O=FE_RN_863_0 I1=A[16] I2=B[16]
XFE_RC_1331_0 OR2 $PINS O=FE_RN_864_0 I1=B[16] I2=A[16]
XFE_RC_1330_0 ND2 $PINS O=FE_RN_865_0 I1=FE_RN_864_0 I2=carry[16]
XFE_RC_1329_0 ND2P $PINS O=carry[17] I1=FE_RN_865_0 I2=FE_RN_863_0
XFE_RC_1101_0 ND2S $PINS O=FE_RN_693_0 I1=A[17] I2=B[17]
XFE_RC_1100_0 AN2 $PINS O=FE_RN_694_0 I1=FE_RN_697_0 I2=FE_RN_693_0
XFE_RC_1099_0 XNR2HS $PINS O=FE_RN_695_0 I1=B[17] I2=A[17]
XFE_RC_1098_0 MXL2HS $PINS OB=SUM[17] S=carry[17] A=FE_RN_695_0 B=FE_RN_694_0
XFE_RC_1096_0 OR2S $PINS O=FE_RN_697_0 I1=B[17] I2=A[17]
XFE_RC_1095_0 ND2 $PINS O=FE_RN_698_0 I1=FE_RN_697_0 I2=carry[17]
XFE_RC_1094_0 ND2P $PINS O=carry[18] I1=FE_RN_698_0 I2=FE_RN_693_0
XFE_RC_951_0 ND2S $PINS O=FE_RN_581_0 I1=A[18] I2=B[18]
XFE_RC_950_0 AN2 $PINS O=FE_RN_582_0 I1=FE_RN_585_0 I2=FE_RN_581_0
XFE_RC_949_0 XNR2HS $PINS O=FE_RN_583_0 I1=B[18] I2=A[18]
XFE_RC_948_0 MXL2HS $PINS OB=SUM[18] S=carry[18] A=FE_RN_583_0 B=FE_RN_582_0
XFE_RC_947_0 ND2S $PINS O=FE_RN_584_0 I1=A[18] I2=B[18]
XFE_RC_946_0 OR2S $PINS O=FE_RN_585_0 I1=B[18] I2=A[18]
XFE_RC_945_0 ND2 $PINS O=FE_RN_586_0 I1=FE_RN_585_0 I2=carry[18]
XFE_RC_944_0 ND2P $PINS O=carry[19] I1=FE_RN_586_0 I2=FE_RN_584_0
XFE_RC_724_0 ND2S $PINS O=FE_RN_415_0 I1=A[19] I2=B[19]
XFE_RC_723_0 AN2 $PINS O=FE_RN_416_0 I1=FE_RN_419_0 I2=FE_RN_415_0
XFE_RC_722_0 XNR2HS $PINS O=FE_RN_417_0 I1=FE_OFN226_FE_OFN43_raw_prime_19
+ I2=A[19]
XFE_RC_721_0 MXL2HS $PINS OB=SUM[19] S=carry[19] A=FE_RN_417_0 B=FE_RN_416_0
XFE_RC_720_0 ND2S $PINS O=FE_RN_418_0 I1=A[19] I2=B[19]
XFE_RC_719_0 OR2S $PINS O=FE_RN_419_0 I1=B[19] I2=A[19]
XFE_RC_718_0 ND2 $PINS O=FE_RN_420_0 I1=FE_RN_419_0 I2=carry[19]
XFE_RC_717_0 ND2P $PINS O=carry[20] I1=FE_RN_420_0 I2=FE_RN_418_0
XFE_RC_569_0 ND2S $PINS O=FE_RN_304_0 I1=A[20] I2=B[20]
XFE_RC_568_0 AN2 $PINS O=FE_RN_305_0 I1=FE_RN_308_0 I2=FE_RN_304_0
XFE_RC_567_0 XNR2HS $PINS O=FE_RN_306_0 I1=B[20] I2=A[20]
XFE_RC_566_0 MXL2HS $PINS OB=SUM[20] S=carry[20] A=FE_RN_306_0 B=FE_RN_305_0
XFE_RC_565_0 ND2S $PINS O=FE_RN_307_0 I1=A[20] I2=B[20]
XFE_RC_564_0 OR2S $PINS O=FE_RN_308_0 I1=B[20] I2=A[20]
XFE_RC_563_0 ND2 $PINS O=FE_RN_309_0 I1=FE_RN_308_0 I2=carry[20]
XFE_RC_562_0 ND2P $PINS O=carry[21] I1=FE_RN_309_0 I2=FE_RN_307_0
XFE_RC_355_0 XOR2HS $PINS O=FE_RN_159_0 I1=B[21] I2=A[21]
XFE_RC_352_0 ND2S $PINS O=FE_RN_161_0 I1=A[21] I2=B[21]
XFE_RC_351_0 OR2S $PINS O=FE_RN_162_0 I1=B[21] I2=A[21]
XFE_RC_350_0 ND2 $PINS O=FE_RN_163_0 I1=carry[21] I2=FE_RN_162_0
XFE_RC_349_0 ND2P $PINS O=carry[22] I1=FE_RN_163_0 I2=FE_RN_161_0
XFE_RC_206_0 ND2S $PINS O=FE_RN_70_0 I1=A[13] I2=B[13]
XFE_RC_205_0 AN2 $PINS O=FE_RN_71_0 I1=FE_RN_74_0 I2=FE_RN_70_0
XFE_RC_204_0 XNR2HS $PINS O=FE_RN_72_0 I1=B[13] I2=A[13]
XFE_RC_203_0 MXL2HS $PINS OB=SUM[13] S=carry[13] A=FE_RN_72_0 B=FE_RN_71_0
XFE_RC_202_0 ND2S $PINS O=FE_RN_73_0 I1=A[13] I2=B[13]
XFE_RC_201_0 OR2S $PINS O=FE_RN_74_0 I1=B[13] I2=A[13]
XFE_RC_200_0 ND2 $PINS O=FE_RN_75_0 I1=FE_RN_74_0 I2=carry[13]
XFE_RC_199_0 ND2P $PINS O=carry[14] I1=FE_RN_75_0 I2=FE_RN_73_0
XFE_RC_106_0 XOR3 $PINS O=SUM[22] I1=A[22] I2=B[22] I3=carry[22]
XFE_RC_105_0 MAO222 $PINS O=carry[23] A1=A[22] B1=B[22] C1=carry[22]
XFE_RC_59_0 XOR3 $PINS O=SUM[6] I1=A[6] I2=B[6] I3=carry[6]
XFE_RC_58_0 MAO222P $PINS O=carry[7] A1=A[6] B1=B[6] C1=carry[6]
XFE_RC_54_0 ND3P $PINS O=carry[24] I1=n17 I2=n18 I3=n19
XFE_RC_53_0 XOR3 $PINS O=SUM[14] I1=A[14] I2=B[14] I3=carry[14]
XFE_RC_52_0 MAO222P $PINS O=carry[15] A1=A[14] B1=B[14] C1=carry[14]
XFE_RC_51_0 ND3HT $PINS O=carry[12] I1=n9 I2=n8 I3=n10
XFE_RC_27_0 XOR3 $PINS O=SUM[7] I1=A[7] I2=B[7] I3=carry[7]
XFE_RC_26_0 MAO222P $PINS O=carry[8] A1=A[7] B1=B[7] C1=carry[7]
XU1_29 FA1 $PINS S=SUM[29] CO=carry[30] A=A[29] B=B[29] CI=carry[29]
XU1_10 FA1 $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_4 FA1 $PINS S=SUM[4] CO=carry[5] A=A[4] B=B[4] CI=carry[4]
XU1_3 FA1 $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_2 FA1 $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1_1 FA1 $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=carry[1]
XU2 ND2P $PINS O=n27 I1=carry[31] I2=B[31]
XU3 ND3P $PINS O=carry[26] I1=n4 I2=n5 I3=n6
XU4 ND3P $PINS O=carry[16] I1=n33 I2=n34 I3=n35
XU6 ND2 $PINS O=n28 I1=carry[31] I2=A[31]
XU7 ND3P $PINS O=carry[31] I1=n14 I2=n15 I3=n16
XU8 XOR3 $PINS O=SUM[24] I1=B[24] I2=A[24] I3=carry[24]
XU10 ND3P $PINS O=carry[9] I1=n11 I2=n12 I3=n13
XU11 ND2 $PINS O=n23 I1=carry[9] I2=B[9]
XU12 ND2 $PINS O=n24 I1=carry[9] I2=A[9]
XU13 XOR3 $PINS O=SUM[9] I1=B[9] I2=A[9] I3=carry[9]
XU14 ND2 $PINS O=n1 I1=carry[24] I2=B[24]
XU15 ND2 $PINS O=n2 I1=carry[24] I2=A[24]
XU16 ND2 $PINS O=n3 I1=B[24] I2=A[24]
XU17 ND3P $PINS O=carry[25] I1=n1 I2=n2 I3=n3
XU19 ND2 $PINS O=n8 I1=n7 I2=B[11]
XU20 ND2P $PINS O=n9 I1=carry[11] I2=A[11]
XU21 XOR3 $PINS O=SUM[5] I1=B[5] I2=A[5] I3=carry[5]
XU22 XOR3 $PINS O=SUM[8] I1=B[8] I2=A[8] I3=carry[8]
XU23 XOR3 $PINS O=SUM[11] I1=B[11] I2=A[11] I3=n7
XU24 XOR3 $PINS O=SUM[12] I1=B[12] I2=A[12] I3=carry[12]
XU25 XOR3 $PINS O=SUM[15] I1=B[15] I2=A[15] I3=carry[15]
XU26 XOR3 $PINS O=SUM[23] I1=B[23] I2=A[23] I3=carry[23]
XU27 XOR3 $PINS O=SUM[30] I1=B[30] I2=A[30] I3=carry[30]
XU28 XOR3 $PINS O=SUM[25] I1=B[25] I2=A[25] I3=carry[25]
XU29 ND2 $PINS O=n4 I1=carry[25] I2=B[25]
XU30 ND2 $PINS O=n5 I1=carry[25] I2=A[25]
XU31 ND2 $PINS O=n6 I1=B[25] I2=A[25]
XU32 MAO222 $PINS O=n7 A1=A[10] B1=B[10] C1=carry[10]
XU33 ND2 $PINS O=n10 I1=B[11] I2=A[11]
XU34 ND2 $PINS O=n11 I1=carry[8] I2=FE_OFN145_raw_prime_8
XU35 ND2 $PINS O=n12 I1=carry[8] I2=A[8]
XU36 ND2 $PINS O=n13 I1=FE_OFN145_raw_prime_8 I2=A[8]
XU37 ND2 $PINS O=n14 I1=carry[30] I2=B[30]
XU38 ND2 $PINS O=n15 I1=carry[30] I2=A[30]
XU39 ND2 $PINS O=n16 I1=B[30] I2=A[30]
XU40 ND2T $PINS O=n20 I1=carry[12] I2=B[12]
XU41 ND2P $PINS O=n21 I1=carry[12] I2=A[12]
XU42 ND2 $PINS O=n17 I1=carry[23] I2=B[23]
XU43 ND2 $PINS O=n18 I1=carry[23] I2=A[23]
XU44 ND2S $PINS O=n19 I1=B[23] I2=A[23]
XU45 ND2S $PINS O=n22 I1=B[12] I2=A[12]
XU46 ND2S $PINS O=n25 I1=B[9] I2=A[9]
XU47 ND3P $PINS O=carry[10] I1=n23 I2=n24 I3=n25
XU48 XOR2HS $PINS O=n26 I1=B[31] I2=A[31]
XU49 XOR2HS $PINS O=SUM[31] I1=carry[31] I2=n26
XU50 ND2S $PINS O=n29 I1=B[31] I2=A[31]
XU51 ND3 $PINS O=SUM[32] I1=n28 I2=n27 I3=n29
XU52 ND2 $PINS O=n30 I1=carry[5] I2=B[5]
XU53 ND2 $PINS O=n31 I1=carry[5] I2=A[5]
XU54 ND2 $PINS O=n32 I1=B[5] I2=A[5]
XU55 ND2 $PINS O=n33 I1=carry[15] I2=B[15]
XU56 ND2 $PINS O=n34 I1=carry[15] I2=A[15]
XU57 ND2 $PINS O=n35 I1=B[15] I2=A[15]
XU58 AN2S $PINS O=carry[1] I1=B[0] I2=A[0]
.ENDS

.SUBCKT Domain_Transfer_1_DW01_add_2 A[32] A[31] A[30] A[29] A[28] A[27] A[26]
+ A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13]
+ A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[32]
+ B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19]
+ B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6]
+ B[5] B[4] B[3] B[2] B[1] B[0] CI SUM[32] SUM[31] SUM[30] SUM[29] SUM[28]
+ SUM[27] SUM[26] SUM[25] SUM[24] SUM[23] SUM[22] SUM[21] SUM[20] SUM[19]
+ SUM[18] SUM[17] SUM[16] SUM[15] SUM[14] SUM[13] SUM[12] SUM[11] SUM[10]
+ SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2] SUM[1] SUM[0] CO
+ FE_OFN159_i1_w_5 FE_OFN181_FE_OFN95_raw_prime_7
XFE_RC_2417_0 XOR2HS $PINS O=SUM[24] I1=FE_RN_808_0 I2=carry[24]
XFE_RC_2383_0 XNR2HS $PINS O=FE_RN_986_0 I1=A[23] I2=B[23]
XFE_RC_2382_0 AN2S $PINS O=FE_RN_1589_0 I1=A[30] I2=B[30]
XFE_RC_2381_0 AN2B1S $PINS O=FE_RN_1590_0 I1=FE_RN_1594_0 B1=FE_RN_1589_0
XFE_RC_2380_0 XNR2HS $PINS O=FE_RN_1591_0 I1=B[30] I2=A[30]
XFE_RC_2379_0 MXL2HS $PINS OB=SUM[30] S=carry[30] A=FE_RN_1591_0 B=FE_RN_1590_0
XFE_RC_2378_0 ND2 $PINS O=FE_RN_1592_0 I1=A[30] I2=B[30]
XFE_RC_2377_0 INV1S $PINS O=FE_RN_1593_0 I=A[30]
XFE_RC_2376_0 OR2B1 $PINS O=FE_RN_1594_0 I1=B[30] B1=FE_RN_1593_0
XFE_RC_2375_0 ND2 $PINS O=FE_RN_1595_0 I1=FE_RN_1594_0 I2=carry[30]
XFE_RC_2374_0 ND2 $PINS O=carry[31] I1=FE_RN_1595_0 I2=FE_RN_1592_0
XFE_RC_2332_0 XOR3 $PINS O=SUM[12] I1=A[12] I2=B[12] I3=carry[12]
XFE_RC_2331_0 MAO222 $PINS O=carry[13] A1=A[12] B1=B[12] C1=carry[12]
XFE_RC_2278_0 XOR3 $PINS O=SUM[2] I1=A[2] I2=B[2] I3=carry[2]
XFE_RC_2277_0 MAO222 $PINS O=carry[3] A1=A[2] B1=B[2] C1=carry[2]
XFE_RC_1996_0 ND2S $PINS O=FE_RN_1351_0 I1=A[15] I2=B[15]
XFE_RC_1995_0 AN2 $PINS O=FE_RN_1352_0 I1=FE_RN_1355_0 I2=FE_RN_1351_0
XFE_RC_1994_0 XNR2HS $PINS O=FE_RN_1353_0 I1=B[15] I2=A[15]
XFE_RC_1993_0 MXL2HS $PINS OB=SUM[15] S=carry[15] A=FE_RN_1353_0 B=FE_RN_1352_0
XFE_RC_1992_0 ND2S $PINS O=FE_RN_1354_0 I1=A[15] I2=B[15]
XFE_RC_1991_0 OR2S $PINS O=FE_RN_1355_0 I1=B[15] I2=A[15]
XFE_RC_1990_0 ND2 $PINS O=FE_RN_1356_0 I1=FE_RN_1355_0 I2=carry[15]
XFE_RC_1989_0 ND2P $PINS O=carry[16] I1=FE_RN_1356_0 I2=FE_RN_1354_0
XFE_RC_1734_0 OR2 $PINS O=FE_RN_1159_0 I1=A[24] I2=B[24]
XFE_RC_1733_0 ND2P $PINS O=FE_RN_811_0 I1=carry[24] I2=FE_RN_1159_0
XFE_RC_1732_0 ND2 $PINS O=FE_RN_1153_0 I1=A[7] I2=B[7]
XFE_RC_1731_0 AN2 $PINS O=FE_RN_1154_0 I1=FE_RN_1157_0 I2=FE_RN_1153_0
XFE_RC_1730_0 XNR2HS $PINS O=FE_RN_1155_0 I1=FE_OFN181_FE_OFN95_raw_prime_7
+ I2=A[7]
XFE_RC_1729_0 MXL2HS $PINS OB=SUM[7] S=carry[7] A=FE_RN_1155_0 B=FE_RN_1154_0
XFE_RC_1728_0 ND2 $PINS O=FE_RN_1156_0 I1=A[7] I2=B[7]
XFE_RC_1727_0 OR2 $PINS O=FE_RN_1157_0 I1=FE_OFN181_FE_OFN95_raw_prime_7
+ I2=A[7]
XFE_RC_1726_0 ND2 $PINS O=FE_RN_1158_0 I1=FE_RN_1157_0 I2=carry[7]
XFE_RC_1725_0 ND2P $PINS O=carry[8] I1=FE_RN_1158_0 I2=FE_RN_1156_0
XFE_RC_1504_0 INV1S $PINS O=FE_RN_982_0 I=FE_RN_989_0
XFE_RC_1503_0 AOI12HS $PINS O=FE_RN_983_0 A1=FE_RN_982_0 B1=A[23] B2=B[23]
XFE_RC_1499_0 MXL2HS $PINS OB=SUM[23] S=carry[23] A=FE_RN_986_0 B=FE_RN_983_0
XFE_RC_1498_0 ND2 $PINS O=FE_RN_987_0 I1=A[23] I2=B[23]
XFE_RC_1497_0 INV1S $PINS O=FE_RN_988_0 I=A[23]
XFE_RC_1496_0 OR2B1S $PINS O=FE_RN_989_0 I1=B[23] B1=FE_RN_988_0
XFE_RC_1495_0 ND2 $PINS O=FE_RN_990_0 I1=FE_RN_989_0 I2=carry[23]
XFE_RC_1494_0 ND2P $PINS O=carry[24] I1=FE_RN_990_0 I2=FE_RN_987_0
XFE_RC_1262_0 XOR2HS $PINS O=FE_RN_808_0 I1=B[24] I2=A[24]
XFE_RC_1259_0 ND2S $PINS O=FE_RN_810_0 I1=A[24] I2=B[24]
XFE_RC_1257_0 ND2P $PINS O=carry[25] I1=FE_RN_811_0 I2=FE_RN_810_0
XFE_RC_1044_0 ND2S $PINS O=FE_RN_651_0 I1=A[16] I2=B[16]
XFE_RC_1043_0 AN2 $PINS O=FE_RN_652_0 I1=FE_RN_655_0 I2=FE_RN_651_0
XFE_RC_1042_0 XNR2HS $PINS O=FE_RN_653_0 I1=B[16] I2=A[16]
XFE_RC_1041_0 MXL2HS $PINS OB=SUM[16] S=carry[16] A=FE_RN_653_0 B=FE_RN_652_0
XFE_RC_1040_0 ND2S $PINS O=FE_RN_654_0 I1=A[16] I2=B[16]
XFE_RC_1039_0 OR2S $PINS O=FE_RN_655_0 I1=B[16] I2=A[16]
XFE_RC_1038_0 ND2 $PINS O=FE_RN_656_0 I1=FE_RN_655_0 I2=carry[16]
XFE_RC_1037_0 ND2P $PINS O=carry[17] I1=FE_RN_656_0 I2=FE_RN_654_0
XFE_RC_879_0 ND2S $PINS O=FE_RN_527_0 I1=A[17] I2=B[17]
XFE_RC_878_0 AN2 $PINS O=FE_RN_528_0 I1=FE_RN_531_0 I2=FE_RN_527_0
XFE_RC_877_0 XNR2HS $PINS O=FE_RN_529_0 I1=B[17] I2=A[17]
XFE_RC_876_0 MXL2HS $PINS OB=SUM[17] S=carry[17] A=FE_RN_529_0 B=FE_RN_528_0
XFE_RC_875_0 ND2S $PINS O=FE_RN_530_0 I1=A[17] I2=B[17]
XFE_RC_874_0 OR2S $PINS O=FE_RN_531_0 I1=B[17] I2=A[17]
XFE_RC_873_0 ND2 $PINS O=FE_RN_532_0 I1=FE_RN_531_0 I2=carry[17]
XFE_RC_872_0 ND2P $PINS O=carry[18] I1=FE_RN_532_0 I2=FE_RN_530_0
XFE_RC_703_0 OR2 $PINS O=FE_RN_406_0 I1=A[22] I2=B[22]
XFE_RC_702_0 ND2P $PINS O=FE_RN_258_0 I1=carry[22] I2=FE_RN_406_0
XFE_RC_675_0 ND2S $PINS O=FE_RN_381_0 I1=A[25] I2=B[25]
XFE_RC_674_0 AN2 $PINS O=FE_RN_382_0 I1=FE_RN_385_0 I2=FE_RN_381_0
XFE_RC_673_0 XNR2HS $PINS O=FE_RN_383_0 I1=B[25] I2=A[25]
XFE_RC_672_0 MXL2HS $PINS OB=SUM[25] S=carry[25] A=FE_RN_383_0 B=FE_RN_382_0
XFE_RC_671_0 ND2S $PINS O=FE_RN_384_0 I1=A[25] I2=B[25]
XFE_RC_670_0 OR2S $PINS O=FE_RN_385_0 I1=B[25] I2=A[25]
XFE_RC_669_0 ND2 $PINS O=FE_RN_386_0 I1=FE_RN_385_0 I2=carry[25]
XFE_RC_668_0 ND2P $PINS O=carry[26] I1=FE_RN_386_0 I2=FE_RN_384_0
XFE_RC_494_0 INV1S $PINS O=FE_RN_253_0 I=FE_RN_254_0
XFE_RC_493_0 XOR2HS $PINS O=FE_RN_254_0 I1=B[22] I2=A[22]
XFE_RC_491_0 ND2 $PINS O=FE_RN_256_0 I1=FE_RN_253_0 I2=carry[22]
XFE_RC_490_0 OAI12HS $PINS O=SUM[22] A1=FE_RN_256_0 B1=FE_RN_253_0 B2=carry[22]
XFE_RC_489_0 ND2 $PINS O=FE_RN_257_0 I1=A[22] I2=B[22]
XFE_RC_487_0 ND2P $PINS O=carry[23] I1=FE_RN_258_0 I2=FE_RN_257_0
XFE_RC_327_0 ND2S $PINS O=FE_RN_141_0 I1=B[8] I2=A[8]
XFE_RC_326_0 AN2 $PINS O=FE_RN_142_0 I1=FE_RN_145_0 I2=FE_RN_141_0
XFE_RC_325_0 XNR2HS $PINS O=FE_RN_143_0 I1=A[8] I2=B[8]
XFE_RC_324_0 MXL2HS $PINS OB=SUM[8] S=carry[8] A=FE_RN_143_0 B=FE_RN_142_0
XFE_RC_323_0 ND2S $PINS O=FE_RN_144_0 I1=B[8] I2=A[8]
XFE_RC_322_0 OR2S $PINS O=FE_RN_145_0 I1=A[8] I2=B[8]
XFE_RC_321_0 ND2 $PINS O=FE_RN_146_0 I1=FE_RN_145_0 I2=carry[8]
XFE_RC_320_0 ND2P $PINS O=carry[9] I1=FE_RN_146_0 I2=FE_RN_144_0
XFE_RC_93_0 INV1S $PINS O=FE_RN_32_0 I=FE_RN_40_0
XFE_RC_92_0 AOI12HS $PINS O=FE_RN_33_0 A1=FE_RN_32_0 B1=A[20] B2=B[20]
XFE_RC_91_0 INV1S $PINS O=FE_RN_34_0 I=A[20]
XFE_RC_90_0 INV1S $PINS O=FE_RN_35_0 I=A[20]
XFE_RC_89_0 NR2 $PINS O=FE_RN_36_0 I1=B[20] I2=FE_RN_35_0
XFE_RC_88_0 AOI12HS $PINS O=FE_RN_37_0 A1=FE_RN_36_0 B1=FE_RN_34_0 B2=B[20]
XFE_RC_87_0 MXL2HS $PINS OB=SUM[20] S=carry[20] A=FE_RN_37_0 B=FE_RN_33_0
XFE_RC_86_0 ND2 $PINS O=FE_RN_38_0 I1=A[20] I2=B[20]
XFE_RC_85_0 INV1S $PINS O=FE_RN_39_0 I=A[20]
XFE_RC_84_0 OR2B1S $PINS O=FE_RN_40_0 I1=B[20] B1=FE_RN_39_0
XFE_RC_83_0 ND2 $PINS O=FE_RN_41_0 I1=FE_RN_40_0 I2=carry[20]
XFE_RC_82_0 ND2P $PINS O=carry[21] I1=FE_RN_41_0 I2=FE_RN_38_0
XFE_RC_71_0 ND3P $PINS O=carry[29] I1=n19 I2=n20 I3=n18
XFE_RC_61_0 ND3P $PINS O=carry[11] I1=n34 I2=n33 I3=n32
XU1_31 FA1 $PINS S=SUM[31] CO=SUM[32] A=A[31] B=B[31] CI=carry[31]
XU1_14 FA1 $PINS S=SUM[14] CO=carry[15] A=A[14] B=B[14] CI=carry[14]
XU1_13 FA1 $PINS S=SUM[13] CO=carry[14] A=A[13] B=B[13] CI=carry[13]
XU1_6 FA1 $PINS S=SUM[6] CO=carry[7] A=A[6] B=B[6] CI=carry[6]
XU1_1 FA1 $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=carry[1]
XU1 ND2 $PINS O=n1 I1=carry[3] I2=B[3]
XU2 XOR3 $PINS O=SUM[19] I1=B[19] I2=A[19] I3=carry[19]
XU3 ND3P $PINS O=carry[19] I1=n10 I2=n11 I3=n12
XU4 XOR3 $PINS O=SUM[5] I1=B[5] I2=FE_OFN159_i1_w_5 I3=carry[5]
XU5 XOR3 $PINS O=SUM[9] I1=A[9] I2=B[9] I3=carry[9]
XU6 XOR3 $PINS O=SUM[11] I1=B[11] I2=A[11] I3=carry[11]
XU7 XOR3 $PINS O=SUM[18] I1=B[18] I2=A[18] I3=carry[18]
XU8 XOR3 $PINS O=SUM[21] I1=B[21] I2=A[21] I3=carry[21]
XU9 XOR3 $PINS O=SUM[27] I1=A[27] I2=B[27] I3=carry[27]
XU10 XOR3 $PINS O=SUM[26] I1=B[26] I2=A[26] I3=carry[26]
XU11 XOR3S $PINS O=SUM[3] I1=B[3] I2=A[3] I3=carry[3]
XU12 ND2 $PINS O=n2 I1=carry[3] I2=A[3]
XU13 ND2S $PINS O=n3 I1=B[3] I2=A[3]
XU14 ND3P $PINS O=carry[4] I1=n1 I2=n2 I3=n3
XU15 XOR3 $PINS O=SUM[4] I1=B[4] I2=A[4] I3=carry[4]
XU16 ND2P $PINS O=n7 I1=carry[5] I2=B[5]
XU17 AN2 $PINS O=carry[1] I1=B[0] I2=A[0]
XU18 ND3P $PINS O=carry[22] I1=n4 I2=n5 I3=n6
XU19 ND3P $PINS O=carry[5] I1=n43 I2=n42 I3=n44
XU20 ND2 $PINS O=n28 I1=A[9] I2=B[9]
XU21 ND2 $PINS O=n14 I1=A[27] I2=B[27]
XU22 ND2 $PINS O=n4 I1=carry[21] I2=B[21]
XU23 ND2 $PINS O=n5 I1=carry[21] I2=A[21]
XU24 ND2 $PINS O=n6 I1=B[21] I2=A[21]
XU25 ND2 $PINS O=n43 I1=carry[4] I2=A[4]
XU26 ND2P $PINS O=n42 I1=carry[4] I2=B[4]
XU27 ND2 $PINS O=n8 I1=carry[5] I2=A[5]
XU28 ND2 $PINS O=n9 I1=B[5] I2=A[5]
XU29 ND3P $PINS O=carry[6] I1=n8 I2=n7 I3=n9
XU30 ND2 $PINS O=n10 I1=carry[18] I2=B[18]
XU31 ND2 $PINS O=n11 I1=carry[18] I2=A[18]
XU32 ND2 $PINS O=n12 I1=B[18] I2=A[18]
XU34 ND2 $PINS O=n22 I1=carry[19] I2=A[19]
XU35 ND2 $PINS O=n21 I1=carry[19] I2=B[19]
XU36 ND2 $PINS O=n15 I1=A[27] I2=carry[27]
XU37 ND2 $PINS O=n16 I1=B[27] I2=carry[27]
XU38 ND3P $PINS O=carry[28] I1=n16 I2=n15 I3=n14
XU39 XOR2HS $PINS O=n17 I1=A[28] I2=B[28]
XU40 XOR2HS $PINS O=SUM[28] I1=n17 I2=carry[28]
XU41 ND2S $PINS O=n18 I1=A[28] I2=B[28]
XU42 ND2 $PINS O=n19 I1=A[28] I2=carry[28]
XU43 ND2 $PINS O=n20 I1=B[28] I2=carry[28]
XU45 ND2S $PINS O=n23 I1=B[19] I2=A[19]
XU46 ND3P $PINS O=carry[20] I1=n21 I2=n22 I3=n23
XU47 ND2P $PINS O=n24 I1=carry[26] I2=B[26]
XU48 ND2 $PINS O=n25 I1=carry[26] I2=A[26]
XU49 ND2S $PINS O=n26 I1=B[26] I2=A[26]
XU50 ND3P $PINS O=carry[27] I1=n25 I2=n24 I3=n26
XU52 ND2 $PINS O=n29 I1=A[9] I2=carry[9]
XU53 ND2 $PINS O=n30 I1=B[9] I2=carry[9]
XU54 ND3P $PINS O=carry[10] I1=n30 I2=n29 I3=n28
XU55 XOR2HS $PINS O=n31 I1=A[10] I2=B[10]
XU56 XOR2HS $PINS O=SUM[10] I1=n31 I2=carry[10]
XU57 ND2S $PINS O=n32 I1=A[10] I2=B[10]
XU58 ND2 $PINS O=n33 I1=A[10] I2=carry[10]
XU59 ND2 $PINS O=n34 I1=B[10] I2=carry[10]
XU61 ND2 $PINS O=n35 I1=carry[11] I2=B[11]
XU62 ND2 $PINS O=n36 I1=carry[11] I2=A[11]
XU63 ND2S $PINS O=n37 I1=B[11] I2=A[11]
XU64 ND3P $PINS O=carry[12] I1=n35 I2=n36 I3=n37
XU65 XOR2HS $PINS O=n38 I1=B[29] I2=A[29]
XU66 XOR2HS $PINS O=SUM[29] I1=carry[29] I2=n38
XU67 ND2 $PINS O=n39 I1=carry[29] I2=B[29]
XU68 ND2 $PINS O=n40 I1=carry[29] I2=A[29]
XU69 ND2 $PINS O=n41 I1=B[29] I2=A[29]
XU70 ND3P $PINS O=carry[30] I1=n39 I2=n40 I3=n41
XU71 ND2 $PINS O=n44 I1=B[4] I2=A[4]
.ENDS

.SUBCKT Domain_Transfer_1 reset ToMont in_sig Px_i[31] Px_i[30] Px_i[29]
+ Px_i[28] Px_i[27] Px_i[26] Px_i[25] Px_i[24] Px_i[23] Px_i[22] Px_i[21]
+ Px_i[20] Px_i[19] Px_i[18] Px_i[17] Px_i[16] Px_i[15] Px_i[14] Px_i[13]
+ Px_i[12] Px_i[11] Px_i[10] Px_i[9] Px_i[8] Px_i[7] Px_i[6] Px_i[5] Px_i[4]
+ Px_i[3] Px_i[2] Px_i[1] Px_i[0] Py_i[31] Py_i[30] Py_i[29] Py_i[28] Py_i[27]
+ Py_i[26] Py_i[25] Py_i[24] Py_i[23] Py_i[22] Py_i[21] Py_i[20] Py_i[19]
+ Py_i[18] Py_i[17] Py_i[16] Py_i[15] Py_i[14] Py_i[13] Py_i[12] Py_i[11]
+ Py_i[10] Py_i[9] Py_i[8] Py_i[7] Py_i[6] Py_i[5] Py_i[4] Py_i[3] Py_i[2]
+ Py_i[1] Py_i[0] A_i[31] A_i[30] A_i[29] A_i[28] A_i[27] A_i[26] A_i[25]
+ A_i[24] A_i[23] A_i[22] A_i[21] A_i[20] A_i[19] A_i[18] A_i[17] A_i[16]
+ A_i[15] A_i[14] A_i[13] A_i[12] A_i[11] A_i[10] A_i[9] A_i[8] A_i[7] A_i[6]
+ A_i[5] A_i[4] A_i[3] A_i[2] A_i[1] A_i[0] Prime[31] Prime[30] Prime[29]
+ Prime[28] Prime[27] Prime[26] Prime[25] Prime[24] Prime[23] Prime[22]
+ Prime[21] Prime[20] Prime[19] Prime[18] Prime[17] Prime[16] Prime[15]
+ Prime[14] Prime[13] Prime[12] Prime[11] Prime[10] Prime[9] Prime[8] Prime[7]
+ Prime[6] Prime[5] Prime[4] Prime[3] Prime[2] Prime[1] Prime[0] Px_out[31]
+ Px_out[30] Px_out[29] Px_out[28] Px_out[27] Px_out[26] Px_out[25] Px_out[24]
+ Px_out[23] Px_out[22] Px_out[21] Px_out[20] Px_out[19] Px_out[18] Px_out[17]
+ Px_out[16] Px_out[15] Px_out[14] Px_out[13] Px_out[12] Px_out[11] Px_out[10]
+ Px_out[9] Px_out[8] Px_out[7] Px_out[6] Px_out[5] Px_out[4] Px_out[3]
+ Px_out[2] Px_out[1] Px_out[0] Py_out[31] Py_out[30] Py_out[29] Py_out[28]
+ Py_out[27] Py_out[26] Py_out[25] Py_out[24] Py_out[23] Py_out[22] Py_out[21]
+ Py_out[20] Py_out[19] Py_out[18] Py_out[17] Py_out[16] Py_out[15] Py_out[14]
+ Py_out[13] Py_out[12] Py_out[11] Py_out[10] Py_out[9] Py_out[8] Py_out[7]
+ Py_out[6] Py_out[5] Py_out[4] Py_out[3] Py_out[2] Py_out[1] Py_out[0]
+ A_out[31] A_out[30] A_out[29] A_out[28] A_out[27] A_out[26] A_out[25]
+ A_out[24] A_out[23] A_out[22] A_out[21] A_out[20] A_out[19] A_out[18]
+ A_out[17] A_out[16] A_out[15] A_out[14] A_out[13] A_out[12] A_out[11]
+ A_out[10] A_out[9] A_out[8] A_out[7] A_out[6] A_out[5] A_out[4] A_out[3]
+ A_out[2] A_out[1] A_out[0] done p1 p2 p3 p4 p5 p6 p7 p8 p9 p10 p11 p12 p13
+ p14 p15 p16 p17 p18 p19 p20 p21 p22 p23 p24 p25 p26 p27 p28 p29 p30 p31 p32
+ FE_OFN41_FE_DBTN1_i_i_rst FE_OFN37_FE_DBTN1_i_i_rst FE_OFN34_FE_DBTN1_i_i_rst
+ FE_OFN28_FE_DBTN1_i_i_rst FE_OFN23_FE_DBTN1_i_i_rst FE_OFN20_FE_DBTN1_i_i_rst
+ FE_OFN48_raw_prime_31 FE_OFN50_raw_prime_30 FE_OFN54_raw_prime_29
+ FE_OFN58_raw_prime_28 FE_OFN60_raw_prime_27 FE_OFN64_raw_prime_26
+ FE_OFN68_raw_prime_25 FE_OFN72_raw_prime_24 FE_OFN74_raw_prime_23
+ FE_OFN78_raw_prime_22 FE_OFN82_raw_prime_21 FE_OFN86_raw_prime_20
+ FE_OFN88_raw_prime_19 FE_OFN92_raw_prime_18 FE_OFN96_raw_prime_17
+ FE_OFN100_raw_prime_16 FE_OFN104_raw_prime_15 FE_OFN107_raw_prime_14
+ FE_OFN110_raw_prime_13 FE_OFN113_raw_prime_12 FE_OFN117_raw_prime_11
+ FE_OFN120_raw_prime_10 FE_OFN123_raw_prime_9 FE_OFN125_raw_prime_7
+ FE_OFN127_raw_prime_6 FE_OFN130_raw_prime_4 FE_OFN133_n312 FE_OFN132_n312
+ FE_OFN143_raw_prime_8 FE_OFN139_raw_prime_8 FE_OFN138_raw_prime_8
+ FE_OFN136_raw_prime_8 FE_OFN147_raw_prime_2 FE_OFN149_raw_prime_3
+ FE_OFN151_raw_prime_9 FE_OFN150_raw_prime_9 FE_OFN154_raw_prime_5
+ FE_OFN158_raw_prime_8 FE_OFN157_raw_prime_8 FE_OFN167_n FE_OFN162_n
+ FE_OFN168_n310 FE_OFN178_FE_OFN325_n310 FE_OFN179_FE_OFN101_raw_prime_5
+ FE_OFN180_FE_OFN95_raw_prime_7 FE_OFN182_FE_OFN93_raw_prime_2
+ FE_OFN183_FE_OFN89_raw_prime_8 FE_OFN186_FE_OFN87_n312
+ FE_OFN187_FE_OFN85_raw_prime_4 FE_OFN189_FE_OFN59_raw_prime_3
+ FE_OFN192_FE_OFN56_raw_prime_6 FE_OFN191_FE_OFN56_raw_prime_6
+ FE_OFN197_FE_OFN55_raw_prime_7 FE_OFN201_FE_OFN53_raw_prime_9
+ FE_OFN206_FE_OFN52_raw_prime_10 FE_OFN204_FE_OFN52_raw_prime_10
+ FE_OFN212_FE_OFN50_raw_prime_12 FE_OFN215_FE_OFN49_raw_prime_13
+ FE_OFN225_FE_OFN43_raw_prime_19 FE_OFN230_FE_OFN42_raw_prime_20
+ FE_OFN235_FE_OFN41_raw_prime_21 FE_OFN241_FE_OFN39_raw_prime_23
+ FE_OFN243_FE_OFN38_raw_prime_24 FE_OFN248_FE_OFN37_raw_prime_25
+ FE_OFN257_FE_OFN35_raw_prime_27 FE_OFN260_FE_OFN34_raw_prime_28
+ FE_OFN266_FE_OFN32_raw_prime_30 FE_OFN269_FE_OFN31_raw_prime_31
+ FE_OFN279_FE_OFN13_FE_DBTN1_i_i_rst FE_OFN291_FE_OFN8_FE_DBTN1_i_i_rst
+ FE_OFN305_FE_OFN4_FE_DBTN1_i_i_rst FE_OFN314_raw_prime_15
+ FE_OFN316_raw_prime_14 FE_OFN322_n FE_OFN338_n FE_OFN337_n FE_OFN335_n
+ FE_OFN341_n FE_OFN345_n FE_OFN343_n FE_OFN348_raw_prime_2 clk_clone6
+ clk_clone5 clk_clone4 clk_clone3 clk_clone2 clk_clone1 clk p33 p34
XFE_PHC1602_raw2_21 BUF1CK $PINS O=FE_PHN1602_raw2_21 I=Py_i[21]
XFE_PHC1564_i1_w_13 BUF1CK $PINS O=FE_PHN1564_i1_w_13 I=Px_out[13]
XFE_PHC1453_n394 BUF1CK $PINS O=FE_PHN1453_n394 I=n394
XFE_PHC1450_n131 BUF1CK $PINS O=FE_PHN1450_n131 I=n131
XFE_PHC1389_n402 BUF1CK $PINS O=n402 I=FE_PHN1389_n402
XFE_PHC1364_n434 BUF1S $PINS O=n434 I=FE_PHN1364_n434
XFE_PHC1325_i1_w_1 BUF1S $PINS O=Px_out[1] I=FE_PHN1325_i1_w_1
XFE_PHC1320_i2_w_0 BUF1CK $PINS O=Py_out[0] I=FE_PHN1320_i2_w_0
XFE_PHC1306_i1_w_0 BUF1CK $PINS O=Px_out[0] I=FE_PSRN_10
XFE_PHC1301_i1_w_6 BUF1CK $PINS O=Px_out[6] I=FE_PHN1301_i1_w_6
XFE_PHC1201_i1_w_15 BUF1CK $PINS O=FE_PHN1201_i1_w_15 I=Px_out[15]
XFE_PHC1198_transferred_a_w0_31 BUF1CK $PINS O=A_out[31] I=FE_PSRN_6
XFE_PHC971_counter_0 BUF1S $PINS O=FE_PHN971_counter_0 I=counter[0]
XFE_PHC961_counter_3 BUF1S $PINS O=FE_PHN961_counter_3 I=counter[3]
XFE_PHC915_n525 BUF3 $PINS O=FE_PHN915_n525 I=n525
XFE_PHC767_n526 BUF2CK $PINS O=FE_PHN767_n526 I=n526
XFE_PHC744_counter_4 BUF1S $PINS O=counter[4] I=FE_PHN744_counter_4
XFE_OCPC658_n310 BUF1 $PINS O=FE_OCPN663_n310 I=FE_OFN168_n310
XFE_OCPC662_n310 BUF2 $PINS O=FE_OCPN662_n310 I=FE_OFN168_n310
XFE_OFC637_FE_OFN59_raw_prime_3 BUF1 $PINS O=FE_RN_2 I=Prime[3]
XFE_OFC610_n270 BUF1 $PINS O=FE_OFN643_n270 I=n270
XFE_OFC609_n169 BUF1 $PINS O=FE_OFN642_n169 I=n169
XFE_OFC608_n63 BUF2CK $PINS O=FE_OFN641_n63 I=n63
XFE_OFC591_n46 BUF1 $PINS O=FE_OFN624_n46 I=n46
XFE_OFC550_n64 INV1S $PINS O=FE_OFN583_n I=FE_OFN581_n
XFE_OFC549_n64 INV1S $PINS O=FE_OFN582_n I=FE_OFN581_n
XFE_OFC548_n64 INV1S $PINS O=FE_OFN581_n I=FE_OFN580_n
XFE_OFC547_n64 BUF1 $PINS O=FE_OFN580_n I=FE_OFN64_n64
XFE_OFC503_n45 BUF1 $PINS O=FE_OFN536_n45 I=n45
XFE_OFC502_n44 BUF1 $PINS O=FE_OFN535_n44 I=n44
XFE_OFC501_n8 BUF1 $PINS O=FE_OFN534_n8 I=n8
XFE_OFC500_n7 BUF1 $PINS O=FE_OFN533_n7 I=n7
XFE_OFC499_n6 BUF1 $PINS O=FE_OFN532_n6 I=n6
XFE_OFC498_n274 BUF1 $PINS O=FE_OFN531_n274 I=n274
XFE_OFC497_n272 BUF1 $PINS O=FE_OFN530_n272 I=n272
XFE_OFC496_n271 BUF1 $PINS O=FE_OFN529_n271 I=n271
XFE_OFC495_n172 BUF1 $PINS O=FE_OFN528_n172 I=n172
XFE_OFC494_n170 BUF1 $PINS O=FE_OFN527_n170 I=n170
XFE_OFC493_n168 BUF1 $PINS O=FE_OFN526_n168 I=n168
XFE_OFC492_n67 BUF1 $PINS O=FE_OFN525_n67 I=n67
XFE_OFC491_n66 BUF1 $PINS O=FE_OFN524_n66 I=n66
XFE_OFC490_n64 BUF1 $PINS O=FE_OFN523_n64 I=n64
XFE_OFC489_n62 BUF2CK $PINS O=FE_OFN522_n62 I=n62
XFE_OFC384_FE_OFN42_raw_prime_20 BUF1 $PINS O=FE_OFN417_FE_OFN42_raw_prime_20
+ I=FE_OFN86_raw_prime_20
XFE_RC_1584_0 ND3P $PINS O=n60 I1=n36 I2=n37 I3=n35
XFE_RC_915_0 AOI22S $PINS O=n175 A1=FE_OFN528_n172 A2=Py_i[30] B1=Py_add[31]
+ B2=FE_OFN527_n170
XFE_RC_299_0 AOI222HS $PINS O=n28 A1=FE_OFN582_n A2=Py_out[30] B1=N156 B2=n169
+ C1=N355 C2=n168
XFE_RC_198_0 ND3P $PINS O=n61 I1=n41 I2=n42 I3=n43
XFE_RC_146_0 ND3P $PINS O=n167 I1=n38 I2=n39 I3=n40
XFE_OFC125_raw_prime_8 INV1S $PINS O=FE_OFN91_raw_prime_8
+ I=FE_OFN183_FE_OFN89_raw_prime_8
XFE_OFC62_n64 BUF1CK $PINS O=FE_OFN64_n64 I=n64
XFE_DBTC34_i1_w_0 INV1S $PINS O=p32 I=Px_out[0]
XFE_DBTC33_i1_w_1 INV1S $PINS O=p31 I=Px_out[1]
XFE_DBTC32_i1_w_3 INV1S $PINS O=p30 I=Px_out[3]
XFE_DBTC31_i1_w_5 INV1S $PINS O=p29 I=Px_out[5]
XFE_DBTC30_i1_w_7 INV1S $PINS O=p28 I=Px_out[7]
XFE_DBTC29_i1_w_9 INV1S $PINS O=p27 I=Px_out[9]
XFE_DBTC28_i1_w_11 INV1S $PINS O=p26 I=Px_out[11]
XFE_DBTC27_i1_w_13 INV1S $PINS O=p25 I=Px_out[13]
XFE_DBTC26_i1_w_15 INV1S $PINS O=p24 I=Px_out[15]
XFE_DBTC25_i1_w_17 INV1S $PINS O=p23 I=Px_out[17]
XFE_DBTC24_i1_w_19 INV1S $PINS O=p22 I=Px_out[19]
XFE_DBTC23_i1_w_21 INV1S $PINS O=p21 I=Px_out[21]
XFE_DBTC22_i1_w_23 INV1S $PINS O=p20 I=Px_out[23]
XFE_DBTC21_i1_w_25 INV1S $PINS O=p19 I=Px_out[25]
XFE_DBTC20_i1_w_27 INV1S $PINS O=p18 I=Px_out[27]
XFE_DBTC19_i1_w_29 INV1S $PINS O=p17 I=Px_out[29]
XFE_DBTC18_i2_w_0 INV1S $PINS O=p16 I=Py_out[0]
XFE_DBTC17_i2_w_1 INV1S $PINS O=p15 I=Py_out[1]
XFE_DBTC16_i2_w_3 INV1S $PINS O=p14 I=Py_out[3]
XFE_DBTC15_i2_w_5 INV1S $PINS O=p13 I=Py_out[5]
XFE_DBTC14_i2_w_7 INV1S $PINS O=p12 I=Py_out[7]
XFE_DBTC13_i2_w_9 INV1S $PINS O=p11 I=Py_out[9]
XFE_DBTC12_i2_w_11 INV1S $PINS O=p10 I=Py_out[11]
XFE_DBTC11_i2_w_13 INV1S $PINS O=p9 I=Py_out[13]
XFE_DBTC10_i2_w_15 INV1S $PINS O=p8 I=Py_out[15]
XFE_DBTC9_i2_w_17 INV1S $PINS O=p7 I=Py_out[17]
XFE_DBTC8_i2_w_19 INV1S $PINS O=p6 I=Py_out[19]
XFE_DBTC7_i2_w_21 INV1S $PINS O=p5 I=Py_out[21]
XFE_DBTC6_i2_w_23 INV1S $PINS O=p4 I=Py_out[23]
XFE_DBTC5_i2_w_25 INV1S $PINS O=p3 I=Py_out[25]
XFE_DBTC4_i2_w_27 INV1S $PINS O=p2 I=Py_out[27]
XFE_DBTC3_i2_w_29 INV1S $PINS O=p1 I=Py_out[29]
XU257 OR3B2 $PINS O=n57 I1=ToMont B1=n521 B2=in_sig
XU260 OR3B2 $PINS O=n372 I1=n68 B1=n69 B2=n70
XU261 AO222 $PINS O=n68 A1=N421 A2=FE_OFN522_n62 B1=N222 B2=FE_OFN641_n63
+ C1=n64 C2=A_out[30]
XU262 OR3B2 $PINS O=n373 I1=n72 B1=n73 B2=n74
XU263 AO222 $PINS O=n72 A1=N420 A2=FE_OFN522_n62 B1=N221 B2=FE_OFN641_n63
+ C1=A_out[29] C2=n64
XU264 OR3B2 $PINS O=n374 I1=n75 B1=n76 B2=n77
XU265 AO222 $PINS O=n75 A1=N419 A2=FE_OFN522_n62 B1=N220 B2=FE_OFN641_n63
+ C1=A_out[28] C2=n64
XU266 OR3B2 $PINS O=n375 I1=n78 B1=n79 B2=n80
XU267 AO222 $PINS O=n78 A1=N418 A2=FE_OFN522_n62 B1=N219 B2=FE_OFN641_n63
+ C1=A_out[27] C2=n64
XU268 OR3B2 $PINS O=n376 I1=n81 B1=n82 B2=n83
XU269 AO222 $PINS O=n81 A1=N417 A2=FE_OFN522_n62 B1=N218 B2=FE_OFN641_n63
+ C1=A_out[26] C2=n64
XU270 OR3B2 $PINS O=n377 I1=n84 B1=n85 B2=n86
XU271 AO222 $PINS O=n84 A1=N416 A2=FE_OFN522_n62 B1=N217 B2=FE_OFN641_n63
+ C1=A_out[25] C2=n64
XU272 OR3B2 $PINS O=n378 I1=n87 B1=n88 B2=n89
XU273 AO222 $PINS O=n87 A1=N415 A2=FE_OFN522_n62 B1=N216 B2=FE_OFN641_n63
+ C1=A_out[24] C2=n64
XU274 OR3B2 $PINS O=n379 I1=n90 B1=n91 B2=n92
XU275 AO222 $PINS O=n90 A1=N414 A2=FE_OFN522_n62 B1=N215 B2=FE_OFN641_n63
+ C1=A_out[23] C2=n64
XU276 OR3B2 $PINS O=n380 I1=n93 B1=n94 B2=n95
XU277 AO222 $PINS O=n93 A1=N413 A2=FE_OFN522_n62 B1=N214 B2=FE_OFN641_n63
+ C1=A_out[22] C2=n64
XU278 OR3B2 $PINS O=n381 I1=n96 B1=n97 B2=n98
XU279 AO222 $PINS O=n96 A1=N412 A2=FE_OFN522_n62 B1=N213 B2=FE_OFN641_n63
+ C1=A_out[21] C2=n64
XU280 OR3B2 $PINS O=n382 I1=n99 B1=n100 B2=n101
XU281 AO222 $PINS O=n99 A1=N411 A2=FE_OFN522_n62 B1=N212 B2=FE_OFN641_n63
+ C1=A_out[20] C2=n64
XU282 OR3B2 $PINS O=n383 I1=n102 B1=n103 B2=n104
XU283 AO222 $PINS O=n102 A1=N410 A2=FE_OFN522_n62 B1=N211 B2=FE_OFN641_n63
+ C1=A_out[19] C2=n64
XU284 OR3B2 $PINS O=n384 I1=n105 B1=n106 B2=n107
XU285 AO222 $PINS O=n105 A1=N409 A2=FE_OFN522_n62 B1=N210 B2=FE_OFN641_n63
+ C1=A_out[18] C2=FE_OFN523_n64
XU286 OR3B2 $PINS O=n385 I1=n108 B1=n109 B2=n110
XU287 AO222 $PINS O=n108 A1=N408 A2=FE_OFN522_n62 B1=N209 B2=FE_OFN641_n63
+ C1=A_out[17] C2=FE_OFN523_n64
XU288 OR3B2 $PINS O=n386 I1=n111 B1=n112 B2=n113
XU289 AO222 $PINS O=n111 A1=N407 A2=n62 B1=N208 B2=FE_OFN641_n63 C1=A_out[16]
+ C2=FE_OFN523_n64
XU290 OR3B2 $PINS O=n387 I1=n114 B1=n115 B2=n116
XU291 AO222 $PINS O=n114 A1=N406 A2=n62 B1=N207 B2=n63 C1=A_out[15]
+ C2=FE_OFN523_n64
XU292 OR3B2 $PINS O=n388 I1=n117 B1=n118 B2=n119
XU293 AO222 $PINS O=n117 A1=N405 A2=n62 B1=N206 B2=n63 C1=A_out[14]
+ C2=FE_OFN523_n64
XU294 OR3B2 $PINS O=n389 I1=n120 B1=n121 B2=n122
XU295 AO222 $PINS O=n120 A1=N404 A2=n62 B1=N205 B2=n63 C1=A_out[13]
+ C2=FE_OFN523_n64
XU296 OR3B2 $PINS O=n390 I1=n123 B1=n124 B2=n125
XU297 AO222 $PINS O=n123 A1=N403 A2=n62 B1=N204 B2=n63 C1=A_out[12]
+ C2=FE_OFN523_n64
XU298 OR3B2 $PINS O=n391 I1=n126 B1=n127 B2=n128
XU299 AO222 $PINS O=n126 A1=N402 A2=n62 B1=N203 B2=n63 C1=A_out[11]
+ C2=FE_OFN523_n64
XU300 OR3B2 $PINS O=n392 I1=n129 B1=n130 B2=FE_PHN1450_n131
XU301 AO222 $PINS O=n129 A1=N401 A2=n62 B1=N202 B2=n63 C1=A_out[10]
+ C2=FE_OFN523_n64
XU302 OR3B2 $PINS O=n393 I1=n132 B1=n133 B2=n134
XU303 AO222 $PINS O=n132 A1=N400 A2=n62 B1=N201 B2=n63 C1=A_out[9]
+ C2=FE_OFN523_n64
XU304 OR3B2 $PINS O=n394 I1=n135 B1=n136 B2=n137
XU305 AO222 $PINS O=n135 A1=N399 A2=n62 B1=N200 B2=n63 C1=A_out[8]
+ C2=FE_OFN523_n64
XU306 OR3B2 $PINS O=n395 I1=n138 B1=n139 B2=n140
XU307 AO222 $PINS O=n138 A1=N398 A2=n62 B1=N199 B2=n63 C1=A_out[7]
+ C2=FE_OFN523_n64
XU308 OR3B2 $PINS O=n396 I1=n141 B1=n142 B2=n143
XU309 AO222 $PINS O=n141 A1=N397 A2=n62 B1=N198 B2=n63 C1=A_out[6]
+ C2=FE_OFN523_n64
XU310 OR3B2 $PINS O=n397 I1=n144 B1=n145 B2=n146
XU311 AO222 $PINS O=n144 A1=N396 A2=n62 B1=N197 B2=n63 C1=A_out[5]
+ C2=FE_OFN523_n64
XU312 OR3B2 $PINS O=n398 I1=n147 B1=n148 B2=n149
XU313 AO222 $PINS O=n147 A1=N395 A2=n62 B1=N196 B2=n63 C1=A_out[4]
+ C2=FE_OFN523_n64
XU314 OR3B2 $PINS O=n399 I1=n150 B1=n151 B2=n152
XU315 AO222 $PINS O=n150 A1=N394 A2=n62 B1=N195 B2=n63 C1=A_out[3]
+ C2=FE_OFN523_n64
XU316 OR3B2 $PINS O=n400 I1=n153 B1=n154 B2=n155
XU317 AO222 $PINS O=n153 A1=N393 A2=n62 B1=N194 B2=n63 C1=A_out[2]
+ C2=FE_OFN523_n64
XU318 OR3B2 $PINS O=n401 I1=n156 B1=n157 B2=n158
XU319 AO222 $PINS O=n156 A1=N392 A2=n62 B1=N193 B2=n63 C1=A_out[1]
+ C2=FE_OFN523_n64
XU320 ND2 $PINS O=n161 I1=A_i[0] I2=n67
XU321 AO12 $PINS O=n165 A1=n64 B1=A_add[1] B2=n159
XU326 OR3B2 $PINS O=n405 I1=n177 B1=n178 B2=n179
XU327 AO222 $PINS O=n177 A1=N354 A2=n168 B1=N155 B2=n169 C1=Py_out[29]
+ C2=FE_OFN582_n
XU328 OR3B2 $PINS O=n406 I1=n180 B1=n181 B2=n182
XU329 AO222 $PINS O=n180 A1=N353 A2=n168 B1=N154 B2=n169 C1=Py_out[28]
+ C2=FE_OFN582_n
XU330 OR3B2 $PINS O=n407 I1=n183 B1=n184 B2=n185
XU331 AO222 $PINS O=n183 A1=N352 A2=n168 B1=N153 B2=n169 C1=Py_out[27]
+ C2=FE_OFN582_n
XU332 OR3B2 $PINS O=n408 I1=n186 B1=n187 B2=n188
XU333 AO222 $PINS O=n186 A1=N351 A2=FE_OFN526_n168 B1=N152 B2=n169
+ C1=Py_out[26] C2=FE_OFN582_n
XU334 OR3B2 $PINS O=n409 I1=n189 B1=n190 B2=n191
XU335 AO222 $PINS O=n189 A1=N350 A2=FE_OFN526_n168 B1=N151 B2=n169
+ C1=Py_out[25] C2=FE_OFN582_n
XU336 OR3B2 $PINS O=n410 I1=n192 B1=n193 B2=n194
XU337 AO222 $PINS O=n192 A1=N349 A2=FE_OFN526_n168 B1=N150 B2=n169
+ C1=Py_out[24] C2=FE_OFN582_n
XU338 OR3B2 $PINS O=n411 I1=n195 B1=n196 B2=n197
XU339 AO222 $PINS O=n195 A1=N348 A2=FE_OFN526_n168 B1=N149 B2=n169
+ C1=Py_out[23] C2=FE_OFN582_n
XU340 OR3B2 $PINS O=n412 I1=n198 B1=n199 B2=n200
XU341 AO222 $PINS O=n198 A1=N347 A2=FE_OFN526_n168 B1=N148 B2=FE_OFN642_n169
+ C1=Py_out[22] C2=FE_OFN583_n
XU342 OR3B2 $PINS O=n413 I1=n201 B1=n202 B2=n203
XU343 AO222 $PINS O=n201 A1=N346 A2=FE_OFN526_n168 B1=N147 B2=FE_OFN642_n169
+ C1=Py_out[21] C2=FE_OFN583_n
XU344 OR3B2 $PINS O=n414 I1=n204 B1=n205 B2=n206
XU345 AO222 $PINS O=n204 A1=N345 A2=FE_OFN526_n168 B1=N146 B2=FE_OFN642_n169
+ C1=Py_out[20] C2=FE_OFN583_n
XU346 OR3B2 $PINS O=n415 I1=n207 B1=n208 B2=n209
XU347 AO222 $PINS O=n207 A1=N344 A2=FE_OFN526_n168 B1=N145 B2=FE_OFN642_n169
+ C1=Py_out[19] C2=FE_OFN583_n
XU348 OR3B2 $PINS O=n416 I1=n210 B1=n211 B2=n212
XU349 AO222 $PINS O=n210 A1=N343 A2=FE_OFN526_n168 B1=N144 B2=FE_OFN642_n169
+ C1=Py_out[18] C2=FE_OFN583_n
XU350 OR3B2 $PINS O=n417 I1=n213 B1=n214 B2=n215
XU351 AO222 $PINS O=n213 A1=N342 A2=FE_OFN526_n168 B1=N143 B2=FE_OFN642_n169
+ C1=Py_out[17] C2=FE_OFN583_n
XU352 OR3B2P $PINS O=n418 I1=n216 B1=n217 B2=n218
XU353 AO222 $PINS O=n216 A1=N341 A2=FE_OFN526_n168 B1=N142 B2=FE_OFN642_n169
+ C1=Py_out[16] C2=FE_OFN583_n
XU354 OR3B2 $PINS O=n419 I1=n219 B1=n220 B2=n221
XU355 AO222 $PINS O=n219 A1=N340 A2=FE_OFN526_n168 B1=N141 B2=FE_OFN642_n169
+ C1=Py_out[15] C2=FE_OFN583_n
XU356 OR3B2 $PINS O=n420 I1=n222 B1=n223 B2=n224
XU357 AO222 $PINS O=n222 A1=N339 A2=FE_OFN526_n168 B1=N140 B2=FE_OFN642_n169
+ C1=Py_out[14] C2=FE_OFN583_n
XU358 OR3B2 $PINS O=n421 I1=n225 B1=n226 B2=n227
XU359 AO222 $PINS O=n225 A1=N338 A2=FE_OFN526_n168 B1=N139 B2=FE_OFN642_n169
+ C1=Py_out[13] C2=FE_OFN583_n
XU360 OR3B2 $PINS O=n422 I1=n228 B1=n229 B2=n230
XU361 AO222 $PINS O=n228 A1=N337 A2=FE_OFN526_n168 B1=N138 B2=n169
+ C1=Py_out[12] C2=FE_OFN582_n
XU362 OR3B2 $PINS O=n423 I1=n231 B1=n232 B2=n233
XU363 AO222 $PINS O=n231 A1=N336 A2=FE_OFN526_n168 B1=N137 B2=n169
+ C1=Py_out[11] C2=FE_OFN582_n
XU364 OR3B2 $PINS O=n424 I1=n234 B1=n235 B2=n236
XU365 AO222 $PINS O=n234 A1=N335 A2=FE_OFN526_n168 B1=N136 B2=n169
+ C1=Py_out[10] C2=FE_OFN582_n
XU366 OR3B2 $PINS O=n425 I1=n237 B1=n238 B2=n239
XU367 AO222 $PINS O=n237 A1=N334 A2=FE_OFN526_n168 B1=N135 B2=n169 C1=Py_out[9]
+ C2=FE_OFN582_n
XU368 OR3B2 $PINS O=n426 I1=n240 B1=n241 B2=n242
XU369 AO222 $PINS O=n240 A1=N333 A2=FE_OFN526_n168 B1=N134 B2=n169 C1=Py_out[8]
+ C2=FE_OFN582_n
XU370 OR3B2 $PINS O=n427 I1=n243 B1=n244 B2=n245
XU371 AO222 $PINS O=n243 A1=N332 A2=FE_OFN526_n168 B1=N133 B2=n169 C1=Py_out[7]
+ C2=FE_OFN582_n
XU372 OR3B2 $PINS O=n428 I1=n246 B1=n247 B2=n248
XU373 AO222 $PINS O=n246 A1=N331 A2=n168 B1=N132 B2=FE_OFN642_n169 C1=Py_out[6]
+ C2=FE_OFN583_n
XU374 OR3B2 $PINS O=n429 I1=n249 B1=n250 B2=n251
XU375 AO222 $PINS O=n249 A1=N330 A2=n168 B1=N131 B2=FE_OFN642_n169 C1=Py_out[5]
+ C2=FE_OFN583_n
XU376 OR3B2 $PINS O=n430 I1=n252 B1=n253 B2=n254
XU377 AO222 $PINS O=n252 A1=N329 A2=n168 B1=N130 B2=FE_OFN642_n169 C1=Py_out[4]
+ C2=FE_OFN583_n
XU378 OR3B2 $PINS O=n431 I1=n255 B1=n256 B2=n257
XU379 AO222 $PINS O=n255 A1=N328 A2=n168 B1=N129 B2=FE_OFN642_n169 C1=Py_out[3]
+ C2=FE_OFN583_n
XU380 OR3B2P $PINS O=n432 I1=n258 B1=n259 B2=n260
XU381 AO222 $PINS O=n258 A1=N327 A2=n168 B1=N128 B2=FE_OFN642_n169 C1=Py_out[2]
+ C2=FE_OFN583_n
XU382 OR3B2 $PINS O=n433 I1=n261 B1=n262 B2=n263
XU383 AO222 $PINS O=n261 A1=N326 A2=n168 B1=N127 B2=FE_OFN642_n169 C1=Py_out[1]
+ C2=FE_OFN580_n
XU384 ND2 $PINS O=n265 I1=Py_i[0] I2=n172
XU385 AO12 $PINS O=n267 A1=FE_OFN580_n B1=Py_add[1] B2=n159
XU386 AO222 $PINS O=n269 A1=N91 A2=n270 B1=Px_i[31] B2=n271 C1=Px_out[31]
+ C2=FE_OFN64_n64
XU388 OR3B2 $PINS O=n436 I1=n275 B1=n276 B2=n277
XU390 OR3B2 $PINS O=n437 I1=n279 B1=n280 B2=n281
XU391 AO222 $PINS O=n279 A1=N89 A2=n270 B1=Px_i[29] B2=n271 C1=Px_out[29]
+ C2=FE_OFN64_n64
XU392 OR3B2 $PINS O=n438 I1=n282 B1=n283 B2=n284
XU393 AO222 $PINS O=n282 A1=N88 A2=n270 B1=Px_i[28] B2=n271 C1=Px_out[28]
+ C2=FE_OFN64_n64
XU394 OR3B2 $PINS O=n439 I1=n285 B1=n286 B2=n287
XU395 AO222 $PINS O=n285 A1=N87 A2=n270 B1=Px_i[27] B2=n271 C1=Px_out[27]
+ C2=FE_OFN64_n64
XU396 OR3B2 $PINS O=n440 I1=n288 B1=n289 B2=n290
XU397 AO222 $PINS O=n288 A1=N86 A2=n270 B1=Px_i[26] B2=n271 C1=Px_out[26]
+ C2=FE_OFN64_n64
XU398 OR3B2 $PINS O=n441 I1=n291 B1=n292 B2=n293
XU400 OR3B2 $PINS O=n442 I1=n294 B1=n295 B2=n296
XU401 AO222 $PINS O=n294 A1=N84 A2=n270 B1=Px_i[24] B2=n271 C1=Px_out[24]
+ C2=FE_OFN64_n64
XU402 OR3B2 $PINS O=n443 I1=n297 B1=n298 B2=n299
XU403 AO222 $PINS O=n297 A1=N83 A2=n270 B1=Px_i[23] B2=n271 C1=Px_out[23]
+ C2=FE_OFN64_n64
XU404 OR3B2 $PINS O=n444 I1=n300 B1=n301 B2=n302
XU406 OR3B2 $PINS O=n445 I1=n303 B1=n304 B2=n305
XU407 AO222 $PINS O=n303 A1=N81 A2=n270 B1=Px_i[21] B2=n271 C1=Px_out[21]
+ C2=FE_OFN64_n64
XU408 OR3B2 $PINS O=n446 I1=n306 B1=n307 B2=n308
XU409 AO222 $PINS O=n306 A1=N80 A2=n270 B1=Px_i[20] B2=n271 C1=Px_out[20]
+ C2=FE_OFN64_n64
XU410 OR3B2 $PINS O=n447 I1=n309 B1=n310 B2=n311
XU411 AO222 $PINS O=n309 A1=N79 A2=FE_OFN643_n270 B1=Px_i[19] B2=FE_OFN529_n271
+ C1=Px_out[19] C2=FE_OFN64_n64
XU412 OR3B2 $PINS O=n448 I1=n312 B1=n313 B2=n314
XU413 AO222 $PINS O=n312 A1=N78 A2=FE_OFN643_n270 B1=Px_i[18] B2=FE_OFN529_n271
+ C1=Px_out[18] C2=FE_OFN64_n64
XU414 OR3B2 $PINS O=n449 I1=n315 B1=n316 B2=n317
XU415 AO222 $PINS O=n315 A1=N77 A2=FE_OFN643_n270 B1=Px_i[17] B2=FE_OFN529_n271
+ C1=Px_out[17] C2=FE_OFN580_n
XU416 OR3B2 $PINS O=n450 I1=n318 B1=n319 B2=n320
XU417 AO222 $PINS O=n318 A1=N76 A2=FE_OFN643_n270 B1=Px_i[16] B2=FE_OFN529_n271
+ C1=Px_out[16] C2=FE_OFN64_n64
XU418 OR3B2 $PINS O=n451 I1=n321 B1=n322 B2=n323
XU419 AO222 $PINS O=n321 A1=N75 A2=FE_OFN643_n270 B1=Px_i[15] B2=FE_OFN529_n271
+ C1=Px_out[15] C2=FE_OFN580_n
XU420 OR3B2 $PINS O=n452 I1=n324 B1=n325 B2=n326
XU421 AO222 $PINS O=n324 A1=N74 A2=FE_OFN643_n270 B1=Px_i[14] B2=FE_OFN529_n271
+ C1=Px_out[14] C2=FE_OFN580_n
XU422 OR3B2 $PINS O=n453 I1=n327 B1=n328 B2=n329
XU423 AO222 $PINS O=n327 A1=N73 A2=FE_OFN643_n270 B1=Px_i[13] B2=FE_OFN529_n271
+ C1=Px_out[13] C2=FE_OFN580_n
XU424 OR3B2 $PINS O=n454 I1=n330 B1=n331 B2=n332
XU425 AO222 $PINS O=n330 A1=N72 A2=FE_OFN643_n270 B1=Px_i[12] B2=FE_OFN529_n271
+ C1=Px_out[12] C2=FE_OFN580_n
XU426 OR3B2 $PINS O=n455 I1=n333 B1=n334 B2=n335
XU427 AO222 $PINS O=n333 A1=N71 A2=FE_OFN643_n270 B1=Px_i[11] B2=FE_OFN529_n271
+ C1=Px_out[11] C2=FE_OFN580_n
XU428 OR3B2 $PINS O=n456 I1=n336 B1=n337 B2=n338
XU429 AO222 $PINS O=n336 A1=N70 A2=FE_OFN643_n270 B1=Px_i[10] B2=FE_OFN529_n271
+ C1=Px_out[10] C2=FE_OFN580_n
XU430 OR3B2 $PINS O=n457 I1=n339 B1=n340 B2=n341
XU431 AO222 $PINS O=n339 A1=N69 A2=FE_OFN643_n270 B1=Px_i[9] B2=FE_OFN529_n271
+ C1=Px_out[9] C2=FE_OFN580_n
XU432 OR3B2 $PINS O=n458 I1=n342 B1=n343 B2=n344
XU433 AO222 $PINS O=n342 A1=N68 A2=FE_OFN643_n270 B1=Px_i[8] B2=FE_OFN529_n271
+ C1=Px_out[8] C2=FE_OFN580_n
XU434 OR3B2 $PINS O=n459 I1=n345 B1=n346 B2=n347
XU435 AO222 $PINS O=n345 A1=N67 A2=FE_OFN643_n270 B1=Px_i[7] B2=FE_OFN529_n271
+ C1=Px_out[7] C2=FE_OFN580_n
XU436 OR3B2 $PINS O=n460 I1=n348 B1=n349 B2=n350
XU437 AO222 $PINS O=n348 A1=N66 A2=FE_OFN643_n270 B1=Px_i[6] B2=FE_OFN529_n271
+ C1=Px_out[6] C2=FE_OFN580_n
XU438 OR3B2 $PINS O=n461 I1=n351 B1=n352 B2=n353
XU439 AO222 $PINS O=n351 A1=N65 A2=FE_OFN643_n270 B1=Px_i[5] B2=FE_OFN529_n271
+ C1=Px_out[5] C2=FE_OFN580_n
XU440 OR3B2 $PINS O=n462 I1=n354 B1=n355 B2=n356
XU441 AO222 $PINS O=n354 A1=N64 A2=FE_OFN643_n270 B1=Px_i[4] B2=FE_OFN529_n271
+ C1=Px_out[4] C2=FE_OFN580_n
XU442 OR3B2 $PINS O=n463 I1=n357 B1=n358 B2=n359
XU443 AO222 $PINS O=n357 A1=N63 A2=FE_OFN643_n270 B1=Px_i[3] B2=FE_OFN529_n271
+ C1=Px_out[3] C2=FE_OFN580_n
XU444 OR3B2 $PINS O=n464 I1=n360 B1=n361 B2=n362
XU446 OR3B2 $PINS O=n465 I1=n363 B1=n364 B2=n365
XU447 AO222 $PINS O=n363 A1=N61 A2=FE_OFN643_n270 B1=Px_i[1] B2=FE_OFN529_n271
+ C1=Px_out[1] C2=FE_OFN580_n
XU448 ND2 $PINS O=n367 I1=FE_OCPN663_n310 I2=FE_OFN531_n274
XU449 AO12 $PINS O=n369 A1=FE_OFN580_n B1=Px_add[1] B2=n159
XU450 AO22 $PINS O=n467 A1=FE_PHN961_counter_3 A2=done B1=N43 B2=n370
XU451 AO22 $PINS O=n471 A1=counter[4] A2=done B1=N44 B2=n370
XU452 ND2 $PINS O=n370 I1=n519 I2=n522
Xsub_2791_S2 Domain_Transfer_1_DW01_sub_0 $PINS A[31]=A_out[30] A[30]=A_out[29]
+ A[29]=A_out[28] A[28]=A_out[27] A[27]=A_out[26] A[26]=A_out[25] A[25]=A_out[24]
+ A[24]=A_out[23] A[23]=A_out[22] A[22]=A_out[21] A[21]=A_out[20] A[20]=A_out[19]
+ A[19]=A_out[18] A[18]=A_out[17] A[17]=A_out[16] A[16]=A_out[15] A[15]=A_out[14]
+ A[14]=A_out[13] A[13]=A_out[12] A[12]=A_out[11] A[11]=A_out[10] A[10]=A_out[9]
+ A[9]=A_out[8] A[8]=A_out[7] A[7]=A_out[6] A[6]=A_out[5] A[5]=A_out[4]
+ A[4]=A_out[3] A[3]=A_out[2] A[2]=A_out[1] A[1]=A_out[0] A[0]=n21
+ B[31]=Prime[31] B[30]=Prime[30] B[29]=Prime[29] B[28]=Prime[28] B[27]=Prime[27]
+ B[26]=Prime[26] B[25]=Prime[25] B[24]=Prime[24] B[23]=Prime[23] B[22]=Prime[22]
+ B[21]=Prime[21] B[20]=Prime[20] B[19]=Prime[19] B[18]=Prime[18] B[17]=Prime[17]
+ B[16]=Prime[16] B[15]=FE_OFN322_n B[14]=FE_OFN107_raw_prime_14
+ B[13]=FE_OFN110_raw_prime_13 B[12]=Prime[12] B[11]=FE_OFN117_raw_prime_11
+ B[10]=Prime[10] B[9]=Prime[9] B[8]=FE_OFN136_raw_prime_8
+ B[7]=FE_OFN125_raw_prime_7 B[6]=FE_OFN191_FE_OFN56_raw_prime_6 B[5]=Prime[5]
+ B[4]=FE_OFN130_raw_prime_4 B[3]=FE_OFN149_raw_prime_3 B[2]=FE_OFN162_n
+ B[1]=FE_OFN132_n312 B[0]=Prime[0] CI=n21 DIFF[31]=N422 DIFF[30]=N421
+ DIFF[29]=N420 DIFF[28]=N419 DIFF[27]=N418 DIFF[26]=N417 DIFF[25]=N416
+ DIFF[24]=N415 DIFF[23]=N414 DIFF[22]=N413 DIFF[21]=N412 DIFF[20]=N411
+ DIFF[19]=N410 DIFF[18]=N409 DIFF[17]=N408 DIFF[16]=N407 DIFF[15]=N406
+ DIFF[14]=N405 DIFF[13]=N404 DIFF[12]=N403 DIFF[11]=N402 DIFF[10]=N401
+ DIFF[9]=N400 DIFF[8]=N399 DIFF[7]=N398 DIFF[6]=N397 DIFF[5]=N396 DIFF[4]=N395
+ DIFF[3]=N394 DIFF[2]=N393 DIFF[1]=N392 DIFF[0]=N391
Xgte_2791 Domain_Transfer_1_DW_cmp_0 $PINS A[32]=A_out[31] A[31]=A_out[30]
+ A[30]=A_out[29] A[29]=A_out[28] A[28]=A_out[27] A[27]=A_out[26] A[26]=A_out[25]
+ A[25]=A_out[24] A[24]=A_out[23] A[23]=A_out[22] A[22]=A_out[21] A[21]=A_out[20]
+ A[20]=A_out[19] A[19]=A_out[18] A[18]=A_out[17] A[17]=A_out[16] A[16]=A_out[15]
+ A[15]=A_out[14] A[14]=A_out[13] A[13]=A_out[12] A[12]=A_out[11] A[11]=A_out[10]
+ A[10]=A_out[9] A[9]=A_out[8] A[8]=A_out[7] A[7]=A_out[6] A[6]=A_out[5]
+ A[5]=A_out[4] A[4]=A_out[3] A[3]=A_out[2] A[2]=A_out[1] A[1]=A_out[0] A[0]=n21
+ B[32]=n21 B[31]=Prime[31] B[30]=Prime[30] B[29]=Prime[29] B[28]=Prime[28]
+ B[27]=Prime[27] B[26]=Prime[26] B[25]=Prime[25] B[24]=Prime[24] B[23]=Prime[23]
+ B[22]=Prime[22] B[21]=Prime[21] B[20]=Prime[20] B[19]=Prime[19] B[18]=Prime[18]
+ B[17]=Prime[17] B[16]=Prime[16] B[15]=FE_OFN322_n B[14]=FE_OFN107_raw_prime_14
+ B[13]=FE_OFN110_raw_prime_13 B[12]=Prime[12] B[11]=FE_OFN117_raw_prime_11
+ B[10]=Prime[10] B[9]=Prime[9] B[8]=FE_OFN143_raw_prime_8
+ B[7]=FE_OFN197_FE_OFN55_raw_prime_7 B[6]=FE_OFN191_FE_OFN56_raw_prime_6
+ B[5]=Prime[5] B[4]=FE_OFN130_raw_prime_4 B[3]=FE_OFN149_raw_prime_3
+ B[2]=FE_OFN167_n B[1]=FE_OFN132_n312 B[0]=Prime[0] TC=n21 GE_LT=n18
+ GE_GT_EQ=n18 GE_LT_GT_LE=N389
Xsub_2789_S2 Domain_Transfer_1_DW01_sub_1 $PINS A[31]=Py_out[30]
+ A[30]=Py_out[29] A[29]=Py_out[28] A[28]=Py_out[27] A[27]=Py_out[26]
+ A[26]=Py_out[25] A[25]=Py_out[24] A[24]=Py_out[23] A[23]=Py_out[22]
+ A[22]=Py_out[21] A[21]=Py_out[20] A[20]=Py_out[19] A[19]=Py_out[18]
+ A[18]=Py_out[17] A[17]=Py_out[16] A[16]=Py_out[15] A[15]=Py_out[14]
+ A[14]=Py_out[13] A[13]=Py_out[12] A[12]=Py_out[11] A[11]=Py_out[10]
+ A[10]=Py_out[9] A[9]=Py_out[8] A[8]=Py_out[7] A[7]=Py_out[6] A[6]=Py_out[5]
+ A[5]=Py_out[4] A[4]=Py_out[3] A[3]=Py_out[2] A[2]=Py_out[1] A[1]=Py_out[0]
+ A[0]=n21 B[31]=FE_OFN269_FE_OFN31_raw_prime_31 B[30]=FE_OFN50_raw_prime_30
+ B[29]=FE_OFN54_raw_prime_29 B[28]=FE_OFN58_raw_prime_28
+ B[27]=FE_OFN257_FE_OFN35_raw_prime_27 B[26]=FE_OFN64_raw_prime_26
+ B[25]=FE_OFN68_raw_prime_25 B[24]=FE_OFN72_raw_prime_24
+ B[23]=FE_OFN241_FE_OFN39_raw_prime_23 B[22]=FE_OFN78_raw_prime_22
+ B[21]=FE_OFN235_FE_OFN41_raw_prime_21 B[20]=FE_OFN417_FE_OFN42_raw_prime_20
+ B[19]=FE_OFN225_FE_OFN43_raw_prime_19 B[18]=FE_OFN92_raw_prime_18
+ B[17]=FE_OFN96_raw_prime_17 B[16]=FE_OFN100_raw_prime_16
+ B[15]=FE_OFN314_raw_prime_15 B[14]=FE_OFN316_raw_prime_14 B[13]=Prime[13]
+ B[12]=FE_OFN212_FE_OFN50_raw_prime_12 B[11]=Prime[11]
+ B[10]=FE_OFN204_FE_OFN52_raw_prime_10 B[9]=FE_OFN150_raw_prime_9
+ B[8]=FE_OFN139_raw_prime_8 B[7]=Prime[7] B[6]=FE_OFN127_raw_prime_6
+ B[5]=FE_OFN154_raw_prime_5 B[4]=Prime[4] B[3]=FE_RN_2
+ B[2]=FE_OFN348_raw_prime_2 B[1]=Prime[1] B[0]=FE_OFN168_n310 CI=n21
+ DIFF[31]=N356 DIFF[30]=N355 DIFF[29]=N354 DIFF[28]=N353 DIFF[27]=N352
+ DIFF[26]=N351 DIFF[25]=N350 DIFF[24]=N349 DIFF[23]=N348 DIFF[22]=N347
+ DIFF[21]=N346 DIFF[20]=N345 DIFF[19]=N344 DIFF[18]=N343 DIFF[17]=N342
+ DIFF[16]=N341 DIFF[15]=N340 DIFF[14]=N339 DIFF[13]=N338 DIFF[12]=N337
+ DIFF[11]=N336 DIFF[10]=N335 DIFF[9]=N334 DIFF[8]=N333 DIFF[7]=N332 DIFF[6]=N331
+ DIFF[5]=N330 DIFF[4]=N329 DIFF[3]=N328 DIFF[2]=N327 DIFF[1]=N326 DIFF[0]=N325
Xgte_2789 Domain_Transfer_1_DW_cmp_1 $PINS A[32]=Py_out[31] A[31]=Py_out[30]
+ A[30]=p1 A[29]=Py_out[28] A[28]=p2 A[27]=Py_out[26] A[26]=p3 A[25]=Py_out[24]
+ A[24]=p4 A[23]=Py_out[22] A[22]=p5 A[21]=Py_out[20] A[20]=p6 A[19]=Py_out[18]
+ A[18]=p7 A[17]=Py_out[16] A[16]=p8 A[15]=Py_out[14] A[14]=p9 A[13]=Py_out[12]
+ A[12]=p10 A[11]=Py_out[10] A[10]=p11 A[9]=Py_out[8] A[8]=p12 A[7]=Py_out[6]
+ A[6]=p13 A[5]=Py_out[4] A[4]=p14 A[3]=Py_out[2] A[2]=p15 A[1]=p16 A[0]=n21
+ B[32]=n21 B[31]=FE_OFN269_FE_OFN31_raw_prime_31 B[30]=FE_OFN50_raw_prime_30
+ B[29]=FE_OFN54_raw_prime_29 B[28]=FE_OFN58_raw_prime_28
+ B[27]=FE_OFN257_FE_OFN35_raw_prime_27 B[26]=FE_OFN64_raw_prime_26
+ B[25]=FE_OFN248_FE_OFN37_raw_prime_25 B[24]=FE_OFN72_raw_prime_24
+ B[23]=FE_OFN241_FE_OFN39_raw_prime_23 B[22]=FE_OFN78_raw_prime_22
+ B[21]=FE_OFN235_FE_OFN41_raw_prime_21 B[20]=FE_OFN417_FE_OFN42_raw_prime_20
+ B[19]=FE_OFN225_FE_OFN43_raw_prime_19 B[18]=FE_OFN92_raw_prime_18
+ B[17]=FE_OFN96_raw_prime_17 B[16]=FE_OFN100_raw_prime_16
+ B[15]=FE_OFN314_raw_prime_15 B[14]=FE_OFN316_raw_prime_14 B[13]=Prime[13]
+ B[12]=FE_OFN212_FE_OFN50_raw_prime_12 B[11]=Prime[11]
+ B[10]=FE_OFN204_FE_OFN52_raw_prime_10 B[9]=FE_OFN151_raw_prime_9
+ B[8]=FE_OFN91_raw_prime_8 B[7]=Prime[7] B[6]=FE_OFN127_raw_prime_6
+ B[5]=FE_OFN154_raw_prime_5 B[4]=FE_OFN187_FE_OFN85_raw_prime_4 B[3]=Prime[3]
+ B[2]=FE_OFN348_raw_prime_2 B[1]=FE_OFN133_n312 B[0]=FE_OFN178_FE_OFN325_n310
+ TC=n21 GE_LT=n18 GE_GT_EQ=n18 GE_LT_GT_LE=N323
+ FE_OFN267_FE_OFN32_raw_prime_30=FE_OFN266_FE_OFN32_raw_prime_30
Xsub_2787_S2 Domain_Transfer_1_DW01_sub_2 $PINS A[31]=Px_out[30]
+ A[30]=Px_out[29] A[29]=Px_out[28] A[28]=Px_out[27] A[27]=Px_out[26]
+ A[26]=Px_out[25] A[25]=Px_out[24] A[24]=Px_out[23] A[23]=Px_out[22]
+ A[22]=Px_out[21] A[21]=Px_out[20] A[20]=Px_out[19] A[19]=Px_out[18]
+ A[18]=Px_out[17] A[17]=Px_out[16] A[16]=Px_out[15] A[15]=Px_out[14]
+ A[14]=Px_out[13] A[13]=Px_out[12] A[12]=Px_out[11] A[11]=Px_out[10]
+ A[10]=Px_out[9] A[9]=Px_out[8] A[8]=Px_out[7] A[7]=Px_out[6] A[6]=Px_out[5]
+ A[5]=Px_out[4] A[4]=Px_out[3] A[3]=Px_out[2] A[2]=Px_out[1] A[1]=Px_out[0]
+ A[0]=n21 B[31]=FE_OFN48_raw_prime_31 B[30]=Prime[30] B[29]=Prime[29]
+ B[28]=FE_OFN260_FE_OFN34_raw_prime_28 B[27]=Prime[27] B[26]=Prime[26]
+ B[25]=Prime[25] B[24]=FE_OFN243_FE_OFN38_raw_prime_24 B[23]=Prime[23]
+ B[22]=Prime[22] B[21]=Prime[21] B[20]=FE_OFN86_raw_prime_20 B[19]=Prime[19]
+ B[18]=Prime[18] B[17]=Prime[17] B[16]=FE_OFN100_raw_prime_16
+ B[15]=FE_OFN104_raw_prime_15 B[14]=FE_OFN107_raw_prime_14
+ B[13]=FE_OFN215_FE_OFN49_raw_prime_13 B[12]=FE_OFN113_raw_prime_12
+ B[11]=FE_OFN117_raw_prime_11 B[10]=FE_OFN206_FE_OFN52_raw_prime_10
+ B[9]=FE_OFN201_FE_OFN53_raw_prime_9 B[8]=FE_OFN138_raw_prime_8
+ B[7]=FE_OFN180_FE_OFN95_raw_prime_7 B[6]=FE_OFN192_FE_OFN56_raw_prime_6
+ B[5]=FE_OFN179_FE_OFN101_raw_prime_5 B[4]=Prime[4] B[3]=Prime[3]
+ B[2]=FE_OFN182_FE_OFN93_raw_prime_2 B[1]=Prime[1] B[0]=FE_OFN168_n310 CI=n21
+ DIFF[31]=N290 DIFF[30]=N289 DIFF[29]=N288 DIFF[28]=N287 DIFF[27]=N286
+ DIFF[26]=N285 DIFF[25]=N284 DIFF[24]=N283 DIFF[23]=N282 DIFF[22]=N281
+ DIFF[21]=N280 DIFF[20]=N279 DIFF[19]=N278 DIFF[18]=N277 DIFF[17]=N276
+ DIFF[16]=N275 DIFF[15]=N274 DIFF[14]=N273 DIFF[13]=N272 DIFF[12]=N271
+ DIFF[11]=N270 DIFF[10]=N269 DIFF[9]=N268 DIFF[8]=N267 DIFF[7]=N266 DIFF[6]=N265
+ DIFF[5]=N264 DIFF[4]=N263 DIFF[3]=N262 DIFF[2]=N261 DIFF[1]=N260
+ DIFF[0]=FE_UNCONNECTEDZ_0
Xgte_2787 Domain_Transfer_1_DW_cmp_2 $PINS A[32]=Px_out[31] A[31]=Px_out[30]
+ A[30]=p17 A[29]=Px_out[28] A[28]=p18 A[27]=Px_out[26] A[26]=p19
+ A[25]=Px_out[24] A[24]=p20 A[23]=Px_out[22] A[22]=p21 A[21]=Px_out[20]
+ A[20]=p22 A[19]=Px_out[18] A[18]=p23 A[17]=Px_out[16] A[16]=p24
+ A[15]=Px_out[14] A[14]=p25 A[13]=Px_out[12] A[12]=p26 A[11]=Px_out[10]
+ A[10]=p27 A[9]=Px_out[8] A[8]=p28 A[7]=Px_out[6] A[6]=p29 A[5]=Px_out[4]
+ A[4]=p30 A[3]=Px_out[2] A[2]=p31 A[1]=p32 A[0]=n21 B[32]=n21
+ B[31]=FE_OFN48_raw_prime_31 B[30]=Prime[30] B[29]=Prime[29]
+ B[28]=FE_OFN260_FE_OFN34_raw_prime_28 B[27]=Prime[27] B[26]=Prime[26]
+ B[25]=Prime[25] B[24]=FE_OFN243_FE_OFN38_raw_prime_24 B[23]=Prime[23]
+ B[22]=Prime[22] B[21]=Prime[21] B[20]=FE_OFN86_raw_prime_20 B[19]=Prime[19]
+ B[18]=Prime[18] B[17]=Prime[17] B[16]=FE_OFN100_raw_prime_16
+ B[15]=FE_OFN104_raw_prime_15 B[14]=FE_OFN107_raw_prime_14
+ B[13]=FE_OFN215_FE_OFN49_raw_prime_13 B[12]=FE_OFN113_raw_prime_12
+ B[11]=FE_OFN117_raw_prime_11 B[10]=FE_OFN206_FE_OFN52_raw_prime_10
+ B[9]=FE_OFN201_FE_OFN53_raw_prime_9 B[8]=FE_OFN138_raw_prime_8
+ B[7]=FE_OFN180_FE_OFN95_raw_prime_7 B[6]=FE_OFN192_FE_OFN56_raw_prime_6
+ B[5]=FE_OFN179_FE_OFN101_raw_prime_5 B[4]=Prime[4] B[3]=Prime[3]
+ B[2]=FE_OFN182_FE_OFN93_raw_prime_2 B[1]=FE_OFN133_n312
+ B[0]=FE_OFN178_FE_OFN325_n310 TC=n21 GE_LT=n18 GE_GT_EQ=n18 GE_LT_GT_LE=N257
+ FE_OFN188_FE_OFN85_raw_prime_4=FE_OFN187_FE_OFN85_raw_prime_4
+ FE_OFN231_FE_OFN42_raw_prime_20=FE_OFN230_FE_OFN42_raw_prime_20
Xsub_2776_S2 Domain_Transfer_1_DW01_sub_3 $PINS A[31]=A_i[31] A[30]=A_i[30]
+ A[29]=A_i[29] A[28]=A_i[28] A[27]=A_i[27] A[26]=A_i[26] A[25]=A_i[25]
+ A[24]=A_i[24] A[23]=p33 A[22]=A_i[22] A[21]=A_i[21] A[20]=A_i[20] A[19]=A_i[19]
+ A[18]=A_i[18] A[17]=A_i[17] A[16]=A_i[16] A[15]=A_i[15] A[14]=A_i[14]
+ A[13]=A_i[13] A[12]=A_i[12] A[11]=A_i[11] A[10]=A_i[10] A[9]=A_i[9] A[8]=A_i[8]
+ A[7]=A_i[7] A[6]=A_i[6] A[5]=A_i[5] A[4]=A_i[4] A[3]=A_i[3] A[2]=A_i[2]
+ A[1]=A_i[1] A[0]=A_i[0] B[31]=Prime[31] B[30]=Prime[30] B[29]=Prime[29]
+ B[28]=Prime[28] B[27]=Prime[27] B[26]=Prime[26] B[25]=Prime[25] B[24]=Prime[24]
+ B[23]=Prime[23] B[22]=Prime[22] B[21]=Prime[21] B[20]=Prime[20] B[19]=Prime[19]
+ B[18]=Prime[18] B[17]=Prime[17] B[16]=Prime[16] B[15]=FE_OFN322_n
+ B[14]=FE_OFN107_raw_prime_14 B[13]=FE_OFN110_raw_prime_13 B[12]=Prime[12]
+ B[11]=FE_OFN117_raw_prime_11 B[10]=Prime[10] B[9]=Prime[9]
+ B[8]=FE_OFN136_raw_prime_8 B[7]=FE_OFN125_raw_prime_7
+ B[6]=FE_OFN191_FE_OFN56_raw_prime_6 B[5]=Prime[5] B[4]=FE_OFN130_raw_prime_4
+ B[3]=FE_OFN149_raw_prime_3 B[2]=FE_OFN162_n B[1]=FE_OFN132_n312 B[0]=Prime[0]
+ CI=n21 DIFF[31]=N223 DIFF[30]=N222 DIFF[29]=N221 DIFF[28]=N220 DIFF[27]=N219
+ DIFF[26]=N218 DIFF[25]=N217 DIFF[24]=N216 DIFF[23]=N215 DIFF[22]=N214
+ DIFF[21]=N213 DIFF[20]=N212 DIFF[19]=N211 DIFF[18]=N210 DIFF[17]=N209
+ DIFF[16]=N208 DIFF[15]=N207 DIFF[14]=N206 DIFF[13]=N205 DIFF[12]=N204
+ DIFF[11]=N203 DIFF[10]=N202 DIFF[9]=N201 DIFF[8]=N200 DIFF[7]=N199 DIFF[6]=N198
+ DIFF[5]=N197 DIFF[4]=N196 DIFF[3]=N195 DIFF[2]=N194 DIFF[1]=N193 DIFF[0]=N192
Xgte_2776 Domain_Transfer_1_DW_cmp_3 $PINS A[31]=A_i[31] A[30]=A_i[30]
+ A[29]=A_i[29] A[28]=A_i[28] A[27]=A_i[27] A[26]=A_i[26] A[25]=A_i[25]
+ A[24]=A_i[24] A[23]=A_i[23] A[22]=A_i[22] A[21]=A_i[21] A[20]=A_i[20]
+ A[19]=A_i[19] A[18]=A_i[18] A[17]=A_i[17] A[16]=A_i[16] A[15]=A_i[15]
+ A[14]=A_i[14] A[13]=A_i[13] A[12]=A_i[12] A[11]=A_i[11] A[10]=A_i[10]
+ A[9]=A_i[9] A[8]=A_i[8] A[7]=A_i[7] A[6]=A_i[6] A[5]=A_i[5] A[4]=A_i[4]
+ A[3]=A_i[3] A[2]=A_i[2] A[1]=A_i[1] A[0]=A_i[0] B[31]=Prime[31] B[30]=Prime[30]
+ B[29]=Prime[29] B[28]=Prime[28] B[27]=Prime[27] B[26]=Prime[26] B[25]=Prime[25]
+ B[24]=Prime[24] B[23]=Prime[23] B[22]=Prime[22] B[21]=Prime[21] B[20]=Prime[20]
+ B[19]=Prime[19] B[18]=Prime[18] B[17]=Prime[17] B[16]=Prime[16]
+ B[15]=FE_OFN322_n B[14]=FE_OFN107_raw_prime_14 B[13]=FE_OFN110_raw_prime_13
+ B[12]=Prime[12] B[11]=FE_OFN117_raw_prime_11 B[10]=Prime[10] B[9]=Prime[9]
+ B[8]=FE_OFN157_raw_prime_8 B[7]=FE_OFN125_raw_prime_7
+ B[6]=FE_OFN191_FE_OFN56_raw_prime_6 B[5]=Prime[5] B[4]=FE_OFN130_raw_prime_4
+ B[3]=FE_OFN149_raw_prime_3 B[2]=FE_OFN147_raw_prime_2 B[1]=FE_OFN132_n312
+ B[0]=Prime[0] TC=n21 GE_LT=n18 GE_GT_EQ=n18 GE_LT_GT_LE=N190
Xsub_2774_S2 Domain_Transfer_1_DW01_sub_4 $PINS A[31]=Py_i[31] A[30]=Py_i[30]
+ A[29]=Py_i[29] A[28]=Py_i[28] A[27]=Py_i[27] A[26]=Py_i[26] A[25]=Py_i[25]
+ A[24]=Py_i[24] A[23]=Py_i[23] A[22]=Py_i[22] A[21]=Py_i[21] A[20]=Py_i[20]
+ A[19]=Py_i[19] A[18]=Py_i[18] A[17]=Py_i[17] A[16]=Py_i[16] A[15]=Py_i[15]
+ A[14]=Py_i[14] A[13]=Py_i[13] A[12]=Py_i[12] A[11]=Py_i[11] A[10]=Py_i[10]
+ A[9]=Py_i[9] A[8]=Py_i[8] A[7]=Py_i[7] A[6]=Py_i[6] A[5]=Py_i[5] A[4]=p34
+ A[3]=Py_i[3] A[2]=Py_i[2] A[1]=Py_i[1] A[0]=Py_i[0]
+ B[31]=FE_OFN269_FE_OFN31_raw_prime_31 B[30]=FE_OFN50_raw_prime_30
+ B[29]=FE_OFN54_raw_prime_29 B[28]=FE_OFN58_raw_prime_28
+ B[27]=FE_OFN60_raw_prime_27 B[26]=FE_OFN64_raw_prime_26
+ B[25]=FE_OFN68_raw_prime_25 B[24]=FE_OFN72_raw_prime_24
+ B[23]=FE_OFN74_raw_prime_23 B[22]=FE_OFN78_raw_prime_22
+ B[21]=FE_OFN82_raw_prime_21 B[20]=FE_OFN417_FE_OFN42_raw_prime_20
+ B[19]=FE_OFN88_raw_prime_19 B[18]=FE_OFN92_raw_prime_18
+ B[17]=FE_OFN96_raw_prime_17 B[16]=FE_OFN100_raw_prime_16
+ B[15]=FE_OFN314_raw_prime_15 B[14]=Prime[14] B[13]=Prime[13]
+ B[12]=FE_OFN212_FE_OFN50_raw_prime_12 B[11]=Prime[11]
+ B[10]=FE_OFN204_FE_OFN52_raw_prime_10 B[9]=FE_OFN123_raw_prime_9
+ B[8]=FE_OFN139_raw_prime_8 B[7]=Prime[7] B[6]=FE_OFN127_raw_prime_6
+ B[5]=FE_OFN154_raw_prime_5 B[4]=Prime[4] B[3]=Prime[3]
+ B[2]=FE_OFN348_raw_prime_2 B[1]=Prime[1] B[0]=FE_OFN168_n310 CI=n21
+ DIFF[31]=N157 DIFF[30]=N156 DIFF[29]=N155 DIFF[28]=N154 DIFF[27]=N153
+ DIFF[26]=N152 DIFF[25]=N151 DIFF[24]=N150 DIFF[23]=N149 DIFF[22]=N148
+ DIFF[21]=N147 DIFF[20]=N146 DIFF[19]=N145 DIFF[18]=N144 DIFF[17]=N143
+ DIFF[16]=N142 DIFF[15]=N141 DIFF[14]=N140 DIFF[13]=N139 DIFF[12]=N138
+ DIFF[11]=N137 DIFF[10]=N136 DIFF[9]=N135 DIFF[8]=N134 DIFF[7]=N133 DIFF[6]=N132
+ DIFF[5]=N131 DIFF[4]=N130 DIFF[3]=N129 DIFF[2]=N128 DIFF[1]=N127 DIFF[0]=N126
+ FE_OFN97_raw_prime_9=FE_OFN150_raw_prime_9 FE_OCPN352_n310=FE_OCPN663_n310
Xgte_2774 Domain_Transfer_1_DW_cmp_4 $PINS A[31]=Py_i[31] A[30]=Py_i[30]
+ A[29]=Py_i[29] A[28]=Py_i[28] A[27]=Py_i[27] A[26]=Py_i[26] A[25]=Py_i[25]
+ A[24]=Py_i[24] A[23]=Py_i[23] A[22]=Py_i[22] A[21]=Py_i[21] A[20]=Py_i[20]
+ A[19]=Py_i[19] A[18]=Py_i[18] A[17]=Py_i[17] A[16]=Py_i[16] A[15]=Py_i[15]
+ A[14]=Py_i[14] A[13]=Py_i[13] A[12]=Py_i[12] A[11]=Py_i[11] A[10]=Py_i[10]
+ A[9]=Py_i[9] A[8]=Py_i[8] A[7]=Py_i[7] A[6]=Py_i[6] A[5]=Py_i[5] A[4]=Py_i[4]
+ A[3]=Py_i[3] A[2]=Py_i[2] A[1]=Py_i[1] A[0]=Py_i[0] B[31]=FE_OFN48_raw_prime_31
+ B[30]=FE_OFN50_raw_prime_30 B[29]=FE_OFN54_raw_prime_29
+ B[28]=FE_OFN58_raw_prime_28 B[27]=FE_OFN60_raw_prime_27
+ B[26]=FE_OFN64_raw_prime_26 B[25]=FE_OFN68_raw_prime_25
+ B[24]=FE_OFN72_raw_prime_24 B[23]=FE_OFN74_raw_prime_23
+ B[22]=FE_OFN78_raw_prime_22 B[21]=FE_OFN82_raw_prime_21
+ B[20]=FE_OFN417_FE_OFN42_raw_prime_20 B[19]=FE_OFN88_raw_prime_19
+ B[18]=FE_OFN92_raw_prime_18 B[17]=FE_OFN96_raw_prime_17
+ B[16]=FE_OFN100_raw_prime_16 B[15]=Prime[15] B[14]=Prime[14] B[13]=Prime[13]
+ B[12]=FE_OFN212_FE_OFN50_raw_prime_12 B[11]=Prime[11] B[10]=Prime[10]
+ B[9]=FE_OFN123_raw_prime_9 B[8]=FE_OFN139_raw_prime_8 B[7]=Prime[7]
+ B[6]=FE_OFN127_raw_prime_6 B[5]=FE_OFN154_raw_prime_5 B[4]=Prime[4]
+ B[3]=Prime[3] B[2]=FE_OFN348_raw_prime_2 B[1]=Prime[1] B[0]=FE_OCPN663_n310
+ TC=n21 GE_LT=n18 GE_GT_EQ=n18 GE_LT_GT_LE=N124 FE_OFN134_n312=FE_OFN133_n312
+ FE_OFN315_raw_prime_15=FE_OFN314_raw_prime_15 p1=p34
Xsub_2772_S2 Domain_Transfer_1_DW01_sub_5 $PINS A[31]=Px_i[31] A[30]=Px_i[30]
+ A[29]=Px_i[29] A[28]=Px_i[28] A[27]=Px_i[27] A[26]=Px_i[26] A[25]=Px_i[25]
+ A[24]=Px_i[24] A[23]=Px_i[23] A[22]=Px_i[22] A[21]=Px_i[21] A[20]=Px_i[20]
+ A[19]=Px_i[19] A[18]=Px_i[18] A[17]=Px_i[17] A[16]=Px_i[16] A[15]=Px_i[15]
+ A[14]=Px_i[14] A[13]=Px_i[13] A[12]=Px_i[12] A[11]=Px_i[11] A[10]=Px_i[10]
+ A[9]=Px_i[9] A[8]=Px_i[8] A[7]=Px_i[7] A[6]=Px_i[6] A[5]=Px_i[5] A[4]=Px_i[4]
+ A[3]=Px_i[3] A[2]=Px_i[2] A[1]=Px_i[1] A[0]=Px_i[0] B[31]=FE_OFN48_raw_prime_31
+ B[30]=Prime[30] B[29]=Prime[29] B[28]=FE_OFN260_FE_OFN34_raw_prime_28
+ B[27]=Prime[27] B[26]=Prime[26] B[25]=Prime[25]
+ B[24]=FE_OFN243_FE_OFN38_raw_prime_24 B[23]=Prime[23] B[22]=Prime[22]
+ B[21]=Prime[21] B[20]=FE_OFN86_raw_prime_20 B[19]=Prime[19] B[18]=Prime[18]
+ B[17]=Prime[17] B[16]=FE_OFN100_raw_prime_16 B[15]=FE_OFN322_n
+ B[14]=FE_OFN107_raw_prime_14 B[13]=FE_OFN215_FE_OFN49_raw_prime_13
+ B[12]=FE_OFN212_FE_OFN50_raw_prime_12 B[11]=FE_OFN117_raw_prime_11
+ B[10]=FE_OFN206_FE_OFN52_raw_prime_10 B[9]=FE_OFN201_FE_OFN53_raw_prime_9
+ B[8]=Prime[8] B[7]=Prime[7] B[6]=FE_OFN127_raw_prime_6
+ B[5]=FE_OFN179_FE_OFN101_raw_prime_5 B[4]=Prime[4] B[3]=Prime[3]
+ B[2]=FE_OFN182_FE_OFN93_raw_prime_2 B[1]=Prime[1] B[0]=FE_OCPN663_n310 CI=n21
+ DIFF[31]=N91 DIFF[30]=N90 DIFF[29]=N89 DIFF[28]=N88 DIFF[27]=N87 DIFF[26]=N86
+ DIFF[25]=N85 DIFF[24]=N84 DIFF[23]=N83 DIFF[22]=N82 DIFF[21]=N81 DIFF[20]=N80
+ DIFF[19]=N79 DIFF[18]=N78 DIFF[17]=N77 DIFF[16]=N76 DIFF[15]=N75 DIFF[14]=N74
+ DIFF[13]=N73 DIFF[12]=N72 DIFF[11]=N71 DIFF[10]=N70 DIFF[9]=N69 DIFF[8]=N68
+ DIFF[7]=N67 DIFF[6]=N66 DIFF[5]=N65 DIFF[4]=N64 DIFF[3]=N63 DIFF[2]=N62
+ DIFF[1]=N61 DIFF[0]=N60 p1=FE_OCPN662_n310
Xgte_2772 Domain_Transfer_1_DW_cmp_5 $PINS A[31]=Px_i[31] A[30]=Px_i[30]
+ A[29]=Px_i[29] A[28]=Px_i[28] A[27]=Px_i[27] A[26]=Px_i[26] A[25]=Px_i[25]
+ A[24]=Px_i[24] A[23]=Px_i[23] A[22]=Px_i[22] A[21]=Px_i[21] A[20]=Px_i[20]
+ A[19]=Px_i[19] A[18]=Px_i[18] A[17]=Px_i[17] A[16]=Px_i[16] A[15]=Px_i[15]
+ A[14]=Px_i[14] A[13]=Px_i[13] A[12]=Px_i[12] A[11]=Px_i[11] A[10]=Px_i[10]
+ A[9]=Px_i[9] A[8]=Px_i[8] A[7]=Px_i[7] A[6]=Px_i[6] A[5]=Px_i[5] A[4]=Px_i[4]
+ A[3]=Px_i[3] A[2]=Px_i[2] A[1]=Px_i[1] A[0]=Px_i[0] B[31]=FE_OFN48_raw_prime_31
+ B[30]=Prime[30] B[29]=Prime[29] B[28]=FE_OFN260_FE_OFN34_raw_prime_28
+ B[27]=Prime[27] B[26]=Prime[26] B[25]=Prime[25] B[24]=FE_OFN72_raw_prime_24
+ B[23]=Prime[23] B[22]=Prime[22] B[21]=Prime[21]
+ B[20]=FE_OFN417_FE_OFN42_raw_prime_20 B[19]=Prime[19] B[18]=Prime[18]
+ B[17]=Prime[17] B[16]=FE_OFN100_raw_prime_16 B[15]=FE_OFN322_n
+ B[14]=FE_OFN107_raw_prime_14 B[13]=FE_OFN110_raw_prime_13
+ B[12]=FE_OFN113_raw_prime_12 B[11]=FE_OFN117_raw_prime_11 B[10]=Prime[10]
+ B[9]=Prime[9] B[8]=Prime[8] B[7]=Prime[7] B[6]=FE_OFN127_raw_prime_6
+ B[5]=FE_OFN154_raw_prime_5 B[4]=Prime[4] B[3]=Prime[3]
+ B[2]=FE_OFN182_FE_OFN93_raw_prime_2 B[1]=FE_OFN133_n312 B[0]=FE_OCPN663_n310
+ TC=n21 GE_LT=n18 GE_GT_EQ=n18 GE_LT_GT_LE=N58
Xadd_2735 Domain_Transfer_1_DW01_add_0 $PINS A[32]=n21 A[31]=A_out[31]
+ A[30]=A_out[30] A[29]=A_out[29] A[28]=A_out[28] A[27]=A_out[27] A[26]=A_out[26]
+ A[25]=A_out[25] A[24]=A_out[24] A[23]=A_out[23] A[22]=A_out[22] A[21]=A_out[21]
+ A[20]=A_out[20] A[19]=A_out[19] A[18]=A_out[18] A[17]=A_out[17] A[16]=A_out[16]
+ A[15]=A_out[15] A[14]=A_out[14] A[13]=A_out[13] A[12]=A_out[12] A[11]=A_out[11]
+ A[10]=A_out[10] A[9]=A_out[9] A[8]=A_out[8] A[7]=A_out[7] A[6]=A_out[6]
+ A[5]=A_out[5] A[4]=A_out[4] A[3]=A_out[3] A[2]=A_out[2] A[1]=A_out[1]
+ A[0]=A_out[0] B[32]=n21 B[31]=Prime[31] B[30]=Prime[30] B[29]=Prime[29]
+ B[28]=Prime[28] B[27]=Prime[27] B[26]=Prime[26] B[25]=Prime[25] B[24]=Prime[24]
+ B[23]=Prime[23] B[22]=Prime[22] B[21]=Prime[21] B[20]=Prime[20] B[19]=Prime[19]
+ B[18]=Prime[18] B[17]=Prime[17] B[16]=Prime[16] B[15]=FE_OFN322_n
+ B[14]=FE_OFN107_raw_prime_14 B[13]=FE_OFN110_raw_prime_13 B[12]=Prime[12]
+ B[11]=FE_OFN117_raw_prime_11 B[10]=Prime[10] B[9]=Prime[9]
+ B[8]=FE_OFN143_raw_prime_8 B[7]=FE_OFN125_raw_prime_7
+ B[6]=FE_OFN191_FE_OFN56_raw_prime_6 B[5]=Prime[5] B[4]=FE_OFN130_raw_prime_4
+ B[3]=FE_OFN149_raw_prime_3 B[2]=FE_OFN147_raw_prime_2 B[1]=FE_OFN132_n312
+ B[0]=Prime[0] CI=n21 SUM[32]=A_add[32] SUM[31]=A_add[31] SUM[30]=A_add[30]
+ SUM[29]=A_add[29] SUM[28]=A_add[28] SUM[27]=A_add[27] SUM[26]=A_add[26]
+ SUM[25]=A_add[25] SUM[24]=A_add[24] SUM[23]=A_add[23] SUM[22]=A_add[22]
+ SUM[21]=A_add[21] SUM[20]=A_add[20] SUM[19]=A_add[19] SUM[18]=A_add[18]
+ SUM[17]=A_add[17] SUM[16]=A_add[16] SUM[15]=A_add[15] SUM[14]=A_add[14]
+ SUM[13]=A_add[13] SUM[12]=A_add[12] SUM[11]=A_add[11] SUM[10]=A_add[10]
+ SUM[9]=A_add[9] SUM[8]=A_add[8] SUM[7]=A_add[7] SUM[6]=A_add[6] SUM[5]=A_add[5]
+ SUM[4]=A_add[4] SUM[3]=A_add[3] SUM[2]=A_add[2] SUM[1]=A_add[1]
+ SUM[0]=SYNOPSYS_UNCONNECTED__0
Xadd_2734 Domain_Transfer_1_DW01_add_1 $PINS A[32]=n21 A[31]=Py_out[31]
+ A[30]=Py_out[30] A[29]=Py_out[29] A[28]=Py_out[28] A[27]=Py_out[27]
+ A[26]=Py_out[26] A[25]=Py_out[25] A[24]=Py_out[24] A[23]=Py_out[23]
+ A[22]=Py_out[22] A[21]=Py_out[21] A[20]=Py_out[20] A[19]=Py_out[19]
+ A[18]=Py_out[18] A[17]=Py_out[17] A[16]=Py_out[16] A[15]=Py_out[15]
+ A[14]=Py_out[14] A[13]=Py_out[13] A[12]=Py_out[12] A[11]=Py_out[11]
+ A[10]=Py_out[10] A[9]=Py_out[9] A[8]=Py_out[8] A[7]=Py_out[7] A[6]=Py_out[6]
+ A[5]=Py_out[5] A[4]=Py_out[4] A[3]=Py_out[3] A[2]=Py_out[2] A[1]=Py_out[1]
+ A[0]=Py_out[0] B[32]=n21 B[31]=FE_OFN269_FE_OFN31_raw_prime_31
+ B[30]=FE_OFN50_raw_prime_30 B[29]=FE_OFN54_raw_prime_29
+ B[28]=FE_OFN58_raw_prime_28 B[27]=FE_OFN60_raw_prime_27
+ B[26]=FE_OFN64_raw_prime_26 B[25]=FE_OFN68_raw_prime_25
+ B[24]=FE_OFN72_raw_prime_24 B[23]=FE_OFN74_raw_prime_23
+ B[22]=FE_OFN78_raw_prime_22 B[21]=FE_OFN235_FE_OFN41_raw_prime_21
+ B[20]=FE_OFN417_FE_OFN42_raw_prime_20 B[19]=FE_OFN88_raw_prime_19
+ B[18]=FE_OFN92_raw_prime_18 B[17]=FE_OFN96_raw_prime_17
+ B[16]=FE_OFN100_raw_prime_16 B[15]=FE_OFN314_raw_prime_15
+ B[14]=FE_OFN316_raw_prime_14 B[13]=Prime[13]
+ B[12]=FE_OFN212_FE_OFN50_raw_prime_12 B[11]=Prime[11]
+ B[10]=FE_OFN204_FE_OFN52_raw_prime_10 B[9]=FE_OFN151_raw_prime_9
+ B[8]=FE_OFN158_raw_prime_8 B[7]=Prime[7] B[6]=FE_OFN127_raw_prime_6
+ B[5]=FE_OFN154_raw_prime_5 B[4]=Prime[4] B[3]=FE_RN_2
+ B[2]=FE_OFN348_raw_prime_2 B[1]=Prime[1] B[0]=FE_OFN168_n310 CI=n21
+ SUM[32]=Py_add[32] SUM[31]=Py_add[31] SUM[30]=Py_add[30] SUM[29]=Py_add[29]
+ SUM[28]=Py_add[28] SUM[27]=Py_add[27] SUM[26]=Py_add[26] SUM[25]=Py_add[25]
+ SUM[24]=Py_add[24] SUM[23]=Py_add[23] SUM[22]=Py_add[22] SUM[21]=Py_add[21]
+ SUM[20]=Py_add[20] SUM[19]=Py_add[19] SUM[18]=Py_add[18] SUM[17]=Py_add[17]
+ SUM[16]=Py_add[16] SUM[15]=Py_add[15] SUM[14]=Py_add[14] SUM[13]=Py_add[13]
+ SUM[12]=Py_add[12] SUM[11]=Py_add[11] SUM[10]=Py_add[10] SUM[9]=Py_add[9]
+ SUM[8]=Py_add[8] SUM[7]=Py_add[7] SUM[6]=Py_add[6] SUM[5]=Py_add[5]
+ SUM[4]=Py_add[4] SUM[3]=Py_add[3] SUM[2]=Py_add[2] SUM[1]=Py_add[1]
+ SUM[0]=SYNOPSYS_UNCONNECTED__1 FE_OFN145_raw_prime_8=FE_OFN91_raw_prime_8
+ FE_OFN226_FE_OFN43_raw_prime_19=FE_OFN225_FE_OFN43_raw_prime_19
+ FE_OFN258_FE_OFN35_raw_prime_27=FE_OFN257_FE_OFN35_raw_prime_27
Xadd_2733 Domain_Transfer_1_DW01_add_2 $PINS A[32]=n21 A[31]=Px_out[31]
+ A[30]=Px_out[30] A[29]=Px_out[29] A[28]=Px_out[28] A[27]=Px_out[27]
+ A[26]=Px_out[26] A[25]=Px_out[25] A[24]=Px_out[24] A[23]=Px_out[23]
+ A[22]=Px_out[22] A[21]=Px_out[21] A[20]=Px_out[20] A[19]=Px_out[19]
+ A[18]=Px_out[18] A[17]=Px_out[17] A[16]=Px_out[16] A[15]=Px_out[15]
+ A[14]=Px_out[14] A[13]=Px_out[13] A[12]=Px_out[12] A[11]=Px_out[11]
+ A[10]=Px_out[10] A[9]=Px_out[9] A[8]=Px_out[8] A[7]=Px_out[7] A[6]=Px_out[6]
+ A[5]=Px_out[5] A[4]=Px_out[4] A[3]=Px_out[3] A[2]=Px_out[2] A[1]=Px_out[1]
+ A[0]=Px_out[0] B[32]=n21 B[31]=FE_OFN48_raw_prime_31 B[30]=Prime[30]
+ B[29]=Prime[29] B[28]=FE_OFN260_FE_OFN34_raw_prime_28 B[27]=Prime[27]
+ B[26]=Prime[26] B[25]=Prime[25] B[24]=FE_OFN243_FE_OFN38_raw_prime_24
+ B[23]=Prime[23] B[22]=Prime[22] B[21]=Prime[21] B[20]=FE_OFN86_raw_prime_20
+ B[19]=Prime[19] B[18]=Prime[18] B[17]=Prime[17] B[16]=FE_OFN100_raw_prime_16
+ B[15]=FE_OFN104_raw_prime_15 B[14]=FE_OFN107_raw_prime_14
+ B[13]=FE_OFN215_FE_OFN49_raw_prime_13 B[12]=FE_OFN113_raw_prime_12
+ B[11]=FE_OFN117_raw_prime_11 B[10]=FE_OFN206_FE_OFN52_raw_prime_10
+ B[9]=FE_OFN201_FE_OFN53_raw_prime_9 B[8]=Prime[8] B[7]=Prime[7]
+ B[6]=FE_OFN192_FE_OFN56_raw_prime_6 B[5]=FE_OFN179_FE_OFN101_raw_prime_5
+ B[4]=Prime[4] B[3]=Prime[3] B[2]=FE_OFN182_FE_OFN93_raw_prime_2 B[1]=Prime[1]
+ B[0]=FE_OFN168_n310 CI=n21 SUM[32]=Px_add[32] SUM[31]=Px_add[31]
+ SUM[30]=Px_add[30] SUM[29]=Px_add[29] SUM[28]=Px_add[28] SUM[27]=Px_add[27]
+ SUM[26]=Px_add[26] SUM[25]=Px_add[25] SUM[24]=Px_add[24] SUM[23]=Px_add[23]
+ SUM[22]=Px_add[22] SUM[21]=Px_add[21] SUM[20]=Px_add[20] SUM[19]=Px_add[19]
+ SUM[18]=Px_add[18] SUM[17]=Px_add[17] SUM[16]=Px_add[16] SUM[15]=Px_add[15]
+ SUM[14]=Px_add[14] SUM[13]=Px_add[13] SUM[12]=Px_add[12] SUM[11]=Px_add[11]
+ SUM[10]=Px_add[10] SUM[9]=Px_add[9] SUM[8]=Px_add[8] SUM[7]=Px_add[7]
+ SUM[6]=Px_add[6] SUM[5]=Px_add[5] SUM[4]=Px_add[4] SUM[3]=Px_add[3]
+ SUM[2]=Px_add[2] SUM[1]=Px_add[1] SUM[0]=SYNOPSYS_UNCONNECTED__2
+ FE_OFN159_i1_w_5=Px_out[5]
+ FE_OFN181_FE_OFN95_raw_prime_7=FE_OFN180_FE_OFN95_raw_prime_7
Xr341/U1_1_1 HA1 $PINS S=N41 C=r341/carry[2] A=counter[1] B=counter[0]
Xr341/U1_1_2 HA1 $PINS S=N42 C=r341/carry[3] A=counter[2] B=r341/carry[2]
Xr341/U1_1_3 HA1 $PINS S=N43 C=r341/carry[4] A=FE_PHN961_counter_3
+ B=r341/carry[3]
Xcounter_reg[4] QDFFRBN $PINS Q=FE_PHN744_counter_4 D=n471 CK=clk_clone2
+ RB=FE_OFN335_n
Xcounter_reg[1] QDFFRBN $PINS Q=counter[1] D=n469 CK=clk_clone2 RB=FE_OFN338_n
Xcounter_reg[2] QDFFRBN $PINS Q=counter[2] D=n468 CK=clk_clone2 RB=FE_OFN335_n
Xcounter_reg[0] QDFFRBN $PINS Q=counter[0] D=n470 CK=clk_clone2 RB=FE_OFN338_n
Xcounter_reg[3] QDFFRBN $PINS Q=counter[3] D=n467 CK=clk_clone2 RB=FE_OFN335_n
XA_reg[31] QDFFRBN $PINS Q=FE_PSRN_6 D=n371 CK=clk_clone1
+ RB=FE_OFN305_FE_OFN4_FE_DBTN1_i_i_rst
XPx_reg[31] QDFFRBN $PINS Q=Px_out[31] D=n435 CK=clk_clone1
+ RB=FE_OFN23_FE_DBTN1_i_i_rst
XPy_reg[31] QDFFRBN $PINS Q=Py_out[31] D=n403 CK=clk_clone5
+ RB=FE_OFN291_FE_OFN8_FE_DBTN1_i_i_rst
XA_reg[27] QDFFRBN $PINS Q=A_out[27] D=n375 CK=clk_clone3
+ RB=FE_OFN305_FE_OFN4_FE_DBTN1_i_i_rst
XA_reg[29] QDFFRBN $PINS Q=A_out[29] D=n373 CK=clk_clone3
+ RB=FE_OFN305_FE_OFN4_FE_DBTN1_i_i_rst
XA_reg[30] QDFFRBN $PINS Q=A_out[30] D=n372 CK=clk_clone1
+ RB=FE_OFN305_FE_OFN4_FE_DBTN1_i_i_rst
XA_reg[28] QDFFRBN $PINS Q=A_out[28] D=n374 CK=clk_clone3
+ RB=FE_OFN305_FE_OFN4_FE_DBTN1_i_i_rst
XPx_reg[27] QDFFRBN $PINS Q=Px_out[27] D=n439 CK=clk RB=FE_OFN335_n
XPy_reg[27] QDFFRBN $PINS Q=Py_out[27] D=n407 CK=clk_clone5
+ RB=FE_OFN20_FE_DBTN1_i_i_rst
XPy_reg[29] QDFFRBN $PINS Q=Py_out[29] D=n405 CK=clk_clone5
+ RB=FE_OFN291_FE_OFN8_FE_DBTN1_i_i_rst
XPx_reg[28] QDFFRBN $PINS Q=Px_out[28] D=n438 CK=clk RB=FE_OFN335_n
XPy_reg[28] QDFFRBN $PINS Q=Py_out[28] D=n406 CK=clk_clone5
+ RB=FE_OFN291_FE_OFN8_FE_DBTN1_i_i_rst
Xstate_reg[1] QDFFRBN $PINS Q=state[1] D=state_nxt[1] CK=clk_clone1
+ RB=FE_OFN337_n
Xstate_reg[0] QDFFRBN $PINS Q=state[0] D=state_nxt[0] CK=clk_clone2
+ RB=FE_OFN338_n
XA_reg[23] QDFFRBN $PINS Q=A_out[23] D=n379 CK=clk_clone3 RB=reset
XA_reg[25] QDFFRBN $PINS Q=A_out[25] D=n377 CK=clk_clone3
+ RB=FE_OFN305_FE_OFN4_FE_DBTN1_i_i_rst
XA_reg[24] QDFFRBN $PINS Q=A_out[24] D=n378 CK=clk_clone3
+ RB=FE_OFN305_FE_OFN4_FE_DBTN1_i_i_rst
XA_reg[26] QDFFRBN $PINS Q=A_out[26] D=n376 CK=clk_clone3
+ RB=FE_OFN305_FE_OFN4_FE_DBTN1_i_i_rst
XPx_reg[23] QDFFRBN $PINS Q=Px_out[23] D=n443 CK=clk_clone1 RB=FE_OFN337_n
XPx_reg[25] QDFFRBN $PINS Q=Px_out[25] D=n441 CK=clk_clone1 RB=FE_OFN335_n
XPy_reg[23] QDFFRBN $PINS Q=Py_out[23] D=n411 CK=clk_clone6
+ RB=FE_OFN279_FE_OFN13_FE_DBTN1_i_i_rst
XPy_reg[25] QDFFRBN $PINS Q=Py_out[25] D=n409 CK=clk_clone6
+ RB=FE_OFN20_FE_DBTN1_i_i_rst
XPx_reg[24] QDFFRBN $PINS Q=Px_out[24] D=n442 CK=clk_clone1 RB=FE_OFN335_n
XPx_reg[26] QDFFRBN $PINS Q=Px_out[26] D=n440 CK=clk_clone1 RB=FE_OFN335_n
XPy_reg[24] QDFFRBN $PINS Q=Py_out[24] D=n410 CK=clk_clone6
+ RB=FE_OFN279_FE_OFN13_FE_DBTN1_i_i_rst
XPy_reg[26] QDFFRBN $PINS Q=Py_out[26] D=n408 CK=clk_clone5
+ RB=FE_OFN20_FE_DBTN1_i_i_rst
XA_reg[21] QDFFRBN $PINS Q=A_out[21] D=n381 CK=clk_clone3 RB=reset
XA_reg[22] QDFFRBN $PINS Q=A_out[22] D=n380 CK=clk_clone3 RB=reset
XPx_reg[21] QDFFRBN $PINS Q=Px_out[21] D=n445 CK=clk_clone1
+ RB=FE_OFN34_FE_DBTN1_i_i_rst
XPy_reg[21] QDFFRBN $PINS Q=Py_out[21] D=n413 CK=clk_clone5 RB=FE_OFN341_n
XPx_reg[22] QDFFRBN $PINS Q=Px_out[22] D=n444 CK=clk_clone1 RB=FE_OFN337_n
XPy_reg[22] QDFFRBN $PINS Q=Py_out[22] D=n412 CK=clk_clone5 RB=FE_OFN341_n
XPx_reg[20] QDFFRBN $PINS Q=Px_out[20] D=n446 CK=clk_clone1
+ RB=FE_OFN34_FE_DBTN1_i_i_rst
XPy_reg[20] QDFFRBN $PINS Q=Py_out[20] D=n414 CK=clk_clone4 RB=FE_OFN341_n
XA_reg[17] QDFFRBN $PINS Q=A_out[17] D=n385 CK=clk_clone3 RB=reset
XA_reg[19] QDFFRBN $PINS Q=A_out[19] D=n383 CK=clk_clone3 RB=reset
XA_reg[18] QDFFRBN $PINS Q=A_out[18] D=n384 CK=clk_clone3 RB=reset
XA_reg[16] QDFFRBN $PINS Q=A_out[16] D=n386 CK=clk_clone3 RB=reset
XPx_reg[17] QDFFRBN $PINS Q=Px_out[17] D=n449 CK=clk_clone1 RB=FE_OFN343_n
XPx_reg[19] QDFFRBN $PINS Q=Px_out[19] D=n447 CK=clk_clone1
+ RB=FE_OFN34_FE_DBTN1_i_i_rst
XPy_reg[17] QDFFRBN $PINS Q=Py_out[17] D=n417 CK=clk_clone4 RB=FE_OFN341_n
XPy_reg[19] QDFFRBN $PINS Q=Py_out[19] D=n415 CK=clk_clone4 RB=FE_OFN341_n
XPx_reg[18] QDFFRBN $PINS Q=Px_out[18] D=n448 CK=clk_clone1
+ RB=FE_OFN34_FE_DBTN1_i_i_rst
XPy_reg[18] QDFFRBN $PINS Q=Py_out[18] D=n416 CK=clk_clone4 RB=FE_OFN341_n
XPx_reg[16] QDFFRBN $PINS Q=Px_out[16] D=n450 CK=clk_clone1
+ RB=FE_OFN23_FE_DBTN1_i_i_rst
XPy_reg[16] QDFFRBN $PINS Q=Py_out[16] D=n418 CK=clk_clone4
+ RB=FE_OFN279_FE_OFN13_FE_DBTN1_i_i_rst
XA_reg[13] QDFFRBN $PINS Q=A_out[13] D=n389 CK=clk_clone3 RB=reset
XA_reg[15] QDFFRBN $PINS Q=A_out[15] D=n387 CK=clk_clone3 RB=reset
XA_reg[14] QDFFRBN $PINS Q=A_out[14] D=n388 CK=clk_clone3 RB=reset
XPx_reg[13] QDFFRBN $PINS Q=Px_out[13] D=n453 CK=clk_clone1 RB=FE_OFN343_n
XPx_reg[15] QDFFRBN $PINS Q=Px_out[15] D=n451 CK=clk_clone1 RB=FE_OFN343_n
XPy_reg[13] QDFFRBN $PINS Q=Py_out[13] D=n421 CK=clk_clone4
+ RB=FE_OFN279_FE_OFN13_FE_DBTN1_i_i_rst
XPx_reg[14] QDFFRBN $PINS Q=Px_out[14] D=n452 CK=clk_clone1 RB=FE_OFN343_n
XPy_reg[14] QDFFRBN $PINS Q=Py_out[14] D=n420 CK=clk_clone4
+ RB=FE_OFN279_FE_OFN13_FE_DBTN1_i_i_rst
XA_reg[9] QDFFRBN $PINS Q=A_out[9] D=n393 CK=clk_clone3 RB=reset
XA_reg[11] QDFFRBN $PINS Q=A_out[11] D=n391 CK=clk_clone3 RB=reset
XA_reg[10] QDFFRBN $PINS Q=A_out[10] D=n392 CK=clk_clone3 RB=reset
XPx_reg[11] QDFFRBN $PINS Q=Px_out[11] D=n455 CK=clk_clone1
+ RB=FE_OFN23_FE_DBTN1_i_i_rst
XPy_reg[11] QDFFRBN $PINS Q=Py_out[11] D=n423 CK=clk_clone4
+ RB=FE_OFN28_FE_DBTN1_i_i_rst
XPx_reg[10] QDFFRBN $PINS Q=Px_out[10] D=n456 CK=clk_clone1
+ RB=FE_OFN23_FE_DBTN1_i_i_rst
XPy_reg[10] QDFFRBN $PINS Q=Py_out[10] D=n424 CK=clk_clone4
+ RB=FE_OFN279_FE_OFN13_FE_DBTN1_i_i_rst
XPx_reg[12] QDFFRBN $PINS Q=Px_out[12] D=n454 CK=clk_clone1
+ RB=FE_OFN23_FE_DBTN1_i_i_rst
XPy_reg[12] QDFFRBN $PINS Q=Py_out[12] D=n422 CK=clk_clone4
+ RB=FE_OFN28_FE_DBTN1_i_i_rst
XA_reg[7] QDFFRBN $PINS Q=A_out[7] D=n395 CK=clk_clone2
+ RB=FE_OFN41_FE_DBTN1_i_i_rst
XA_reg[6] QDFFRBN $PINS Q=A_out[6] D=n396 CK=clk_clone3 RB=reset
XA_reg[8] QDFFRBN $PINS Q=A_out[8] D=FE_PHN1453_n394 CK=clk_clone3 RB=reset
XPx_reg[7] QDFFRBN $PINS Q=Px_out[7] D=n459 CK=clk_clone1
+ RB=FE_OFN23_FE_DBTN1_i_i_rst
XPx_reg[9] QDFFRBN $PINS Q=Px_out[9] D=n457 CK=clk_clone1
+ RB=FE_OFN23_FE_DBTN1_i_i_rst
XPy_reg[7] QDFFRBN $PINS Q=Py_out[7] D=n427 CK=clk_clone6
+ RB=FE_OFN20_FE_DBTN1_i_i_rst
XPy_reg[9] QDFFRBN $PINS Q=Py_out[9] D=n425 CK=clk_clone4
+ RB=FE_OFN279_FE_OFN13_FE_DBTN1_i_i_rst
XPx_reg[6] QDFFRBN $PINS Q=FE_PHN1301_i1_w_6 D=n460 CK=clk_clone1
+ RB=FE_OFN23_FE_DBTN1_i_i_rst
XPx_reg[8] QDFFRBN $PINS Q=Px_out[8] D=n458 CK=clk_clone1
+ RB=FE_OFN23_FE_DBTN1_i_i_rst
XPy_reg[6] QDFFRBN $PINS Q=Py_out[6] D=n428 CK=clk_clone5
+ RB=FE_OFN37_FE_DBTN1_i_i_rst
XPy_reg[8] QDFFRBN $PINS Q=Py_out[8] D=n426 CK=clk_clone4
+ RB=FE_OFN279_FE_OFN13_FE_DBTN1_i_i_rst
XA_reg[3] QDFFRBN $PINS Q=A_out[3] D=n399 CK=clk_clone3 RB=reset
XA_reg[5] QDFFRBN $PINS Q=A_out[5] D=n397 CK=clk_clone3 RB=reset
XA_reg[4] QDFFRBN $PINS Q=A_out[4] D=n398 CK=clk_clone3
+ RB=FE_OFN305_FE_OFN4_FE_DBTN1_i_i_rst
XPx_reg[3] QDFFRBN $PINS Q=Px_out[3] D=n463 CK=clk_clone5
+ RB=FE_OFN291_FE_OFN8_FE_DBTN1_i_i_rst
XPx_reg[5] QDFFRBN $PINS Q=Px_out[5] D=n461 CK=clk_clone5
+ RB=FE_OFN291_FE_OFN8_FE_DBTN1_i_i_rst
XPy_reg[3] QDFFRBN $PINS Q=Py_out[3] D=n431 CK=clk_clone5
+ RB=FE_OFN37_FE_DBTN1_i_i_rst
XPy_reg[4] QDFFRBN $PINS Q=Py_out[4] D=n430 CK=clk_clone5
+ RB=FE_OFN37_FE_DBTN1_i_i_rst
XA_reg[12] QDFFRBN $PINS Q=A_out[12] D=n390 CK=clk_clone3 RB=reset
XA_reg[20] QDFFRBN $PINS Q=A_out[20] D=n382 CK=clk_clone3 RB=reset
XPx_reg[30] QDFFRBN $PINS Q=Px_out[30] D=n436 CK=clk
+ RB=FE_OFN23_FE_DBTN1_i_i_rst
XPx_reg[0] QDFFRBP $PINS Q=FE_PSRN_10 D=n466 CK=clk_clone1 RB=FE_OFN343_n
XPx_reg[1] QDFFRBN $PINS Q=FE_PHN1325_i1_w_1 D=n465 CK=clk_clone1
+ RB=FE_OFN345_n
XPx_reg[2] QDFFRBN $PINS Q=Px_out[2] D=n464 CK=clk_clone1 RB=FE_OFN345_n
XPy_reg[0] QDFFRBP $PINS Q=FE_PHN1320_i2_w_0 D=n434 CK=clk_clone5
+ RB=FE_OFN37_FE_DBTN1_i_i_rst
XPy_reg[1] QDFFRBN $PINS Q=Py_out[1] D=n433 CK=clk_clone5
+ RB=FE_OFN291_FE_OFN8_FE_DBTN1_i_i_rst
XPy_reg[2] QDFFRBN $PINS Q=Py_out[2] D=n432 CK=clk_clone5
+ RB=FE_OFN37_FE_DBTN1_i_i_rst
XA_reg[0] QDFFRBN $PINS Q=A_out[0] D=n402 CK=clk_clone1
+ RB=FE_OFN34_FE_DBTN1_i_i_rst
XA_reg[1] QDFFRBN $PINS Q=A_out[1] D=n401 CK=clk_clone1
+ RB=FE_OFN34_FE_DBTN1_i_i_rst
XA_reg[2] QDFFRBN $PINS Q=A_out[2] D=n400 CK=clk_clone1
+ RB=FE_OFN305_FE_OFN4_FE_DBTN1_i_i_rst
XPy_reg[30] QDFFRBN $PINS Q=Py_out[30] D=n404 CK=clk_clone5
+ RB=FE_OFN291_FE_OFN8_FE_DBTN1_i_i_rst
XPy_reg[15] QDFFRBN $PINS Q=Py_out[15] D=n419 CK=clk_clone4
+ RB=FE_OFN279_FE_OFN13_FE_DBTN1_i_i_rst
XPy_reg[5] QDFFRBN $PINS Q=Py_out[5] D=n429 CK=clk_clone5 RB=FE_OFN341_n
XPx_reg[4] QDFFRBN $PINS Q=Px_out[4] D=n462 CK=clk_clone5
+ RB=FE_OFN291_FE_OFN8_FE_DBTN1_i_i_rst
XPx_reg[29] QDFFRBN $PINS Q=Px_out[29] D=n437 CK=clk
+ RB=FE_OFN23_FE_DBTN1_i_i_rst
XU3 ND2P $PINS O=n39 I1=N157 I2=n169
XU4 ND2P $PINS O=n36 I1=A_add[32] I2=FE_OFN524_n66
XU5 ND2P $PINS O=n38 I1=N356 I2=n168
XU7 ND3 $PINS O=n166 I1=n32 I2=n33 I3=n34
XU22 ND2 $PINS O=n29 I1=Px_add[32] I2=FE_OFN530_n272
XU29 ND2 $PINS O=n32 I1=Py_add[32] I2=FE_OFN527_n170
XU34 ND2 $PINS O=n34 I1=Py_i[31] I2=FE_OFN528_n172
XU35 ND2 $PINS O=n33 I1=Py_out[30] I2=FE_OFN534_n8
XU36 ND2 $PINS O=n30 I1=Px_out[30] I2=n6
XU37 ND2 $PINS O=n37 I1=A_i[31] I2=n67
XU38 ND3 $PINS O=n404 I1=n28 I2=n174 I3=n175
XU40 OR2 $PINS O=n403 I1=n166 I2=n167
XU45 NR2 $PINS O=n6 I1=n519 I2=N257
XU46 NR2P $PINS O=n7 I1=n519 I2=N389
XU47 NR2P $PINS O=n8 I1=n519 I2=N323
XU63 ND2 $PINS O=n26 I1=n29 I2=n30
XU64 ND2 $PINS O=n268 I1=n31 I2=n27
XU65 INV1CK $PINS O=n27 I=n26
XU66 ND2 $PINS O=n31 I1=N290 I2=n274
XU67 AO222S $PINS O=n360 A1=N62 A2=FE_OFN643_n270 B1=Px_i[2] B2=FE_OFN529_n271
+ C1=Px_out[2] C2=FE_OFN580_n
XU68 AO222S $PINS O=n300 A1=N82 A2=n270 B1=Px_i[22] B2=n271 C1=Px_out[22]
+ C2=FE_OFN64_n64
XU69 AO222S $PINS O=n291 A1=N85 A2=n270 B1=Px_i[25] B2=n271 C1=Px_out[25]
+ C2=FE_OFN64_n64
XU70 AO222S $PINS O=n275 A1=N90 A2=n270 B1=Px_i[30] B2=n271 C1=Px_out[30]
+ C2=FE_OFN64_n64
XU71 ND2P $PINS O=n41 I1=N422 I2=FE_OFN522_n62
XU72 ND2P $PINS O=n42 I1=N223 I2=FE_OFN641_n63
XU74 ND2 $PINS O=n35 I1=A_out[30] I2=n7
XU75 ND2 $PINS O=n40 I1=Py_out[31] I2=FE_OFN582_n
XU77 ND2 $PINS O=n43 I1=A_out[31] I2=n64
XU80 OR2T $PINS O=n371 I1=n60 I2=n61
XU81 OR2 $PINS O=n435 I1=n268 I2=n269
XU89 NR2P $PINS O=n44 I1=n522 I2=A_out[0]
XU90 NR2 $PINS O=n45 I1=n522 I2=Py_out[0]
XU91 NR2 $PINS O=n46 I1=n522 I2=FE_PSRN_10
XU98 NR2 $PINS O=n271 I1=n518 I2=N58
XU99 NR2P $PINS O=n67 I1=n518 I2=N190
XU100 NR2P $PINS O=n172 I1=n518 I2=N124
XU111 INV1S $PINS O=n520 I=done
XU116 AOI12HS $PINS O=n64 A1=n370 B1=in_sig B2=n523
XU117 INV1S $PINS O=n518 I=n164
XU118 AN2 $PINS O=n63 I1=N190 I2=n164
XU119 AN2 $PINS O=n169 I1=N124 I2=n164
XU120 AN2 $PINS O=n270 I1=N58 I2=n164
XU122 INV1S $PINS O=n522 I=n159
XU123 INV1S $PINS O=n519 I=n163
XU124 AN2 $PINS O=n274 I1=N257 I2=n163
XU127 AN2 $PINS O=n62 I1=N389 I2=n163
XU128 AN2 $PINS O=n168 I1=N323 I2=n163
XU130 NR2 $PINS O=done I1=n521 I2=n523
XU131 MOAI1S $PINS O=n468 A1=FE_PHN767_n526 A2=n520 B1=N42 B2=n370
XU132 MOAI1S $PINS O=n469 A1=FE_PHN915_n525 A2=n520 B1=N41 B2=n370
XU136 AOI22S $PINS O=n74 A1=A_out[28] A2=n7 B1=A_i[29] B2=n67
XU137 AOI22S $PINS O=n73 A1=FE_OFN535_n44 A2=A_out[30] B1=A_add[30]
+ B2=FE_OFN524_n66
XU138 AOI22S $PINS O=n80 A1=A_out[26] A2=n7 B1=A_i[27] B2=n67
XU139 AOI22S $PINS O=n79 A1=A_out[28] A2=FE_OFN535_n44 B1=A_add[28]
+ B2=FE_OFN524_n66
XU140 AOI22S $PINS O=n70 A1=A_out[29] A2=n7 B1=A_i[30] B2=n67
XU141 AOI22S $PINS O=n69 A1=FE_OFN535_n44 A2=A_out[31] B1=A_add[31]
+ B2=FE_OFN524_n66
XU142 AOI22S $PINS O=n77 A1=A_out[27] A2=n7 B1=A_i[28] B2=n67
XU143 AOI22S $PINS O=n76 A1=A_out[29] A2=FE_OFN535_n44 B1=A_add[29]
+ B2=FE_OFN524_n66
XU144 AOI22S $PINS O=n83 A1=A_out[25] A2=n7 B1=A_i[26] B2=n67
XU145 AOI22S $PINS O=n82 A1=A_out[27] A2=FE_OFN535_n44 B1=A_add[27]
+ B2=FE_OFN524_n66
XU146 AOI22S $PINS O=n276 A1=Px_out[29] A2=n6 B1=n46 B2=Px_out[31]
XU147 AOI22S $PINS O=n277 A1=Px_add[31] A2=FE_OFN530_n272 B1=N289 B2=n274
XU148 AOI22S $PINS O=n181 A1=Py_out[27] A2=n8 B1=n45 B2=Py_out[29]
XU149 AOI22S $PINS O=n182 A1=Py_add[29] A2=FE_OFN527_n170 B1=Py_i[28]
+ B2=FE_OFN528_n172
XU150 AOI22S $PINS O=n283 A1=Px_out[27] A2=n6 B1=FE_OFN624_n46 B2=Px_out[29]
XU151 AOI22S $PINS O=n284 A1=Px_add[29] A2=FE_OFN530_n272 B1=N287 B2=n274
XU152 AOI22S $PINS O=n178 A1=Py_out[28] A2=n8 B1=n45 B2=Py_out[30]
XU153 AOI22S $PINS O=n179 A1=Py_add[30] A2=FE_OFN527_n170 B1=Py_i[29]
+ B2=FE_OFN528_n172
XU154 AOI22S $PINS O=n280 A1=Px_out[28] A2=n6 B1=FE_OFN624_n46 B2=Px_out[30]
XU155 AOI22S $PINS O=n281 A1=Px_add[30] A2=FE_OFN530_n272 B1=N288 B2=n274
XU156 AOI22S $PINS O=n184 A1=Py_out[26] A2=n8 B1=Py_out[28] B2=n45
XU157 AOI22S $PINS O=n185 A1=Py_add[28] A2=FE_OFN527_n170 B1=Py_i[27]
+ B2=FE_OFN528_n172
XU158 AOI22S $PINS O=n187 A1=Py_out[25] A2=n8 B1=Py_out[27] B2=n45
XU159 AOI22S $PINS O=n188 A1=Py_add[27] A2=FE_OFN527_n170 B1=Py_i[26]
+ B2=FE_OFN528_n172
XU160 AOI22S $PINS O=n286 A1=Px_out[26] A2=n6 B1=Px_out[28] B2=FE_OFN624_n46
XU161 AOI22S $PINS O=n287 A1=Px_add[28] A2=FE_OFN530_n272 B1=N286 B2=n274
XU162 AOI22S $PINS O=n174 A1=Py_out[29] A2=FE_OFN534_n8 B1=n45 B2=Py_out[31]
XU164 AOI22S $PINS O=n289 A1=Px_out[25] A2=n6 B1=Px_out[27] B2=FE_OFN624_n46
XU165 AOI22S $PINS O=n290 A1=Px_add[27] A2=FE_OFN530_n272 B1=N285 B2=n274
XU167 AOI22S $PINS O=n92 A1=A_out[22] A2=n7 B1=p33 B2=n67
XU168 AOI22S $PINS O=n91 A1=A_out[24] A2=FE_OFN535_n44 B1=A_add[24]
+ B2=FE_OFN524_n66
XU169 AOI22S $PINS O=n86 A1=A_out[24] A2=n7 B1=A_i[25] B2=n67
XU170 AOI22S $PINS O=n85 A1=A_out[26] A2=FE_OFN535_n44 B1=A_add[26]
+ B2=FE_OFN524_n66
XU171 AOI22S $PINS O=n89 A1=A_out[23] A2=n7 B1=A_i[24] B2=n67
XU172 AOI22S $PINS O=n88 A1=A_out[25] A2=FE_OFN535_n44 B1=A_add[25]
+ B2=FE_OFN524_n66
XU173 AOI22S $PINS O=n95 A1=A_out[21] A2=n7 B1=A_i[22] B2=n67
XU174 AOI22S $PINS O=n94 A1=A_out[23] A2=FE_OFN535_n44 B1=A_add[23]
+ B2=FE_OFN524_n66
XU175 AOI22S $PINS O=n190 A1=Py_out[24] A2=n8 B1=Py_out[26] B2=n45
XU176 AOI22S $PINS O=n191 A1=Py_add[26] A2=FE_OFN527_n170 B1=Py_i[25]
+ B2=FE_OFN528_n172
XU177 AOI22S $PINS O=n193 A1=Py_out[23] A2=n8 B1=Py_out[25] B2=n45
XU178 AOI22S $PINS O=n194 A1=Py_add[25] A2=FE_OFN527_n170 B1=Py_i[24]
+ B2=FE_OFN528_n172
XU179 AOI22S $PINS O=n196 A1=Py_out[22] A2=FE_OFN534_n8 B1=Py_out[24]
+ B2=FE_OFN536_n45
XU180 AOI22S $PINS O=n197 A1=Py_add[24] A2=FE_OFN527_n170 B1=Py_i[23]
+ B2=FE_OFN528_n172
XU181 AOI22S $PINS O=n199 A1=Py_out[21] A2=FE_OFN534_n8 B1=Py_out[23]
+ B2=FE_OFN536_n45
XU182 AOI22S $PINS O=n200 A1=Py_add[23] A2=n170 B1=Py_i[22] B2=n172
XU183 AOI22S $PINS O=n292 A1=Px_out[24] A2=n6 B1=Px_out[26] B2=FE_OFN624_n46
XU184 AOI22S $PINS O=n293 A1=Px_add[26] A2=n272 B1=N284 B2=n274
XU185 AOI22S $PINS O=n295 A1=Px_out[23] A2=n6 B1=Px_out[25] B2=FE_OFN624_n46
XU186 AOI22S $PINS O=n296 A1=Px_add[25] A2=n272 B1=N283 B2=n274
XU187 AOI22S $PINS O=n298 A1=Px_out[22] A2=n6 B1=Px_out[24] B2=FE_OFN624_n46
XU188 AOI22S $PINS O=n299 A1=Px_add[24] A2=n272 B1=N282 B2=n274
XU189 AOI22S $PINS O=n301 A1=Px_out[21] A2=n6 B1=Px_out[23] B2=FE_OFN624_n46
XU190 AOI22S $PINS O=n302 A1=Px_add[23] A2=n272 B1=N281 B2=n274
XU191 AOI22S $PINS O=n98 A1=A_out[20] A2=n7 B1=A_i[21] B2=n67
XU192 AOI22S $PINS O=n97 A1=A_out[22] A2=FE_OFN535_n44 B1=A_add[22]
+ B2=FE_OFN524_n66
XU193 AOI22S $PINS O=n101 A1=A_out[19] A2=n7 B1=A_i[20] B2=n67
XU194 AOI22S $PINS O=n100 A1=A_out[21] A2=FE_OFN535_n44 B1=A_add[21]
+ B2=FE_OFN524_n66
XU195 AOI22S $PINS O=n202 A1=Py_out[20] A2=FE_OFN534_n8 B1=Py_out[22]
+ B2=FE_OFN536_n45
XU196 AOI22S $PINS O=n203 A1=Py_add[22] A2=n170 B1=FE_PHN1602_raw2_21 B2=n172
XU197 AOI22S $PINS O=n205 A1=Py_out[19] A2=FE_OFN534_n8 B1=Py_out[21]
+ B2=FE_OFN536_n45
XU198 AOI22S $PINS O=n206 A1=Py_add[21] A2=n170 B1=Py_i[20] B2=n172
XU199 AOI22S $PINS O=n304 A1=Px_out[20] A2=n6 B1=Px_out[22] B2=FE_OFN624_n46
XU200 AOI22S $PINS O=n305 A1=Px_add[22] A2=n272 B1=N280 B2=n274
XU201 AOI22S $PINS O=n307 A1=Px_out[19] A2=FE_OFN532_n6 B1=Px_out[21]
+ B2=FE_OFN624_n46
XU202 AOI22S $PINS O=n308 A1=Px_add[21] A2=n272 B1=N279 B2=FE_OFN531_n274
XU203 AOI22S $PINS O=n104 A1=A_out[18] A2=n7 B1=A_i[19] B2=n67
XU204 AOI22S $PINS O=n103 A1=A_out[20] A2=FE_OFN535_n44 B1=A_add[20]
+ B2=FE_OFN524_n66
XU205 AOI22S $PINS O=n208 A1=Py_out[18] A2=FE_OFN534_n8 B1=Py_out[20]
+ B2=FE_OFN536_n45
XU206 AOI22S $PINS O=n209 A1=Py_add[20] A2=n170 B1=Py_i[19] B2=n172
XU207 AOI22S $PINS O=n310 A1=Px_out[18] A2=FE_OFN532_n6 B1=Px_out[20]
+ B2=FE_OFN624_n46
XU208 AOI22S $PINS O=n311 A1=Px_add[20] A2=n272 B1=N278 B2=FE_OFN531_n274
XU209 AOI22S $PINS O=n107 A1=A_out[17] A2=n7 B1=A_i[18] B2=n67
XU210 AOI22S $PINS O=n106 A1=A_out[19] A2=FE_OFN535_n44 B1=A_add[19]
+ B2=FE_OFN524_n66
XU211 AOI22S $PINS O=n110 A1=A_out[16] A2=FE_OFN533_n7 B1=A_i[17]
+ B2=FE_OFN525_n67
XU212 AOI22S $PINS O=n109 A1=A_out[18] A2=FE_OFN535_n44 B1=A_add[18]
+ B2=FE_OFN524_n66
XU213 AOI22S $PINS O=n113 A1=A_out[15] A2=FE_OFN533_n7 B1=A_i[16]
+ B2=FE_OFN525_n67
XU214 AOI22S $PINS O=n112 A1=A_out[17] A2=n44 B1=A_add[17] B2=n66
XU215 AOI22S $PINS O=n211 A1=Py_out[17] A2=FE_OFN534_n8 B1=Py_out[19]
+ B2=FE_OFN536_n45
XU216 AOI22S $PINS O=n212 A1=Py_add[19] A2=n170 B1=Py_i[18] B2=n172
XU217 AOI22S $PINS O=n214 A1=Py_out[16] A2=FE_OFN534_n8 B1=Py_out[18]
+ B2=FE_OFN536_n45
XU218 AOI22S $PINS O=n215 A1=Py_add[18] A2=n170 B1=Py_i[17] B2=n172
XU219 AOI22S $PINS O=n217 A1=Py_out[15] A2=FE_OFN534_n8 B1=Py_out[17]
+ B2=FE_OFN536_n45
XU220 AOI22S $PINS O=n218 A1=Py_add[17] A2=n170 B1=Py_i[16] B2=n172
XU221 AOI22S $PINS O=n313 A1=Px_out[17] A2=FE_OFN532_n6 B1=Px_out[19]
+ B2=FE_OFN624_n46
XU222 AOI22S $PINS O=n314 A1=Px_add[19] A2=n272 B1=N277 B2=FE_OFN531_n274
XU223 AOI22S $PINS O=n316 A1=Px_out[16] A2=FE_OFN532_n6 B1=Px_out[18]
+ B2=FE_OFN624_n46
XU224 AOI22S $PINS O=n317 A1=Px_add[18] A2=n272 B1=N276 B2=FE_OFN531_n274
XU225 AOI22S $PINS O=n319 A1=Px_out[15] A2=FE_OFN532_n6 B1=Px_out[17]
+ B2=FE_OFN624_n46
XU226 AOI22S $PINS O=n320 A1=Px_add[17] A2=n272 B1=N275 B2=FE_OFN531_n274
XU228 AOI22S $PINS O=n322 A1=Px_out[14] A2=FE_OFN532_n6 B1=Px_out[16]
+ B2=FE_OFN624_n46
XU229 AOI22S $PINS O=n323 A1=Px_add[16] A2=n272 B1=N274 B2=FE_OFN531_n274
XU230 AOI22S $PINS O=n325 A1=FE_PHN1564_i1_w_13 A2=FE_OFN532_n6
+ B1=FE_PHN1201_i1_w_15 B2=FE_OFN624_n46
XU231 AOI22S $PINS O=n326 A1=Px_add[15] A2=n272 B1=N273 B2=FE_OFN531_n274
XU232 AOI22S $PINS O=n328 A1=Px_out[12] A2=FE_OFN532_n6 B1=Px_out[14]
+ B2=FE_OFN624_n46
XU233 AOI22S $PINS O=n329 A1=Px_add[14] A2=FE_OFN530_n272 B1=N272
+ B2=FE_OFN531_n274
XU234 AOI22S $PINS O=n331 A1=Px_out[11] A2=FE_OFN532_n6 B1=Px_out[13] B2=n46
XU235 AOI22S $PINS O=n332 A1=Px_add[13] A2=FE_OFN530_n272 B1=N271
+ B2=FE_OFN531_n274
XU236 AOI22S $PINS O=n116 A1=A_out[14] A2=FE_OFN533_n7 B1=A_i[15]
+ B2=FE_OFN525_n67
XU237 AOI22S $PINS O=n115 A1=A_out[16] A2=n44 B1=A_add[16] B2=n66
XU238 AOI22S $PINS O=n119 A1=A_out[13] A2=FE_OFN533_n7 B1=A_i[14]
+ B2=FE_OFN525_n67
XU239 AOI22S $PINS O=n118 A1=A_out[15] A2=n44 B1=A_add[15] B2=n66
XU240 AOI22S $PINS O=n122 A1=A_out[12] A2=FE_OFN533_n7 B1=A_i[13]
+ B2=FE_OFN525_n67
XU241 AOI22S $PINS O=n121 A1=A_out[14] A2=n44 B1=A_add[14] B2=n66
XU242 AOI22S $PINS O=n125 A1=A_out[11] A2=FE_OFN533_n7 B1=A_i[12]
+ B2=FE_OFN525_n67
XU243 AOI22S $PINS O=n124 A1=A_out[13] A2=n44 B1=A_add[13] B2=n66
XU244 AOI22S $PINS O=n220 A1=Py_out[14] A2=FE_OFN534_n8 B1=Py_out[16]
+ B2=FE_OFN536_n45
XU245 AOI22S $PINS O=n221 A1=Py_add[16] A2=n170 B1=Py_i[15] B2=n172
XU246 AOI22S $PINS O=n223 A1=Py_out[13] A2=n8 B1=Py_out[15] B2=FE_OFN536_n45
XU247 AOI22S $PINS O=n224 A1=Py_add[15] A2=n170 B1=Py_i[14] B2=n172
XU248 AOI22S $PINS O=n226 A1=Py_out[12] A2=n8 B1=Py_out[14] B2=FE_OFN536_n45
XU249 AOI22S $PINS O=n227 A1=Py_add[14] A2=FE_OFN527_n170 B1=Py_i[13]
+ B2=FE_OFN528_n172
XU250 AOI22S $PINS O=n229 A1=Py_out[11] A2=n8 B1=Py_out[13] B2=FE_OFN536_n45
XU251 AOI22S $PINS O=n230 A1=Py_add[13] A2=FE_OFN527_n170 B1=Py_i[12]
+ B2=FE_OFN528_n172
XU252 NR3 $PINS O=n164 I1=state[0] I2=state[1] I3=FE_OFN64_n64
XU253 AOI22S $PINS O=n334 A1=Px_out[10] A2=FE_OFN532_n6 B1=Px_out[12] B2=n46
XU254 AOI22S $PINS O=n335 A1=Px_add[12] A2=FE_OFN530_n272 B1=N270 B2=n274
XU255 AOI22S $PINS O=n337 A1=Px_out[9] A2=FE_OFN532_n6 B1=Px_out[11] B2=n46
XU256 AOI22S $PINS O=n338 A1=Px_add[11] A2=FE_OFN530_n272 B1=N269
+ B2=FE_OFN531_n274
XU258 AOI22S $PINS O=n340 A1=Px_out[8] A2=FE_OFN532_n6 B1=Px_out[10] B2=n46
XU259 AOI22S $PINS O=n341 A1=Px_add[10] A2=FE_OFN530_n272 B1=N268
+ B2=FE_OFN531_n274
XU322 AOI22S $PINS O=n343 A1=Px_out[7] A2=FE_OFN532_n6 B1=Px_out[9] B2=n46
XU323 AOI22S $PINS O=n344 A1=Px_add[9] A2=FE_OFN530_n272 B1=N267
+ B2=FE_OFN531_n274
XU324 AOI22S $PINS O=n346 A1=Px_out[6] A2=FE_OFN532_n6 B1=Px_out[8] B2=n46
XU325 AOI22S $PINS O=n347 A1=Px_add[8] A2=FE_OFN530_n272 B1=N266
+ B2=FE_OFN531_n274
XU387 AOI22S $PINS O=n350 A1=Px_add[7] A2=n272 B1=N265 B2=FE_OFN531_n274
XU389 AOI22S $PINS O=n349 A1=Px_out[5] A2=FE_OFN532_n6 B1=Px_out[7] B2=n46
XU399 AOI22S $PINS O=n353 A1=Px_add[6] A2=n272 B1=N264 B2=FE_OFN531_n274
XU405 AOI22S $PINS O=n352 A1=Px_out[4] A2=FE_OFN532_n6 B1=Px_out[6] B2=n46
XU445 AOI22S $PINS O=n356 A1=Px_add[5] A2=n272 B1=N263 B2=FE_OFN531_n274
XU453 AOI22S $PINS O=n355 A1=Px_out[3] A2=FE_OFN532_n6 B1=Px_out[5] B2=n46
XU454 AOI22S $PINS O=n359 A1=Px_add[4] A2=n272 B1=N262 B2=FE_OFN531_n274
XU455 AOI22S $PINS O=n358 A1=Px_out[2] A2=FE_OFN532_n6 B1=Px_out[4] B2=n46
XU456 AOI22S $PINS O=n362 A1=Px_add[3] A2=n272 B1=N261 B2=FE_OFN531_n274
XU457 AOI22S $PINS O=n361 A1=Px_out[1] A2=FE_OFN532_n6 B1=Px_out[3] B2=n46
XU458 AOI22S $PINS O=n365 A1=Px_add[2] A2=n272 B1=N260 B2=FE_OFN531_n274
XU459 AOI22S $PINS O=n364 A1=Px_out[0] A2=FE_OFN532_n6 B1=Px_out[2] B2=n46
XU460 AOI22S $PINS O=n128 A1=A_out[10] A2=FE_OFN533_n7 B1=A_i[11]
+ B2=FE_OFN525_n67
XU461 AOI22S $PINS O=n127 A1=A_out[12] A2=n44 B1=A_add[12] B2=n66
XU462 AOI22S $PINS O=n131 A1=A_out[9] A2=FE_OFN533_n7 B1=A_i[10]
+ B2=FE_OFN525_n67
XU463 AOI22S $PINS O=n130 A1=A_out[11] A2=n44 B1=A_add[11] B2=n66
XU464 AOI22S $PINS O=n134 A1=A_out[8] A2=FE_OFN533_n7 B1=A_i[9]
+ B2=FE_OFN525_n67
XU465 AOI22S $PINS O=n133 A1=A_out[10] A2=n44 B1=A_add[10] B2=n66
XU466 AOI22S $PINS O=n136 A1=A_out[9] A2=n44 B1=A_add[9] B2=n66
XU467 AOI22S $PINS O=n137 A1=A_out[7] A2=FE_OFN533_n7 B1=A_i[8]
+ B2=FE_OFN525_n67
XU468 AOI22S $PINS O=n139 A1=A_out[8] A2=n44 B1=A_add[8] B2=n66
XU469 AOI22S $PINS O=n140 A1=A_out[6] A2=FE_OFN533_n7 B1=A_i[7]
+ B2=FE_OFN525_n67
XU470 AOI22S $PINS O=n142 A1=A_out[7] A2=n44 B1=A_add[7] B2=n66
XU471 AOI22S $PINS O=n143 A1=A_out[5] A2=FE_OFN533_n7 B1=A_i[6]
+ B2=FE_OFN525_n67
XU472 AOI22S $PINS O=n145 A1=A_out[6] A2=n44 B1=A_add[6] B2=n66
XU473 AOI22S $PINS O=n146 A1=A_out[4] A2=FE_OFN533_n7 B1=A_i[5]
+ B2=FE_OFN525_n67
XU474 AOI22S $PINS O=n148 A1=A_out[5] A2=n44 B1=A_add[5] B2=n66
XU475 AOI22S $PINS O=n149 A1=A_out[3] A2=FE_OFN533_n7 B1=A_i[4]
+ B2=FE_OFN525_n67
XU476 AOI22S $PINS O=n151 A1=A_out[4] A2=n44 B1=A_add[4] B2=n66
XU477 AOI22S $PINS O=n152 A1=A_out[2] A2=FE_OFN533_n7 B1=A_i[3]
+ B2=FE_OFN525_n67
XU478 AOI22S $PINS O=n154 A1=A_out[3] A2=n44 B1=A_add[3] B2=n66
XU479 AOI22S $PINS O=n155 A1=A_out[1] A2=FE_OFN533_n7 B1=A_i[2]
+ B2=FE_OFN525_n67
XU480 AOI22S $PINS O=n157 A1=A_out[2] A2=FE_OFN535_n44 B1=A_add[2]
+ B2=FE_OFN524_n66
XU481 AOI22S $PINS O=n158 A1=n7 A2=A_out[0] B1=A_i[1] B2=FE_OFN525_n67
XU482 AOI22S $PINS O=n232 A1=Py_out[10] A2=n8 B1=Py_out[12] B2=FE_OFN536_n45
XU483 AOI22S $PINS O=n233 A1=Py_add[12] A2=FE_OFN527_n170 B1=Py_i[11]
+ B2=FE_OFN528_n172
XU484 AOI22S $PINS O=n235 A1=Py_out[9] A2=n8 B1=Py_out[11] B2=n45
XU485 AOI22S $PINS O=n236 A1=Py_add[11] A2=FE_OFN527_n170 B1=Py_i[10]
+ B2=FE_OFN528_n172
XU486 AOI22S $PINS O=n238 A1=Py_out[8] A2=n8 B1=Py_out[10] B2=n45
XU487 AOI22S $PINS O=n239 A1=Py_add[10] A2=FE_OFN527_n170 B1=Py_i[9]
+ B2=FE_OFN528_n172
XU488 AOI22S $PINS O=n241 A1=Py_out[7] A2=n8 B1=Py_out[9] B2=n45
XU489 AOI22S $PINS O=n242 A1=Py_add[9] A2=FE_OFN527_n170 B1=Py_i[8]
+ B2=FE_OFN528_n172
XU490 AOI22S $PINS O=n244 A1=Py_out[6] A2=n8 B1=Py_out[8] B2=n45
XU491 AOI22S $PINS O=n245 A1=Py_add[8] A2=FE_OFN527_n170 B1=Py_i[7]
+ B2=FE_OFN528_n172
XU492 AOI22S $PINS O=n247 A1=Py_out[5] A2=FE_OFN534_n8 B1=Py_out[7]
+ B2=FE_OFN536_n45
XU493 AOI22S $PINS O=n248 A1=Py_add[7] A2=n170 B1=Py_i[6] B2=n172
XU494 AOI22S $PINS O=n250 A1=Py_out[4] A2=FE_OFN534_n8 B1=Py_out[6]
+ B2=FE_OFN536_n45
XU495 AOI22S $PINS O=n251 A1=Py_add[6] A2=n170 B1=Py_i[5] B2=n172
XU496 AOI22S $PINS O=n253 A1=Py_out[3] A2=FE_OFN534_n8 B1=Py_out[5]
+ B2=FE_OFN536_n45
XU497 AOI22S $PINS O=n254 A1=Py_add[5] A2=n170 B1=p34 B2=n172
XU498 AOI22S $PINS O=n256 A1=Py_out[2] A2=FE_OFN534_n8 B1=Py_out[4]
+ B2=FE_OFN536_n45
XU499 AOI22S $PINS O=n257 A1=Py_add[4] A2=n170 B1=Py_i[3] B2=n172
XU500 AOI22S $PINS O=n259 A1=Py_out[1] A2=FE_OFN534_n8 B1=Py_out[3]
+ B2=FE_OFN536_n45
XU501 AOI22S $PINS O=n260 A1=Py_add[3] A2=n170 B1=Py_i[2] B2=n172
XU502 AOI22S $PINS O=n262 A1=Py_out[0] A2=FE_OFN534_n8 B1=Py_out[2]
+ B2=FE_OFN536_n45
XU503 AOI22S $PINS O=n263 A1=Py_add[2] A2=n170 B1=Py_i[1] B2=n172
XU505 NR2 $PINS O=n159 I1=n523 I2=state[0]
XU506 INV1S $PINS O=n523 I=state[1]
XU507 NR2 $PINS O=n163 I1=n521 I2=state[1]
XU508 ND3 $PINS O=FE_PHN1364_n434 I1=n264 I2=n265 I3=n266
XU509 AOI22S $PINS O=n264 A1=Py_out[0] A2=n267 B1=Py_out[1] B2=n45
XU510 AOI22S $PINS O=n266 A1=N126 A2=FE_OFN642_n169 B1=N325 B2=n168
XU511 INV1S $PINS O=n521 I=state[0]
XU512 ND3 $PINS O=n466 I1=n366 I2=n367 I3=n368
XU513 AOI22S $PINS O=n366 A1=Px_out[0] A2=n369 B1=Px_out[1] B2=n46
XU514 AOI22S $PINS O=n368 A1=Px_i[0] A2=FE_OFN529_n271 B1=N60 B2=FE_OFN643_n270
XU515 ND3 $PINS O=FE_PHN1389_n402 I1=n160 I2=n161 I3=n162
XU516 AOI22S $PINS O=n160 A1=A_out[0] A2=n165 B1=A_out[1] B2=n44
XU517 AOI22S $PINS O=n162 A1=N192 A2=n63 B1=N391 B2=FE_OFN522_n62
XU518 OAI112HS $PINS O=state_nxt[0] A1=n58 B1=n519 C1=n56 C2=n522
XU519 ND3 $PINS O=n58 I1=in_sig I2=n523 I3=ToMont
XU520 AN2 $PINS O=n66 I1=A_out[0] I2=n159
XU521 OAI112HS $PINS O=state_nxt[1] A1=n57 B1=n522 C1=n519 C2=n56
XU522 AN2 $PINS O=n170 I1=Py_out[0] I2=n159
XU523 AN2 $PINS O=n272 I1=FE_PSRN_10 I2=n159
XU524 ND3 $PINS O=n56 I1=counter[4] I2=FE_PHN961_counter_3 I3=n59
XU525 NR3 $PINS O=n59 I1=n526 I2=n524 I3=n525
XU526 MOAI1S $PINS O=n470 A1=n524 A2=n520 B1=n524 B2=n370
XU527 INV1S $PINS O=n526 I=counter[2]
XU528 INV1S $PINS O=n524 I=FE_PHN971_counter_0
XU529 INV1S $PINS O=n525 I=counter[1]
XU533 XOR2HS $PINS O=N44 I1=r341/carry[4] I2=counter[4]
.ENDS

.SUBCKT Domain_Transfer_0_DW01_sub_0 A[31] A[30] A[29] A[28] A[27] A[26] A[25]
+ A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12]
+ A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] CI DIFF[31] DIFF[30] DIFF[29] DIFF[28] DIFF[27] DIFF[26]
+ DIFF[25] DIFF[24] DIFF[23] DIFF[22] DIFF[21] DIFF[20] DIFF[19] DIFF[18]
+ DIFF[17] DIFF[16] DIFF[15] DIFF[14] DIFF[13] DIFF[12] DIFF[11] DIFF[10]
+ DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3] DIFF[2] DIFF[1]
+ DIFF[0] CO
.ENDS

.SUBCKT Domain_Transfer_0_DW_cmp_0 A[32] A[31] A[30] A[29] A[28] A[27] A[26]
+ A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13]
+ A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[32]
+ B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19]
+ B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6]
+ B[5] B[4] B[3] B[2] B[1] B[0] TC GE_LT GE_GT_EQ GE_LT_GT_LE EQ_NE
.ENDS

.SUBCKT Domain_Transfer_0_DW01_sub_1 A[31] A[30] A[29] A[28] A[27] A[26] A[25]
+ A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12]
+ A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] CI DIFF[31] DIFF[30] DIFF[29] DIFF[28] DIFF[27] DIFF[26]
+ DIFF[25] DIFF[24] DIFF[23] DIFF[22] DIFF[21] DIFF[20] DIFF[19] DIFF[18]
+ DIFF[17] DIFF[16] DIFF[15] DIFF[14] DIFF[13] DIFF[12] DIFF[11] DIFF[10]
+ DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3] DIFF[2] DIFF[1]
+ DIFF[0] CO
XFE_RC_2347_0 ND3P $PINS O=carry[28] I1=n15 I2=n16 I3=n14
XFE_RC_2346_0 ND3P $PINS O=carry[17] I1=n30 I2=n29 I3=n28
XFE_RC_2345_0 ND3P $PINS O=carry[5] I1=n8 I2=n9 I3=n7
XFE_OFC649_FE_OFN87_n312 INV2 $PINS O=n38 I=B[1]
XFE_OFC619_n310 INV2 $PINS O=n37 I=B[0]
XFE_OCPC445_carry_20 BUF1S $PINS O=FE_OCPN445_carry_20 I=carry[20]
XFE_OCPC444_carry_17 BUF1S $PINS O=FE_OCPN444_carry_17 I=carry[17]
XFE_OCPC400_carry_26 BUF1S $PINS O=FE_OCPN400_carry_26 I=carry[26]
XFE_OCPC397_carry_5 BUF1S $PINS O=FE_OCPN397_carry_5 I=carry[5]
XFE_RC_2313_0 XOR3 $PINS O=DIFF[3] I1=A[3] I2=n40 I3=carry[3]
XFE_RC_2312_0 MAO222 $PINS O=carry[4] A1=A[3] B1=n40 C1=carry[3]
XFE_RC_2274_0 XOR3 $PINS O=DIFF[6] I1=A[6] I2=n43 I3=carry[6]
XFE_RC_2273_0 MAO222 $PINS O=carry[7] A1=A[6] B1=n43 C1=carry[6]
XFE_OCPC343_carry_28 BUF1S $PINS O=FE_OCPN343_carry_28 I=carry[28]
XFE_RC_2128_0 ND2 $PINS O=FE_RN_1451_0 I1=A[7] I2=n44
XFE_RC_2127_0 AN2 $PINS O=FE_RN_1452_0 I1=FE_RN_1455_0 I2=FE_RN_1451_0
XFE_RC_2126_0 XNR2HS $PINS O=FE_RN_1453_0 I1=n44 I2=A[7]
XFE_RC_2125_0 MXL2HS $PINS OB=DIFF[7] S=carry[7] A=FE_RN_1453_0 B=FE_RN_1452_0
XFE_RC_2124_0 ND2 $PINS O=FE_RN_1454_0 I1=A[7] I2=n44
XFE_RC_2123_0 OR2 $PINS O=FE_RN_1455_0 I1=n44 I2=A[7]
XFE_RC_2122_0 ND2 $PINS O=FE_RN_1456_0 I1=FE_RN_1455_0 I2=carry[7]
XFE_RC_2121_0 ND2P $PINS O=carry[8] I1=FE_RN_1456_0 I2=FE_RN_1454_0
XFE_RC_1917_0 ND2S $PINS O=FE_RN_1292_0 I1=A[8] I2=B[8]
XFE_RC_1916_0 AN2 $PINS O=FE_RN_1293_0 I1=FE_RN_1296_0 I2=FE_RN_1292_0
XFE_RC_1915_0 XNR2HS $PINS O=FE_RN_1294_0 I1=B[8] I2=A[8]
XFE_RC_1914_0 MXL2HS $PINS OB=DIFF[8] S=carry[8] A=FE_RN_1294_0 B=FE_RN_1293_0
XFE_RC_1913_0 ND2S $PINS O=FE_RN_1295_0 I1=A[8] I2=B[8]
XFE_RC_1912_0 OR2S $PINS O=FE_RN_1296_0 I1=B[8] I2=A[8]
XFE_RC_1911_0 ND2 $PINS O=FE_RN_1297_0 I1=FE_RN_1296_0 I2=carry[8]
XFE_RC_1910_0 ND2P $PINS O=carry[9] I1=FE_RN_1297_0 I2=FE_RN_1295_0
XFE_RC_1676_0 ND2S $PINS O=FE_RN_1110_0 I1=A[9] I2=n46
XFE_RC_1675_0 AN2 $PINS O=FE_RN_1111_0 I1=FE_RN_1114_0 I2=FE_RN_1110_0
XFE_RC_1674_0 XNR2HS $PINS O=FE_RN_1112_0 I1=n46 I2=A[9]
XFE_RC_1673_0 MXL2HS $PINS OB=DIFF[9] S=carry[9] A=FE_RN_1112_0 B=FE_RN_1111_0
XFE_RC_1671_0 OR2 $PINS O=FE_RN_1114_0 I1=n46 I2=A[9]
XFE_RC_1670_0 ND2 $PINS O=FE_RN_1115_0 I1=FE_RN_1114_0 I2=carry[9]
XFE_RC_1669_0 ND2P $PINS O=carry[10] I1=FE_RN_1115_0 I2=FE_RN_1110_0
XFE_RC_1469_0 ND2 $PINS O=FE_RN_957_0 I1=A[10] I2=n47
XFE_RC_1468_0 AN2 $PINS O=FE_RN_958_0 I1=FE_RN_961_0 I2=FE_RN_957_0
XFE_RC_1467_0 XNR2HS $PINS O=FE_RN_959_0 I1=n47 I2=A[10]
XFE_RC_1466_0 MXL2HS $PINS OB=DIFF[10] S=carry[10] A=FE_RN_959_0 B=FE_RN_958_0
XFE_RC_1464_0 OR2 $PINS O=FE_RN_961_0 I1=n47 I2=A[10]
XFE_RC_1463_0 ND2 $PINS O=FE_RN_962_0 I1=FE_RN_961_0 I2=carry[10]
XFE_RC_1462_0 ND2P $PINS O=carry[11] I1=FE_RN_962_0 I2=FE_RN_957_0
XFE_RC_1246_0 ND2S $PINS O=FE_RN_795_0 I1=A[11] I2=n48
XFE_RC_1245_0 AN2 $PINS O=FE_RN_796_0 I1=FE_RN_799_0 I2=FE_RN_795_0
XFE_RC_1244_0 XNR2HS $PINS O=FE_RN_797_0 I1=n48 I2=A[11]
XFE_RC_1243_0 MXL2HS $PINS OB=DIFF[11] S=carry[11] A=FE_RN_797_0 B=FE_RN_796_0
XFE_RC_1242_0 ND2S $PINS O=FE_RN_798_0 I1=A[11] I2=n48
XFE_RC_1241_0 OR2 $PINS O=FE_RN_799_0 I1=n48 I2=A[11]
XFE_RC_1240_0 ND2 $PINS O=FE_RN_800_0 I1=FE_RN_799_0 I2=carry[11]
XFE_RC_1239_0 ND2P $PINS O=carry[12] I1=FE_RN_800_0 I2=FE_RN_798_0
XFE_RC_1028_0 ND2S $PINS O=FE_RN_639_0 I1=A[12] I2=n49
XFE_RC_1027_0 AN2 $PINS O=FE_RN_640_0 I1=FE_RN_643_0 I2=FE_RN_639_0
XFE_RC_1026_0 XNR2HS $PINS O=FE_RN_641_0 I1=n49 I2=A[12]
XFE_RC_1025_0 MXL2HS $PINS OB=DIFF[12] S=carry[12] A=FE_RN_641_0 B=FE_RN_640_0
XFE_RC_1024_0 ND2S $PINS O=FE_RN_642_0 I1=A[12] I2=n49
XFE_RC_1023_0 OR2S $PINS O=FE_RN_643_0 I1=n49 I2=A[12]
XFE_RC_1022_0 ND2 $PINS O=FE_RN_644_0 I1=FE_RN_643_0 I2=carry[12]
XFE_RC_1021_0 ND2P $PINS O=carry[13] I1=FE_RN_644_0 I2=FE_RN_642_0
XFE_RC_854_0 MOAI1 $PINS O=carry[26] A1=FE_RN_410_0 A2=FE_RN_407_0 B1=n62
+ B2=A[25]
XFE_RC_853_0 ND2S $PINS O=FE_RN_508_0 I1=A[13] I2=n50
XFE_RC_852_0 AN2 $PINS O=FE_RN_509_0 I1=FE_RN_512_0 I2=FE_RN_508_0
XFE_RC_851_0 XNR2HS $PINS O=FE_RN_510_0 I1=n50 I2=A[13]
XFE_RC_850_0 MXL2HS $PINS OB=DIFF[13] S=carry[13] A=FE_RN_510_0 B=FE_RN_509_0
XFE_RC_849_0 ND2S $PINS O=FE_RN_511_0 I1=A[13] I2=n50
XFE_RC_848_0 OR2 $PINS O=FE_RN_512_0 I1=n50 I2=A[13]
XFE_RC_847_0 ND2 $PINS O=FE_RN_513_0 I1=FE_RN_512_0 I2=carry[13]
XFE_RC_846_0 ND2P $PINS O=carry[14] I1=FE_RN_513_0 I2=FE_RN_511_0
XFE_RC_716_0 INV1S $PINS O=FE_RN_414_0 I=n35
XFE_RC_715_0 MXL2HS $PINS OB=DIFF[31] S=carry[31] A=FE_RN_414_0 B=n35
XFE_RC_711_0 INV1S $PINS O=FE_RN_407_0 I=FE_RN_411_0
XFE_RC_710_0 AOI12HS $PINS O=FE_RN_408_0 A1=FE_RN_407_0 B1=A[25] B2=n62
XFE_RC_709_0 XNR2HS $PINS O=FE_RN_409_0 I1=n62 I2=A[25]
XFE_RC_708_0 MXL2HS $PINS OB=DIFF[25] S=carry[25] A=FE_RN_409_0 B=FE_RN_408_0
XFE_RC_707_0 INV1S $PINS O=FE_RN_410_0 I=carry[25]
XFE_RC_706_0 OR2S $PINS O=FE_RN_411_0 I1=n62 I2=A[25]
XFE_RC_466_0 ND2S $PINS O=FE_RN_232_0 I1=A[14] I2=n51
XFE_RC_465_0 AN2 $PINS O=FE_RN_233_0 I1=FE_RN_236_0 I2=FE_RN_232_0
XFE_RC_464_0 XNR2HS $PINS O=FE_RN_234_0 I1=n51 I2=A[14]
XFE_RC_463_0 MXL2HS $PINS OB=DIFF[14] S=carry[14] A=FE_RN_234_0 B=FE_RN_233_0
XFE_RC_462_0 ND2S $PINS O=FE_RN_235_0 I1=A[14] I2=n51
XFE_RC_461_0 OR2S $PINS O=FE_RN_236_0 I1=n51 I2=A[14]
XFE_RC_460_0 ND2 $PINS O=FE_RN_237_0 I1=FE_RN_236_0 I2=carry[14]
XFE_RC_459_0 ND2P $PINS O=carry[15] I1=FE_RN_237_0 I2=FE_RN_235_0
XFE_RC_182_0 ND2S $PINS O=FE_RN_60_0 I1=A[26] I2=n63
XFE_RC_181_0 AN2 $PINS O=FE_RN_61_0 I1=FE_RN_64_0 I2=FE_RN_60_0
XFE_RC_180_0 XNR2HS $PINS O=FE_RN_62_0 I1=n63 I2=A[26]
XFE_RC_179_0 MXL2HS $PINS OB=DIFF[26] S=FE_OCPN400_carry_26 A=FE_RN_62_0
+ B=FE_RN_61_0
XFE_RC_178_0 ND2S $PINS O=FE_RN_63_0 I1=A[26] I2=n63
XFE_RC_177_0 OR2S $PINS O=FE_RN_64_0 I1=n63 I2=A[26]
XFE_RC_176_0 ND2 $PINS O=FE_RN_65_0 I1=FE_RN_64_0 I2=carry[26]
XFE_RC_175_0 ND2P $PINS O=carry[27] I1=FE_RN_65_0 I2=FE_RN_63_0
XFE_RC_112_0 ND3P $PINS O=carry[18] I1=n33 I2=n34 I3=n32
XFE_RC_111_0 ND3P $PINS O=carry[29] I1=n20 I2=n19 I3=n18
XFE_RC_110_0 ND3P $PINS O=carry[6] I1=n13 I2=n12 I3=n11
XFE_RC_109_0 ND3P $PINS O=carry[21] I1=n27 I2=n26 I3=n25
XFE_RC_57_0 ND3P $PINS O=carry[20] I1=n22 I2=n23 I3=n21
XFE_RC_48_0 ND3P $PINS O=carry[16] I1=n1 I2=n2 I3=n3
XFE_OFC283_raw_prime_3 INV1S $PINS O=n40 I=B[3]
XFE_OFC223_raw_prime_5 INV1S $PINS O=n42 I=B[5]
XFE_OFC204_raw_prime_9 INV1S $PINS O=n46 I=B[9]
XFE_OFC171_raw_prime_7 INV1S $PINS O=n44 I=B[7]
XFE_OFC151_raw_prime_6 INV1S $PINS O=n43 I=B[6]
XFE_OFC136_raw_prime_2 INV1S $PINS O=n39 I=B[2]
XFE_OFC100_raw_prime_4 INV1S $PINS O=n41 I=B[4]
XU2_30 FA1 $PINS S=DIFF[30] CO=carry[31] A=A[30] B=n67 CI=carry[30]
XU2_29 FA1 $PINS S=DIFF[29] CO=carry[30] A=A[29] B=n66 CI=carry[29]
XU2_24 FA1 $PINS S=DIFF[24] CO=carry[25] A=A[24] B=n61 CI=carry[24]
XU2_23 FA1 $PINS S=DIFF[23] CO=carry[24] A=A[23] B=n60 CI=carry[23]
XU2_22 FA1 $PINS S=DIFF[22] CO=carry[23] A=A[22] B=n59 CI=carry[22]
XU2_21 FA1 $PINS S=DIFF[21] CO=carry[22] A=A[21] B=n58 CI=carry[21]
XU2_2 FA1 $PINS S=DIFF[2] CO=carry[3] A=A[2] B=n39 CI=carry[2]
XU2_1 FA1 $PINS S=DIFF[1] CO=carry[2] A=A[1] B=n38 CI=n37
XU1 XOR3 $PINS O=DIFF[15] I1=n52 I2=A[15] I3=carry[15]
XU2 ND2 $PINS O=n1 I1=carry[15] I2=n52
XU3 ND2 $PINS O=n2 I1=carry[15] I2=A[15]
XU4 ND2 $PINS O=n3 I1=n52 I2=A[15]
XU8 ND2 $PINS O=n7 I1=A[4] I2=n41
XU9 INV1S $PINS O=n55 I=B[18]
XU10 ND2 $PINS O=n28 I1=A[16] I2=n53
XU11 ND2 $PINS O=n21 I1=A[19] I2=n56
XU12 ND2 $PINS O=n14 I1=A[27] I2=n64
XU13 XOR3 $PINS O=DIFF[4] I1=A[4] I2=n41 I3=carry[4]
XU14 XOR3 $PINS O=DIFF[16] I1=A[16] I2=n53 I3=carry[16]
XU15 XOR3 $PINS O=DIFF[18] I1=n55 I2=A[18] I3=carry[18]
XU16 XOR3 $PINS O=DIFF[19] I1=A[19] I2=n56 I3=carry[19]
XU17 XOR3 $PINS O=DIFF[27] I1=A[27] I2=n64 I3=carry[27]
XU19 ND2 $PINS O=n4 I1=carry[18] I2=n55
XU20 ND2 $PINS O=n5 I1=carry[18] I2=A[18]
XU21 ND2S $PINS O=n6 I1=n55 I2=A[18]
XU22 ND3P $PINS O=carry[19] I1=n4 I2=n5 I3=n6
XU23 ND2 $PINS O=n8 I1=A[4] I2=carry[4]
XU24 ND2 $PINS O=n9 I1=n41 I2=carry[4]
XU26 XOR2HS $PINS O=n10 I1=A[5] I2=n42
XU27 XOR2HS $PINS O=DIFF[5] I1=n10 I2=FE_OCPN397_carry_5
XU28 ND2S $PINS O=n11 I1=A[5] I2=n42
XU29 ND2 $PINS O=n12 I1=A[5] I2=carry[5]
XU30 ND2 $PINS O=n13 I1=n42 I2=carry[5]
XU32 ND2 $PINS O=n15 I1=A[27] I2=carry[27]
XU33 ND2 $PINS O=n16 I1=n64 I2=carry[27]
XU35 XOR2HS $PINS O=n17 I1=A[28] I2=n65
XU36 XOR2HS $PINS O=DIFF[28] I1=n17 I2=FE_OCPN343_carry_28
XU37 ND2S $PINS O=n18 I1=A[28] I2=n65
XU38 ND2 $PINS O=n19 I1=A[28] I2=carry[28]
XU39 ND2 $PINS O=n20 I1=n65 I2=carry[28]
XU41 ND2 $PINS O=n22 I1=A[19] I2=carry[19]
XU42 ND2 $PINS O=n23 I1=n56 I2=carry[19]
XU44 XOR2HS $PINS O=n24 I1=A[20] I2=n57
XU45 XOR2HS $PINS O=DIFF[20] I1=n24 I2=FE_OCPN445_carry_20
XU46 ND2S $PINS O=n25 I1=A[20] I2=n57
XU47 ND2 $PINS O=n26 I1=A[20] I2=carry[20]
XU48 ND2 $PINS O=n27 I1=n57 I2=carry[20]
XU50 ND2 $PINS O=n29 I1=A[16] I2=carry[16]
XU51 ND2 $PINS O=n30 I1=n53 I2=carry[16]
XU53 XOR2HS $PINS O=n31 I1=A[17] I2=n54
XU54 XOR2HS $PINS O=DIFF[17] I1=n31 I2=FE_OCPN444_carry_17
XU55 ND2S $PINS O=n32 I1=A[17] I2=n54
XU56 ND2 $PINS O=n33 I1=A[17] I2=carry[17]
XU57 ND2 $PINS O=n34 I1=n54 I2=carry[17]
XU60 XOR2HS $PINS O=n35 I1=n68 I2=A[31]
XU61 INV1S $PINS O=DIFF[0] I=n37
XU62 INV1S $PINS O=n58 I=B[21]
XU63 INV1S $PINS O=n50 I=B[13]
XU64 INV1S $PINS O=n66 I=B[29]
XU65 INV1S $PINS O=n54 I=B[17]
XU66 INV1S $PINS O=n60 I=B[23]
XU67 INV1S $PINS O=n52 I=B[15]
XU70 INV1S $PINS O=n56 I=B[19]
XU71 INV1S $PINS O=n64 I=B[27]
XU72 INV1S $PINS O=n62 I=B[25]
XU73 INV1S $PINS O=n48 I=B[11]
XU75 INV1S $PINS O=n67 I=B[30]
XU76 INV1S $PINS O=n61 I=B[24]
XU77 INV1S $PINS O=n59 I=B[22]
XU78 INV1S $PINS O=n53 I=B[16]
XU79 INV1S $PINS O=n51 I=B[14]
XU82 INV1S $PINS O=n65 I=B[28]
XU83 INV1S $PINS O=n63 I=B[26]
XU84 INV1S $PINS O=n57 I=B[20]
XU85 INV1S $PINS O=n49 I=B[12]
XU86 INV1S $PINS O=n47 I=B[10]
XU88 INV1S $PINS O=n68 I=B[31]
.ENDS

.SUBCKT Domain_Transfer_0_DW_cmp_1 A[32] A[31] A[30] A[29] A[28] A[27] A[26]
+ A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13]
+ A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[32]
+ B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19]
+ B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6]
+ B[5] B[4] B[3] B[2] B[1] B[0] TC GE_LT GE_GT_EQ GE_LT_GT_LE EQ_NE
XFE_RC_2404_0 AO12 $PINS O=n277 A1=n286 B1=n285 B2=n287
XU158 INV1S $PINS O=n241 I=B[18]
XU159 INV1S $PINS O=n256 I=n316
XU160 INV1S $PINS O=n261 I=n295
XU161 INV1S $PINS O=n253 I=n314
XU162 OR2 $PINS O=n340 I1=n338 I2=n229
XU163 AO22S $PINS O=n229 A1=B[1] A2=n249 B1=B[0] B2=n341
XU164 INV1S $PINS O=n247 I=B[29]
XU165 INV1S $PINS O=n238 I=B[13]
XU166 INV1S $PINS O=n234 I=B[5]
XU167 INV1S $PINS O=n233 I=B[3]
XU168 INV1S $PINS O=n235 I=B[7]
XU169 INV1S $PINS O=n239 I=B[15]
XU170 INV1S $PINS O=n248 I=B[31]
XU171 INV1S $PINS O=n237 I=B[11]
XU172 INV1S $PINS O=n236 I=B[9]
XU173 INV1S $PINS O=n245 I=B[25]
XU174 INV1S $PINS O=n246 I=B[27]
XU175 INV1S $PINS O=n244 I=B[23]
XU176 INV1S $PINS O=n242 I=B[19]
XU177 INV1S $PINS O=n243 I=B[21]
XU178 INV1S $PINS O=n240 I=B[17]
XU179 MAOI1 $PINS O=n321 A1=B[14] A2=n230 B1=A[15] B2=n239
XU180 AN2 $PINS O=n230 I1=n324 I2=n258
XU181 MAOI1 $PINS O=n281 A1=B[30] A2=n231 B1=A[31] B2=n248
XU182 AN2 $PINS O=n231 I1=n284 I2=n267
XU183 MAOI1 $PINS O=n304 A1=B[22] A2=n232 B1=A[23] B2=n244
XU184 AN2 $PINS O=n232 I1=n307 I2=n263
XU185 INV1S $PINS O=n258 I=A[14]
XU186 INV1S $PINS O=n254 I=A[8]
XU187 INV1S $PINS O=n264 I=A[24]
XU188 INV1S $PINS O=n255 I=A[10]
XU189 INV1S $PINS O=n265 I=A[26]
XU190 INV1S $PINS O=n250 I=A[2]
XU191 INV1S $PINS O=n249 I=A[1]
XU192 INV1S $PINS O=n257 I=A[12]
XU193 INV1S $PINS O=n262 I=A[20]
XU194 INV1S $PINS O=n260 I=A[18]
XU195 INV1S $PINS O=n259 I=A[16]
XU196 INV1S $PINS O=n266 I=A[28]
XU197 INV1S $PINS O=n267 I=A[30]
XU198 INV1S $PINS O=n263 I=A[22]
XU199 INV1S $PINS O=n251 I=A[4]
XU200 INV1S $PINS O=n252 I=A[6]
XU201 OR2 $PINS O=GE_LT_GT_LE I1=A[32] I2=n268
XU202 AOI13HS $PINS O=n268 A1=n272 B1=n269 B2=n270 B3=n271
XU203 AOI22S $PINS O=n272 A1=n273 A2=n274 B1=n274 B2=n275
XU204 AOI22S $PINS O=n274 A1=n276 A2=n277 B1=n278 B2=n279
XU205 OAI112HS $PINS O=n279 A1=n280 B1=n281 C1=A[29] C2=n247
XU206 ND3 $PINS O=n280 I1=n282 I2=n266 I3=B[28]
XU207 OR2B1S $PINS O=n278 I1=n283 B1=n281
XU209 MOAI1S $PINS O=n287 A1=A[25] A2=n245 B1=B[24] B2=n288
XU210 AN2 $PINS O=n288 I1=n289 I2=n264
XU211 MOAI1S $PINS O=n286 A1=A[27] A2=n246 B1=B[26] B2=n290
XU212 AN2 $PINS O=n290 I1=n291 I2=n265
XU213 AOI22S $PINS O=n273 A1=n292 A2=n293 B1=n294 B2=n261
XU214 AOI22S $PINS O=n294 A1=n296 A2=n297 B1=n297 B2=n298
XU215 OA22 $PINS O=n297 A1=A[19] A2=n242 B1=n241 B2=n299
XU216 ND2 $PINS O=n299 I1=n300 I2=n260
XU217 AOI13HS $PINS O=n296 A1=n302 B1=n301 B2=n259 B3=B[16]
XU218 NR2 $PINS O=n302 I1=A[17] I2=n240
XU219 OAI112HS $PINS O=n293 A1=n303 B1=n304 C1=A[21] C2=n243
XU220 ND3 $PINS O=n303 I1=n305 I2=n262 I3=B[20]
XU221 OR2B1S $PINS O=n292 I1=n306 B1=n304
XU222 NR3 $PINS O=n271 I1=n298 I2=n295 I3=n275
XU223 ND3 $PINS O=n275 I1=n285 I2=n276 I3=n308
XU224 OA12 $PINS O=n308 A1=n289 B1=B[24] B2=n264
XU225 ND2 $PINS O=n289 I1=A[25] I2=n245
XU226 OA112 $PINS O=n276 A1=n282 B1=n283 C1=B[28] C2=n266
XU227 OA12 $PINS O=n283 A1=n284 B1=B[30] B2=n267
XU228 ND2 $PINS O=n284 I1=A[31] I2=n248
XU229 ND2 $PINS O=n282 I1=A[29] I2=n247
XU230 OA12 $PINS O=n285 A1=n291 B1=B[26] B2=n265
XU231 ND2 $PINS O=n291 I1=A[27] I2=n246
XU232 OAI112HS $PINS O=n295 A1=n305 B1=n306 C1=B[20] C2=n262
XU233 OA12 $PINS O=n306 A1=n307 B1=B[22] B2=n263
XU234 ND2 $PINS O=n307 I1=A[23] I2=n244
XU235 ND2 $PINS O=n305 I1=A[21] I2=n243
XU236 OAI12HS $PINS O=n298 A1=n300 B1=B[18] B2=n260
XU237 ND2 $PINS O=n300 I1=A[19] I2=n242
XU238 OA12 $PINS O=n270 A1=n301 B1=B[16] B2=n259
XU239 ND2 $PINS O=n301 I1=A[17] I2=n240
XU240 AOI13HS $PINS O=n269 A1=n311 B1=n309 B2=n310 B3=n253
XU241 AOI13HS $PINS O=n311 A1=n314 B1=n312 B2=n256 B3=n313
XU242 OA12 $PINS O=n313 A1=n315 B1=B[8] B2=n254
XU243 MOAI1S $PINS O=n314 A1=n316 A2=n317 B1=n318 B2=n319
XU244 OAI112HS $PINS O=n319 A1=n320 B1=n321 C1=A[13] C2=n238
XU245 ND3 $PINS O=n320 I1=n322 I2=n257 I3=B[12]
XU246 OR2B1S $PINS O=n318 I1=n323 B1=n321
XU247 OAI22S $PINS O=n317 A1=n312 A2=n325 B1=n325 B2=n326
XU248 MOAI1S $PINS O=n326 A1=A[9] A2=n236 B1=B[8] B2=n327
XU249 AN2 $PINS O=n327 I1=n315 I2=n254
XU250 ND2 $PINS O=n315 I1=A[9] I2=n236
XU251 MOAI1S $PINS O=n325 A1=A[11] A2=n237 B1=B[10] B2=n328
XU252 AN2 $PINS O=n328 I1=n329 I2=n255
XU253 OA12 $PINS O=n312 A1=n329 B1=B[10] B2=n255
XU254 ND2 $PINS O=n329 I1=A[11] I2=n237
XU255 OAI112HS $PINS O=n316 A1=n322 B1=n323 C1=B[12] C2=n257
XU256 OA12 $PINS O=n323 A1=n324 B1=B[14] B2=n258
XU257 ND2 $PINS O=n324 I1=A[15] I2=n239
XU258 ND2 $PINS O=n322 I1=A[13] I2=n238
XU259 OAI22S $PINS O=n310 A1=n330 A2=n331 B1=n331 B2=n332
XU260 MOAI1S $PINS O=n332 A1=A[5] A2=n234 B1=B[4] B2=n333
XU261 AN2 $PINS O=n333 I1=n334 I2=n251
XU262 MOAI1S $PINS O=n331 A1=A[7] A2=n235 B1=B[6] B2=n335
XU263 AN2 $PINS O=n335 I1=n336 I2=n252
XU264 OAI112HS $PINS O=n309 A1=n330 B1=n339 C1=n337 C2=n338
XU265 OA112 $PINS O=n339 A1=n334 B1=n340 C1=B[4] C2=n251
XU266 OR2 $PINS O=n341 I1=n249 I2=B[1]
XU267 ND2 $PINS O=n334 I1=A[5] I2=n234
XU268 OA12 $PINS O=n330 A1=n336 B1=B[6] B2=n252
XU269 ND2 $PINS O=n336 I1=A[7] I2=n235
XU270 MOAI1S $PINS O=n338 A1=A[3] A2=n233 B1=B[2] B2=n342
XU271 AN2 $PINS O=n342 I1=n343 I2=n250
XU272 OA12 $PINS O=n337 A1=n343 B1=B[2] B2=n250
XU273 ND2 $PINS O=n343 I1=A[3] I2=n233
.ENDS

.SUBCKT Domain_Transfer_0_DW01_sub_2 A[31] A[30] A[29] A[28] A[27] A[26] A[25]
+ A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12]
+ A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] CI DIFF[31] DIFF[30] DIFF[29] DIFF[28] DIFF[27] DIFF[26]
+ DIFF[25] DIFF[24] DIFF[23] DIFF[22] DIFF[21] DIFF[20] DIFF[19] DIFF[18]
+ DIFF[17] DIFF[16] DIFF[15] DIFF[14] DIFF[13] DIFF[12] DIFF[11] DIFF[10]
+ DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3] DIFF[2] DIFF[1]
+ DIFF[0] CO
XFE_RC_2387_0 XNR2HS $PINS O=FE_RN_1094_0 I1=A[5] I2=n44
XFE_RC_2385_0 XNR2HS $PINS O=FE_RN_1260_0 I1=A[2] I2=B[2]
XFE_RC_2356_0 ND3P $PINS O=carry[5] I1=n14 I2=n15 I3=n13
XFE_OFC648_FE_OFN87_n312 INV1S $PINS O=n40 I=B[1]
XFE_OFC618_n310 INV2 $PINS O=n39 I=B[0]
XFE_RC_2310_0 XOR3 $PINS O=DIFF[12] I1=A[12] I2=n51 I3=carry[12]
XFE_RC_2309_0 MAO222 $PINS O=carry[13] A1=A[12] B1=n51 C1=carry[12]
XFE_RC_2253_0 ND2S $PINS O=FE_RN_1543_0 I1=A[13] I2=n52
XFE_RC_2252_0 AN2S $PINS O=FE_RN_1544_0 I1=FE_RN_1547_0 I2=FE_RN_1543_0
XFE_RC_2251_0 XNR2HS $PINS O=FE_RN_1545_0 I1=n52 I2=A[13]
XFE_RC_2250_0 MXL2HS $PINS OB=DIFF[13] S=carry[13] A=FE_RN_1545_0
+ B=FE_RN_1544_0
XFE_RC_2249_0 ND2S $PINS O=FE_RN_1546_0 I1=A[13] I2=n52
XFE_RC_2248_0 OR2S $PINS O=FE_RN_1547_0 I1=n52 I2=A[13]
XFE_RC_2247_0 ND2 $PINS O=FE_RN_1548_0 I1=FE_RN_1547_0 I2=carry[13]
XFE_RC_2246_0 ND2P $PINS O=carry[14] I1=FE_RN_1548_0 I2=FE_RN_1546_0
XFE_RC_2043_0 ND2 $PINS O=FE_RN_1387_0 I1=A[14] I2=n53
XFE_RC_2042_0 AN2S $PINS O=FE_RN_1388_0 I1=FE_RN_1391_0 I2=FE_RN_1387_0
XFE_RC_2041_0 XNR2HS $PINS O=FE_RN_1389_0 I1=n53 I2=A[14]
XFE_RC_2040_0 MXL2HS $PINS OB=DIFF[14] S=carry[14] A=FE_RN_1389_0
+ B=FE_RN_1388_0
XFE_RC_2039_0 ND2 $PINS O=FE_RN_1390_0 I1=A[14] I2=n53
XFE_RC_2038_0 OR2 $PINS O=FE_RN_1391_0 I1=n53 I2=A[14]
XFE_RC_2037_0 ND2 $PINS O=FE_RN_1392_0 I1=FE_RN_1391_0 I2=carry[14]
XFE_RC_2036_0 ND2P $PINS O=carry[15] I1=FE_RN_1392_0 I2=FE_RN_1390_0
XFE_RC_1873_0 ND2 $PINS O=FE_RN_1261_0 I1=A[2] I2=B[2]
XFE_RC_1872_0 ND2 $PINS O=FE_RN_1262_0 I1=FE_RN_1261_0 I2=FE_RN_1266_0
XFE_RC_1871_0 ND2 $PINS O=FE_RN_1263_0 I1=FE_RN_1262_0 I2=carry[2]
XFE_RC_1870_0 OAI12HS $PINS O=DIFF[2] A1=FE_RN_1263_0 B1=FE_RN_1260_0
+ B2=carry[2]
XFE_RC_1869_0 ND2 $PINS O=FE_RN_1264_0 I1=A[2] I2=B[2]
XFE_RC_1868_0 INV1S $PINS O=FE_RN_1265_0 I=A[2]
XFE_RC_1867_0 OR2B1S $PINS O=FE_RN_1266_0 I1=B[2] B1=FE_RN_1265_0
XFE_RC_1866_0 ND2 $PINS O=FE_RN_1267_0 I1=FE_RN_1266_0 I2=carry[2]
XFE_RC_1865_0 ND2P $PINS O=carry[3] I1=FE_RN_1267_0 I2=FE_RN_1264_0
XFE_RC_1650_0 AN2 $PINS O=FE_RN_1090_0 I1=A[5] I2=n44
XFE_RC_1649_0 AN2B1S $PINS O=FE_RN_1091_0 I1=FE_RN_1096_0 B1=FE_RN_1090_0
XFE_RC_1645_0 MXL2HS $PINS OB=DIFF[5] S=carry[5] A=FE_RN_1094_0 B=FE_RN_1091_0
XFE_RC_1644_0 ND2 $PINS O=FE_RN_1095_0 I1=A[5] I2=n44
XFE_RC_1643_0 OR2 $PINS O=FE_RN_1096_0 I1=n44 I2=A[5]
XFE_RC_1642_0 ND2 $PINS O=FE_RN_1097_0 I1=FE_RN_1096_0 I2=carry[5]
XFE_RC_1641_0 ND2P $PINS O=carry[6] I1=FE_RN_1097_0 I2=FE_RN_1095_0
XFE_RC_1424_0 MOAI1 $PINS O=carry[27] A1=FE_RN_778_0 A2=FE_RN_775_0 B1=n65
+ B2=A[26]
XFE_RC_1412_0 ND2S $PINS O=FE_RN_915_0 I1=A[6] I2=n45
XFE_RC_1411_0 AN2 $PINS O=FE_RN_916_0 I1=FE_RN_919_0 I2=FE_RN_915_0
XFE_RC_1410_0 XNR2HS $PINS O=FE_RN_917_0 I1=n45 I2=A[6]
XFE_RC_1409_0 MXL2HS $PINS OB=DIFF[6] S=carry[6] A=FE_RN_917_0 B=FE_RN_916_0
XFE_RC_1407_0 OR2 $PINS O=FE_RN_919_0 I1=n45 I2=A[6]
XFE_RC_1406_0 ND2 $PINS O=FE_RN_920_0 I1=FE_RN_919_0 I2=carry[6]
XFE_RC_1405_0 ND2P $PINS O=carry[7] I1=FE_RN_920_0 I2=FE_RN_915_0
XFE_RC_1219_0 INV1S $PINS O=FE_RN_775_0 I=FE_RN_779_0
XFE_RC_1218_0 AOI12HS $PINS O=FE_RN_776_0 A1=FE_RN_775_0 B1=A[26] B2=n65
XFE_RC_1217_0 XNR2HS $PINS O=FE_RN_777_0 I1=n65 I2=A[26]
XFE_RC_1216_0 MXL2HS $PINS OB=DIFF[26] S=carry[26] A=FE_RN_777_0 B=FE_RN_776_0
XFE_RC_1215_0 INV1S $PINS O=FE_RN_778_0 I=carry[26]
XFE_RC_1214_0 OR2S $PINS O=FE_RN_779_0 I1=n65 I2=A[26]
XFE_RC_1002_0 ND2 $PINS O=FE_RN_620_0 I1=A[27] I2=n66
XFE_RC_1001_0 AN2 $PINS O=FE_RN_621_0 I1=FE_RN_624_0 I2=FE_RN_620_0
XFE_RC_1000_0 XNR2HS $PINS O=FE_RN_622_0 I1=n66 I2=A[27]
XFE_RC_999_0 MXL2HS $PINS OB=DIFF[27] S=carry[27] A=FE_RN_622_0 B=FE_RN_621_0
XFE_RC_998_0 ND2 $PINS O=FE_RN_623_0 I1=A[27] I2=n66
XFE_RC_997_0 OR2S $PINS O=FE_RN_624_0 I1=n66 I2=A[27]
XFE_RC_996_0 ND2 $PINS O=FE_RN_625_0 I1=FE_RN_624_0 I2=carry[27]
XFE_RC_995_0 ND2P $PINS O=carry[28] I1=FE_RN_625_0 I2=FE_RN_623_0
XFE_RC_845_0 ND2S $PINS O=FE_RN_502_0 I1=A[15] I2=n54
XFE_RC_844_0 AN2 $PINS O=FE_RN_503_0 I1=FE_RN_506_0 I2=FE_RN_502_0
XFE_RC_843_0 XNR2HS $PINS O=FE_RN_504_0 I1=n54 I2=A[15]
XFE_RC_842_0 MXL2HS $PINS OB=DIFF[15] S=carry[15] A=FE_RN_504_0 B=FE_RN_503_0
XFE_RC_841_0 ND2S $PINS O=FE_RN_505_0 I1=A[15] I2=n54
XFE_RC_840_0 OR2 $PINS O=FE_RN_506_0 I1=n54 I2=A[15]
XFE_RC_839_0 ND2 $PINS O=FE_RN_507_0 I1=FE_RN_506_0 I2=carry[15]
XFE_RC_838_0 ND2P $PINS O=carry[16] I1=FE_RN_507_0 I2=FE_RN_505_0
XFE_RC_667_0 ND2 $PINS O=FE_RN_375_0 I1=A[28] I2=n67
XFE_RC_666_0 AN2 $PINS O=FE_RN_376_0 I1=FE_RN_379_0 I2=FE_RN_375_0
XFE_RC_665_0 XNR2HS $PINS O=FE_RN_377_0 I1=n67 I2=A[28]
XFE_RC_664_0 MXL2HS $PINS OB=DIFF[28] S=carry[28] A=FE_RN_377_0 B=FE_RN_376_0
XFE_RC_663_0 ND2 $PINS O=FE_RN_378_0 I1=A[28] I2=n67
XFE_RC_662_0 OR2S $PINS O=FE_RN_379_0 I1=n67 I2=A[28]
XFE_RC_661_0 ND2 $PINS O=FE_RN_380_0 I1=FE_RN_379_0 I2=carry[28]
XFE_RC_660_0 ND2P $PINS O=carry[29] I1=FE_RN_380_0 I2=FE_RN_378_0
XFE_RC_571_0 OR2 $PINS O=FE_RN_310_0 I1=FE_RN_250_0 I2=FE_RN_246_0
XFE_RC_570_0 ND2P $PINS O=carry[19] I1=FE_RN_252_0 I2=FE_RN_310_0
XFE_RC_486_0 INV1S $PINS O=FE_RN_244_0 I=FE_RN_251_0
XFE_RC_485_0 AOI12HS $PINS O=FE_RN_245_0 A1=FE_RN_244_0 B1=A[18] B2=n57
XFE_RC_484_0 INV1S $PINS O=FE_RN_246_0 I=n57
XFE_RC_483_0 INV1S $PINS O=FE_RN_247_0 I=A[18]
XFE_RC_482_0 AOI22S $PINS O=FE_RN_248_0 A1=FE_RN_247_0 A2=n57 B1=A[18]
+ B2=FE_RN_246_0
XFE_RC_481_0 MXL2HS $PINS OB=DIFF[18] S=carry[18] A=FE_RN_248_0 B=FE_RN_245_0
XFE_RC_479_0 INV1S $PINS O=FE_RN_250_0 I=A[18]
XFE_RC_478_0 OR2S $PINS O=FE_RN_251_0 I1=n57 I2=A[18]
XFE_RC_477_0 ND2 $PINS O=FE_RN_252_0 I1=FE_RN_251_0 I2=carry[18]
XFE_RC_272_0 ND2S $PINS O=FE_RN_112_0 I1=A[7] I2=n46
XFE_RC_271_0 AN2 $PINS O=FE_RN_113_0 I1=FE_RN_116_0 I2=FE_RN_112_0
XFE_RC_270_0 XNR2HS $PINS O=FE_RN_114_0 I1=n46 I2=A[7]
XFE_RC_269_0 MXL2HS $PINS OB=DIFF[7] S=carry[7] A=FE_RN_114_0 B=FE_RN_113_0
XFE_RC_268_0 ND2S $PINS O=FE_RN_115_0 I1=A[7] I2=n46
XFE_RC_267_0 OR2 $PINS O=FE_RN_116_0 I1=n46 I2=A[7]
XFE_RC_266_0 ND2 $PINS O=FE_RN_117_0 I1=FE_RN_116_0 I2=carry[7]
XFE_RC_265_0 ND2P $PINS O=carry[8] I1=FE_RN_117_0 I2=FE_RN_115_0
XFE_RC_139_0 ND3P $PINS O=carry[4] I1=n11 I2=n10 I3=n9
XFE_RC_138_0 ND3 $PINS O=carry[10] I1=n22 I2=n21 I3=n20
XFE_RC_133_0 XOR3 $PINS O=DIFF[29] I1=A[29] I2=n68 I3=carry[29]
XFE_RC_132_0 MAO222P $PINS O=carry[30] A1=A[29] B1=n68 C1=carry[29]
XFE_RC_102_0 ND3P $PINS O=carry[22] I1=n33 I2=n32 I3=n31
XFE_RC_45_0 INV1S $PINS O=FE_RN_19_0 I=n37
XFE_RC_44_0 MXL2HS $PINS OB=DIFF[31] S=carry[31] A=FE_RN_19_0 B=n37
XFE_RC_43_0 ND3P $PINS O=carry[17] I1=n35 I2=n34 I3=n36
XFE_RC_42_0 ND3P $PINS O=carry[9] I1=n18 I2=n17 I3=n16
XFE_OFC281_raw_prime_3 INV1S $PINS O=n42 I=B[3]
XFE_OFC222_raw_prime_5 INV1S $PINS O=n44 I=B[5]
XFE_OFC199_raw_prime_9 INV1S $PINS O=n48 I=B[9]
XFE_OFC175_raw_prime_10 INV1S $PINS O=n49 I=B[10]
XFE_OFC172_raw_prime_7 INV1S $PINS O=n46 I=B[7]
XFE_OFC152_raw_prime_6 INV1S $PINS O=n45 I=B[6]
XFE_OFC99_raw_prime_4 INV1S $PINS O=n43 I=B[4]
XU2_25 FA1 $PINS S=DIFF[25] CO=carry[26] A=A[25] B=n64 CI=carry[25]
XU2_24 FA1 $PINS S=DIFF[24] CO=carry[25] A=A[24] B=n63 CI=carry[24]
XU2_23 FA1 $PINS S=DIFF[23] CO=carry[24] A=A[23] B=n62 CI=carry[23]
XU2_22 FA1 $PINS S=DIFF[22] CO=carry[23] A=A[22] B=n61 CI=carry[22]
XU2_11 FA1 $PINS S=DIFF[11] CO=carry[12] A=A[11] B=n50 CI=carry[11]
XU2_10 FA1 $PINS S=DIFF[10] CO=carry[11] A=A[10] B=n49 CI=carry[10]
XU2_1 FA1 $PINS S=DIFF[1] CO=carry[2] A=A[1] B=n40 CI=n39
XU1 ND2 $PINS O=n27 I1=A[20] I2=n59
XU2 ND2P $PINS O=carry[21] I1=n29 I2=n5
XU3 INV2CK $PINS O=n5 I=n4
XU4 XOR3 $PINS O=DIFF[19] I1=n58 I2=A[19] I3=carry[19]
XU5 ND2 $PINS O=n1 I1=carry[19] I2=n58
XU6 ND2 $PINS O=n2 I1=carry[19] I2=A[19]
XU7 ND2 $PINS O=n3 I1=n58 I2=A[19]
XU8 ND3P $PINS O=carry[20] I1=n1 I2=n2 I3=n3
XU9 ND2 $PINS O=n28 I1=A[20] I2=carry[20]
XU10 ND2P $PINS O=n4 I1=n28 I2=n27
XU11 ND2 $PINS O=n9 I1=A[3] I2=n42
XU12 ND2 $PINS O=n16 I1=A[8] I2=B[8]
XU13 INV1S $PINS O=n55 I=B[16]
XU14 INV1S $PINS O=n69 I=B[30]
XU15 INV1S $PINS O=n70 I=B[31]
XU16 XOR3 $PINS O=DIFF[20] I1=A[20] I2=n59 I3=carry[20]
XU18 XOR3 $PINS O=DIFF[3] I1=A[3] I2=n42 I3=carry[3]
XU19 XOR3 $PINS O=DIFF[8] I1=A[8] I2=B[8] I3=carry[8]
XU21 XOR3 $PINS O=DIFF[16] I1=n55 I2=A[16] I3=carry[16]
XU23 XOR3 $PINS O=DIFF[17] I1=n56 I2=A[17] I3=carry[17]
XU24 ND2 $PINS O=n6 I1=carry[17] I2=n56
XU25 ND2 $PINS O=n7 I1=carry[17] I2=A[17]
XU26 ND2 $PINS O=n8 I1=n56 I2=A[17]
XU27 ND3P $PINS O=carry[18] I1=n6 I2=n7 I3=n8
XU30 ND2 $PINS O=n10 I1=A[3] I2=carry[3]
XU31 ND2 $PINS O=n11 I1=n42 I2=carry[3]
XU33 XOR2HS $PINS O=n12 I1=A[4] I2=n43
XU34 XOR2HS $PINS O=DIFF[4] I1=n12 I2=carry[4]
XU35 ND2S $PINS O=n13 I1=A[4] I2=n43
XU36 ND2 $PINS O=n14 I1=A[4] I2=carry[4]
XU37 ND2 $PINS O=n15 I1=n43 I2=carry[4]
XU38 ND2 $PINS O=n17 I1=carry[8] I2=A[8]
XU39 ND2 $PINS O=n18 I1=B[8] I2=carry[8]
XU41 XOR2HS $PINS O=n19 I1=A[9] I2=n48
XU42 XOR2HS $PINS O=DIFF[9] I1=n19 I2=carry[9]
XU43 ND2S $PINS O=n20 I1=A[9] I2=n48
XU44 ND2 $PINS O=n21 I1=A[9] I2=carry[9]
XU45 ND2 $PINS O=n22 I1=n48 I2=carry[9]
XU46 XOR2HS $PINS O=n23 I1=n69 I2=A[30]
XU47 XOR2HS $PINS O=DIFF[30] I1=carry[30] I2=n23
XU48 ND2 $PINS O=n24 I1=carry[30] I2=n69
XU49 ND2 $PINS O=n25 I1=carry[30] I2=A[30]
XU50 ND2S $PINS O=n26 I1=n69 I2=A[30]
XU51 ND3P $PINS O=carry[31] I1=n24 I2=n25 I3=n26
XU52 ND2 $PINS O=n29 I1=n59 I2=carry[20]
XU53 XOR2HS $PINS O=n30 I1=A[21] I2=n60
XU54 XOR2HS $PINS O=DIFF[21] I1=n30 I2=carry[21]
XU55 ND2S $PINS O=n31 I1=A[21] I2=n60
XU56 ND2 $PINS O=n32 I1=A[21] I2=carry[21]
XU57 ND2 $PINS O=n33 I1=n60 I2=carry[21]
XU59 ND2 $PINS O=n34 I1=carry[16] I2=n55
XU60 ND2 $PINS O=n35 I1=carry[16] I2=A[16]
XU61 ND2S $PINS O=n36 I1=n55 I2=A[16]
XU62 XOR2HS $PINS O=n37 I1=n70 I2=A[31]
XU65 INV1S $PINS O=n68 I=B[29]
XU66 INV1S $PINS O=n60 I=B[21]
XU67 INV1S $PINS O=n52 I=B[13]
XU68 INV1S $PINS O=n56 I=B[17]
XU69 INV1S $PINS O=n62 I=B[23]
XU70 INV1S $PINS O=n54 I=B[15]
XU73 INV1S $PINS O=n58 I=B[19]
XU74 INV1S $PINS O=n66 I=B[27]
XU75 INV1S $PINS O=n64 I=B[25]
XU76 INV1S $PINS O=n50 I=B[11]
XU79 INV1S $PINS O=n63 I=B[24]
XU80 INV1S $PINS O=n61 I=B[22]
XU81 INV1S $PINS O=n53 I=B[14]
XU84 INV1S $PINS O=n67 I=B[28]
XU85 INV1S $PINS O=n65 I=B[26]
XU86 INV1S $PINS O=n59 I=B[20]
XU87 INV1S $PINS O=n57 I=B[18]
XU88 INV1S $PINS O=n51 I=B[12]
.ENDS

.SUBCKT Domain_Transfer_0_DW_cmp_2 A[32] A[31] A[30] A[29] A[28] A[27] A[26]
+ A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13]
+ A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[32]
+ B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19]
+ B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6]
+ B[5] B[4] B[3] B[2] B[1] B[0] TC GE_LT GE_GT_EQ GE_LT_GT_LE EQ_NE
XFE_RC_2405_0 AO12 $PINS O=n277 A1=n286 B1=n285 B2=n287
XFE_OFC622_raw_prime_2 INV1S $PINS O=FE_OFN647_raw_prime_2 I=B[2]
XU158 INV1S $PINS O=n241 I=B[18]
XU159 INV1S $PINS O=n256 I=n316
XU160 INV1S $PINS O=n261 I=n295
XU161 INV1S $PINS O=n253 I=n314
XU162 OR2 $PINS O=n340 I1=n338 I2=n229
XU163 AO22S $PINS O=n229 A1=B[1] A2=n249 B1=B[0] B2=n341
XU164 INV1S $PINS O=n238 I=B[13]
XU165 INV1S $PINS O=n234 I=B[5]
XU166 INV1S $PINS O=n233 I=B[3]
XU167 INV1S $PINS O=n235 I=B[7]
XU168 INV1S $PINS O=n239 I=B[15]
XU169 INV1S $PINS O=n248 I=B[31]
XU170 INV1S $PINS O=n237 I=B[11]
XU171 INV1S $PINS O=n236 I=B[9]
XU172 INV1S $PINS O=n245 I=B[25]
XU173 INV1S $PINS O=n246 I=B[27]
XU174 INV1S $PINS O=n244 I=B[23]
XU175 INV1S $PINS O=n242 I=B[19]
XU176 INV1S $PINS O=n247 I=B[29]
XU177 INV1S $PINS O=n243 I=B[21]
XU178 INV1S $PINS O=n240 I=B[17]
XU179 MAOI1 $PINS O=n304 A1=B[22] A2=n230 B1=A[23] B2=n244
XU180 AN2 $PINS O=n230 I1=n307 I2=n263
XU181 MAOI1 $PINS O=n281 A1=B[30] A2=n231 B1=A[31] B2=n248
XU182 AN2 $PINS O=n231 I1=n284 I2=n267
XU183 MAOI1 $PINS O=n321 A1=B[14] A2=n232 B1=A[15] B2=n239
XU184 AN2 $PINS O=n232 I1=n324 I2=n258
XU185 INV1S $PINS O=n258 I=A[14]
XU186 INV1S $PINS O=n254 I=A[8]
XU187 INV1S $PINS O=n264 I=A[24]
XU188 INV1S $PINS O=n255 I=A[10]
XU189 INV1S $PINS O=n265 I=A[26]
XU190 INV1S $PINS O=n250 I=A[2]
XU191 INV1S $PINS O=n249 I=A[1]
XU192 INV1S $PINS O=n257 I=A[12]
XU193 INV1S $PINS O=n262 I=A[20]
XU194 INV1S $PINS O=n260 I=A[18]
XU195 INV1S $PINS O=n259 I=A[16]
XU196 INV1S $PINS O=n266 I=A[28]
XU197 INV1S $PINS O=n267 I=A[30]
XU198 INV1S $PINS O=n263 I=A[22]
XU199 INV1S $PINS O=n251 I=A[4]
XU200 INV1S $PINS O=n252 I=A[6]
XU201 OR2 $PINS O=GE_LT_GT_LE I1=A[32] I2=n268
XU202 AOI13HS $PINS O=n268 A1=n272 B1=n269 B2=n270 B3=n271
XU203 AOI22S $PINS O=n272 A1=n273 A2=n274 B1=n274 B2=n275
XU204 AOI22S $PINS O=n274 A1=n276 A2=n277 B1=n278 B2=n279
XU205 OAI112HS $PINS O=n279 A1=n280 B1=n281 C1=A[29] C2=n247
XU206 ND3 $PINS O=n280 I1=n282 I2=n266 I3=B[28]
XU207 OR2B1S $PINS O=n278 I1=n283 B1=n281
XU209 MOAI1S $PINS O=n287 A1=A[25] A2=n245 B1=B[24] B2=n288
XU210 AN2 $PINS O=n288 I1=n289 I2=n264
XU211 MOAI1S $PINS O=n286 A1=A[27] A2=n246 B1=B[26] B2=n290
XU212 AN2 $PINS O=n290 I1=n291 I2=n265
XU213 AOI22S $PINS O=n273 A1=n292 A2=n293 B1=n294 B2=n261
XU214 AOI22S $PINS O=n294 A1=n296 A2=n297 B1=n297 B2=n298
XU215 OA22 $PINS O=n297 A1=A[19] A2=n242 B1=n241 B2=n299
XU216 ND2 $PINS O=n299 I1=n300 I2=n260
XU217 AOI13HS $PINS O=n296 A1=n302 B1=n301 B2=n259 B3=B[16]
XU218 NR2 $PINS O=n302 I1=A[17] I2=n240
XU219 OAI112HS $PINS O=n293 A1=n303 B1=n304 C1=A[21] C2=n243
XU220 ND3 $PINS O=n303 I1=n305 I2=n262 I3=B[20]
XU221 OR2B1S $PINS O=n292 I1=n306 B1=n304
XU222 NR3 $PINS O=n271 I1=n298 I2=n295 I3=n275
XU223 ND3 $PINS O=n275 I1=n285 I2=n276 I3=n308
XU224 OA12 $PINS O=n308 A1=n289 B1=B[24] B2=n264
XU225 ND2 $PINS O=n289 I1=A[25] I2=n245
XU226 OA112 $PINS O=n276 A1=n282 B1=n283 C1=B[28] C2=n266
XU227 OA12 $PINS O=n283 A1=n284 B1=B[30] B2=n267
XU228 ND2 $PINS O=n284 I1=A[31] I2=n248
XU229 ND2 $PINS O=n282 I1=A[29] I2=n247
XU230 OA12 $PINS O=n285 A1=n291 B1=B[26] B2=n265
XU231 ND2 $PINS O=n291 I1=A[27] I2=n246
XU232 OAI112HS $PINS O=n295 A1=n305 B1=n306 C1=B[20] C2=n262
XU233 OA12 $PINS O=n306 A1=n307 B1=B[22] B2=n263
XU234 ND2 $PINS O=n307 I1=A[23] I2=n244
XU235 ND2 $PINS O=n305 I1=A[21] I2=n243
XU236 OAI12HS $PINS O=n298 A1=n300 B1=B[18] B2=n260
XU237 ND2 $PINS O=n300 I1=A[19] I2=n242
XU238 OA12 $PINS O=n270 A1=n301 B1=B[16] B2=n259
XU239 ND2 $PINS O=n301 I1=A[17] I2=n240
XU240 AOI13HS $PINS O=n269 A1=n311 B1=n309 B2=n310 B3=n253
XU241 AOI13HS $PINS O=n311 A1=n314 B1=n312 B2=n256 B3=n313
XU242 OA12 $PINS O=n313 A1=n315 B1=B[8] B2=n254
XU243 MOAI1S $PINS O=n314 A1=n316 A2=n317 B1=n318 B2=n319
XU244 OAI112HS $PINS O=n319 A1=n320 B1=n321 C1=A[13] C2=n238
XU245 ND3 $PINS O=n320 I1=n322 I2=n257 I3=B[12]
XU246 OR2B1S $PINS O=n318 I1=n323 B1=n321
XU247 OAI22S $PINS O=n317 A1=n312 A2=n325 B1=n325 B2=n326
XU248 MOAI1S $PINS O=n326 A1=A[9] A2=n236 B1=B[8] B2=n327
XU249 AN2 $PINS O=n327 I1=n315 I2=n254
XU250 ND2 $PINS O=n315 I1=A[9] I2=n236
XU251 MOAI1S $PINS O=n325 A1=A[11] A2=n237 B1=B[10] B2=n328
XU252 AN2 $PINS O=n328 I1=n329 I2=n255
XU253 OA12 $PINS O=n312 A1=n329 B1=B[10] B2=n255
XU254 ND2 $PINS O=n329 I1=A[11] I2=n237
XU255 OAI112HS $PINS O=n316 A1=n322 B1=n323 C1=B[12] C2=n257
XU256 OA12 $PINS O=n323 A1=n324 B1=B[14] B2=n258
XU257 ND2 $PINS O=n324 I1=A[15] I2=n239
XU258 ND2 $PINS O=n322 I1=A[13] I2=n238
XU259 OAI22S $PINS O=n310 A1=n330 A2=n331 B1=n331 B2=n332
XU260 MOAI1S $PINS O=n332 A1=A[5] A2=n234 B1=B[4] B2=n333
XU261 AN2 $PINS O=n333 I1=n334 I2=n251
XU262 MOAI1S $PINS O=n331 A1=A[7] A2=n235 B1=B[6] B2=n335
XU263 AN2 $PINS O=n335 I1=n336 I2=n252
XU264 OAI112HS $PINS O=n309 A1=n330 B1=n339 C1=n337 C2=n338
XU265 OA112 $PINS O=n339 A1=n334 B1=n340 C1=B[4] C2=n251
XU266 OR2 $PINS O=n341 I1=n249 I2=B[1]
XU267 ND2 $PINS O=n334 I1=A[5] I2=n234
XU268 OA12 $PINS O=n330 A1=n336 B1=B[6] B2=n252
XU269 ND2 $PINS O=n336 I1=A[7] I2=n235
XU270 MOAI1S $PINS O=n338 A1=A[3] A2=n233 B1=FE_OFN647_raw_prime_2 B2=n342
XU271 AN2 $PINS O=n342 I1=n343 I2=n250
XU272 OA12 $PINS O=n337 A1=n343 B1=FE_OFN647_raw_prime_2 B2=n250
XU273 ND2 $PINS O=n343 I1=A[3] I2=n233
.ENDS

.SUBCKT Domain_Transfer_0_DW01_sub_3 A[31] A[30] A[29] A[28] A[27] A[26] A[25]
+ A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12]
+ A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] CI DIFF[31] DIFF[30] DIFF[29] DIFF[28] DIFF[27] DIFF[26]
+ DIFF[25] DIFF[24] DIFF[23] DIFF[22] DIFF[21] DIFF[20] DIFF[19] DIFF[18]
+ DIFF[17] DIFF[16] DIFF[15] DIFF[14] DIFF[13] DIFF[12] DIFF[11] DIFF[10]
+ DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3] DIFF[2] DIFF[1]
+ DIFF[0] CO
.ENDS

.SUBCKT Domain_Transfer_0_DW_cmp_3 A[31] A[30] A[29] A[28] A[27] A[26] A[25]
+ A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12]
+ A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] TC GE_LT GE_GT_EQ GE_LT_GT_LE EQ_NE
.ENDS

.SUBCKT Domain_Transfer_0_DW01_sub_4 A[31] A[30] A[29] A[28] A[27] A[26] A[25]
+ A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12]
+ A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] CI DIFF[31] DIFF[30] DIFF[29] DIFF[28] DIFF[27] DIFF[26]
+ DIFF[25] DIFF[24] DIFF[23] DIFF[22] DIFF[21] DIFF[20] DIFF[19] DIFF[18]
+ DIFF[17] DIFF[16] DIFF[15] DIFF[14] DIFF[13] DIFF[12] DIFF[11] DIFF[10]
+ DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3] DIFF[2] DIFF[1]
+ DIFF[0] CO p1 n466 p2
XFE_OFC647_FE_OFN87_n312 INV2 $PINS O=n52 I=B[1]
XFE_RC_2307_0 XOR3 $PINS O=DIFF[4] I1=A[4] I2=n55 I3=carry[4]
XFE_RC_2306_0 MAO222 $PINS O=carry[5] A1=A[4] B1=n55 C1=carry[4]
XFE_RC_2279_0 ND3P $PINS O=carry[2] I1=n4 I2=n5 I3=n6
XFE_RC_2080_0 ND2 $PINS O=FE_RN_1414_0 I1=A[20] I2=n71
XFE_RC_2079_0 AN2 $PINS O=FE_RN_1415_0 I1=FE_RN_1418_0 I2=FE_RN_1414_0
XFE_RC_2078_0 XNR2HS $PINS O=FE_RN_1416_0 I1=n71 I2=A[20]
XFE_RC_2077_0 MXL2HS $PINS OB=DIFF[20] S=carry[20] A=FE_RN_1416_0
+ B=FE_RN_1415_0
XFE_RC_2075_0 OR2S $PINS O=FE_RN_1418_0 I1=n71 I2=A[20]
XFE_RC_2074_0 ND2 $PINS O=FE_RN_1419_0 I1=FE_RN_1418_0 I2=carry[20]
XFE_RC_2073_0 ND2P $PINS O=carry[21] I1=FE_RN_1419_0 I2=FE_RN_1414_0
XFE_RC_1893_0 ND2S $PINS O=FE_RN_1274_0 I1=A[21] I2=n72
XFE_RC_1892_0 AN2 $PINS O=FE_RN_1275_0 I1=FE_RN_1278_0 I2=FE_RN_1274_0
XFE_RC_1891_0 XNR2HS $PINS O=FE_RN_1276_0 I1=n72 I2=A[21]
XFE_RC_1890_0 MXL2HS $PINS OB=DIFF[21] S=carry[21] A=FE_RN_1276_0
+ B=FE_RN_1275_0
XFE_RC_1888_0 OR2S $PINS O=FE_RN_1278_0 I1=n72 I2=A[21]
XFE_RC_1887_0 ND2 $PINS O=FE_RN_1279_0 I1=FE_RN_1278_0 I2=carry[21]
XFE_RC_1886_0 ND2P $PINS O=carry[22] I1=FE_RN_1279_0 I2=FE_RN_1274_0
XFE_RC_1630_0 ND2S $PINS O=FE_RN_1078_0 I1=A[22] I2=n73
XFE_RC_1629_0 AN2 $PINS O=FE_RN_1079_0 I1=FE_RN_1082_0 I2=FE_RN_1078_0
XFE_RC_1628_0 XNR2HS $PINS O=FE_RN_1080_0 I1=n73 I2=A[22]
XFE_RC_1627_0 MXL2HS $PINS OB=DIFF[22] S=carry[22] A=FE_RN_1080_0
+ B=FE_RN_1079_0
XFE_RC_1625_0 OR2S $PINS O=FE_RN_1082_0 I1=n73 I2=A[22]
XFE_RC_1624_0 ND2 $PINS O=FE_RN_1083_0 I1=FE_RN_1082_0 I2=carry[22]
XFE_RC_1623_0 ND2P $PINS O=carry[23] I1=FE_RN_1083_0 I2=FE_RN_1078_0
XFE_RC_1545_0 OR2S $PINS O=FE_RN_1021_0 I1=FE_RN_904_0 I2=n466
XFE_RC_1544_0 ND2P $PINS O=carry[11] I1=FE_RN_914_0 I2=FE_RN_1021_0
XFE_RC_1404_0 INV1S $PINS O=FE_RN_904_0 I=n61
XFE_RC_1402_0 NR2 $PINS O=FE_RN_906_0 I1=FE_RN_904_0 I2=n466
XFE_RC_1401_0 AN2B1S $PINS O=FE_RN_907_0 I1=FE_RN_913_0 B1=FE_RN_906_0
XFE_RC_1398_0 AOI22S $PINS O=FE_RN_910_0 A1=n466 A2=n61 B1=A[10] B2=FE_RN_904_0
XFE_RC_1397_0 MXL2HS $PINS OB=DIFF[10] S=carry[10] A=FE_RN_910_0 B=FE_RN_907_0
XFE_RC_1394_0 OR2 $PINS O=FE_RN_913_0 I1=n61 I2=A[10]
XFE_RC_1393_0 ND2 $PINS O=FE_RN_914_0 I1=FE_RN_913_0 I2=carry[10]
XFE_RC_1180_0 ND2 $PINS O=FE_RN_750_0 I1=A[27] I2=n78
XFE_RC_1179_0 AN2 $PINS O=FE_RN_751_0 I1=FE_RN_754_0 I2=FE_RN_750_0
XFE_RC_1178_0 XNR2HS $PINS O=FE_RN_752_0 I1=n78 I2=A[27]
XFE_RC_1177_0 MXL2HS $PINS OB=DIFF[27] S=carry[27] A=FE_RN_752_0 B=FE_RN_751_0
XFE_RC_1175_0 OR2S $PINS O=FE_RN_754_0 I1=n78 I2=A[27]
XFE_RC_1174_0 ND2 $PINS O=FE_RN_755_0 I1=FE_RN_754_0 I2=carry[27]
XFE_RC_1173_0 ND2P $PINS O=carry[28] I1=FE_RN_755_0 I2=FE_RN_750_0
XFE_RC_975_0 ND2 $PINS O=FE_RN_599_0 I1=A[11] I2=n62
XFE_RC_974_0 AN2S $PINS O=FE_RN_600_0 I1=FE_RN_603_0 I2=FE_RN_599_0
XFE_RC_973_0 XNR2HS $PINS O=FE_RN_601_0 I1=n62 I2=A[11]
XFE_RC_972_0 MXL2HS $PINS OB=DIFF[11] S=carry[11] A=FE_RN_601_0 B=FE_RN_600_0
XFE_RC_970_0 OR2 $PINS O=FE_RN_603_0 I1=n62 I2=A[11]
XFE_RC_969_0 ND2 $PINS O=FE_RN_604_0 I1=FE_RN_603_0 I2=carry[11]
XFE_RC_968_0 ND2P $PINS O=carry[12] I1=FE_RN_604_0 I2=FE_RN_599_0
XFE_RC_790_0 ND2S $PINS O=FE_RN_461_0 I1=A[23] I2=n74
XFE_RC_789_0 AN2 $PINS O=FE_RN_462_0 I1=FE_RN_465_0 I2=FE_RN_461_0
XFE_RC_788_0 XNR2HS $PINS O=FE_RN_463_0 I1=n74 I2=A[23]
XFE_RC_787_0 MXL2HS $PINS OB=DIFF[23] S=carry[23] A=FE_RN_463_0 B=FE_RN_462_0
XFE_RC_785_0 OR2S $PINS O=FE_RN_465_0 I1=n74 I2=A[23]
XFE_RC_784_0 ND2 $PINS O=FE_RN_466_0 I1=FE_RN_465_0 I2=carry[23]
XFE_RC_783_0 ND2P $PINS O=carry[24] I1=FE_RN_466_0 I2=FE_RN_461_0
XFE_RC_613_0 ND3P $PINS O=carry[8] I1=n43 I2=n42 I3=n41
XFE_RC_612_0 ND2 $PINS O=FE_RN_335_0 I1=A[5] I2=n56
XFE_RC_611_0 AN2 $PINS O=FE_RN_336_0 I1=FE_RN_339_0 I2=FE_RN_335_0
XFE_RC_610_0 XNR2HS $PINS O=FE_RN_337_0 I1=n56 I2=A[5]
XFE_RC_609_0 MXL2HS $PINS OB=DIFF[5] S=carry[5] A=FE_RN_337_0 B=FE_RN_336_0
XFE_RC_607_0 OR2 $PINS O=FE_RN_339_0 I1=n56 I2=A[5]
XFE_RC_606_0 ND2 $PINS O=FE_RN_340_0 I1=FE_RN_339_0 I2=carry[5]
XFE_RC_605_0 ND2P $PINS O=carry[6] I1=FE_RN_340_0 I2=FE_RN_335_0
XFE_RC_402_0 ND2 $PINS O=FE_RN_188_0 I1=A[13] I2=n64
XFE_RC_401_0 AN2S $PINS O=FE_RN_189_0 I1=FE_RN_192_0 I2=FE_RN_188_0
XFE_RC_400_0 XNR2HS $PINS O=FE_RN_190_0 I1=n64 I2=A[13]
XFE_RC_399_0 MXL2HS $PINS OB=DIFF[13] S=carry[13] A=FE_RN_190_0 B=FE_RN_189_0
XFE_RC_397_0 OR2 $PINS O=FE_RN_192_0 I1=n64 I2=A[13]
XFE_RC_396_0 ND2 $PINS O=FE_RN_193_0 I1=FE_RN_192_0 I2=carry[13]
XFE_RC_395_0 ND2P $PINS O=carry[14] I1=FE_RN_193_0 I2=FE_RN_188_0
XFE_RC_366_0 ND3P $PINS O=carry[26] I1=n13 I2=n14 I3=n12
XFE_RC_345_0 ND3P $PINS O=carry[25] I1=n10 I2=n9 I3=n8
XFE_RC_297_0 ND3P $PINS O=carry[10] I1=n36 I2=n35 I3=n34
XFE_RC_283_0 ND3P $PINS O=carry[7] I1=n39 I2=n38 I3=n37
XFE_RC_273_0 ND3P $PINS O=carry[15] I1=n17 I2=n16 I3=n15
XFE_RC_159_0 ND3 $PINS O=carry[16] I1=n21 I2=n20 I3=n19
XFE_RC_108_0 ND3P $PINS O=carry[13] I1=n23 I2=n22 I3=n24
XFE_RC_103_0 XNR2HS $PINS O=DIFF[31] I1=n25 I2=carry[31]
XFE_OFC282_raw_prime_3 INV1S $PINS O=n54 I=B[3]
XFE_OFC221_raw_prime_5 INV1S $PINS O=n56 I=B[5]
XFE_OFC203_raw_prime_9 INV1S $PINS O=n60 I=B[9]
XFE_OFC169_raw_prime_7 INV1S $PINS O=n58 I=B[7]
XFE_OFC148_raw_prime_6 INV1S $PINS O=n57 I=B[6]
XFE_OFC98_raw_prime_4 INV1S $PINS O=n55 I=B[4]
XU2_19 FA1 $PINS S=DIFF[19] CO=carry[20] A=A[19] B=n70 CI=carry[19]
XU2_18 FA1 $PINS S=DIFF[18] CO=carry[19] A=A[18] B=n69 CI=carry[18]
XU2_16 FA1 $PINS S=DIFF[16] CO=carry[17] A=A[16] B=n67 CI=carry[16]
XU2_26 FA1 $PINS S=DIFF[26] CO=carry[27] A=A[26] B=n77 CI=carry[26]
XU2_17 FA1 $PINS S=DIFF[17] CO=carry[18] A=A[17] B=n68 CI=carry[17]
XU2_3 FA1 $PINS S=DIFF[3] CO=carry[4] A=A[3] B=n54 CI=carry[3]
XU1 ND3P $PINS O=carry[29] I1=n44 I2=n45 I3=n46
XU7 ND3 $PINS O=carry[31] I1=n47 I2=n48 I3=n49
XU8 INV1S $PINS O=n51 I=B[0]
XU9 XOR3 $PINS O=DIFF[2] I1=B[2] I2=A[2] I3=carry[2]
XU10 ND2 $PINS O=n1 I1=carry[2] I2=B[2]
XU11 ND2 $PINS O=n2 I1=carry[2] I2=A[2]
XU12 ND2 $PINS O=n3 I1=B[2] I2=A[2]
XU13 ND3 $PINS O=carry[3] I1=n1 I2=n2 I3=n3
XU14 XOR3 $PINS O=DIFF[1] I1=n52 I2=A[1] I3=carry[1]
XU15 ND2 $PINS O=n4 I1=carry[1] I2=n52
XU16 ND2 $PINS O=n5 I1=carry[1] I2=A[1]
XU17 ND2 $PINS O=n6 I1=n52 I2=A[1]
XU19 ND2P $PINS O=carry[1] I1=B[0] I2=p1
XU20 ND3P $PINS O=carry[30] I1=n27 I2=n28 I3=n29
XU21 ND3P $PINS O=carry[9] I1=n32 I2=n31 I3=n30
XU22 ND2 $PINS O=n8 I1=A[24] I2=n75
XU23 ND2 $PINS O=n37 I1=A[6] I2=n57
XU24 ND2 $PINS O=n30 I1=A[8] I2=B[8]
XU25 ND2 $PINS O=n15 I1=A[14] I2=n65
XU26 INV1S $PINS O=n79 I=B[28]
XU27 INV1S $PINS O=n80 I=B[29]
XU28 XOR3 $PINS O=DIFF[6] I1=A[6] I2=n57 I3=carry[6]
XU29 XOR3 $PINS O=DIFF[8] I1=A[8] I2=B[8] I3=carry[8]
XU30 XOR3 $PINS O=DIFF[14] I1=A[14] I2=n65 I3=carry[14]
XU31 XOR3 $PINS O=DIFF[24] I1=A[24] I2=n75 I3=carry[24]
XU32 XOR3 $PINS O=DIFF[28] I1=n79 I2=A[28] I3=carry[28]
XU35 XNR2HS $PINS O=n7 I1=n81 I2=A[30]
XU36 ND2 $PINS O=n9 I1=A[24] I2=carry[24]
XU37 ND2 $PINS O=n10 I1=n75 I2=carry[24]
XU39 XOR2HS $PINS O=n11 I1=A[25] I2=n76
XU40 XOR2HS $PINS O=DIFF[25] I1=n11 I2=carry[25]
XU41 ND2S $PINS O=n12 I1=A[25] I2=n76
XU42 ND2 $PINS O=n13 I1=A[25] I2=carry[25]
XU43 ND2 $PINS O=n14 I1=n76 I2=carry[25]
XU44 ND2 $PINS O=n16 I1=A[14] I2=carry[14]
XU45 ND2 $PINS O=n17 I1=n65 I2=carry[14]
XU46 XOR2HS $PINS O=n18 I1=A[15] I2=n66
XU47 XOR2HS $PINS O=DIFF[15] I1=n18 I2=carry[15]
XU48 ND2S $PINS O=n19 I1=A[15] I2=n66
XU49 ND2 $PINS O=n20 I1=A[15] I2=carry[15]
XU50 ND2 $PINS O=n21 I1=n66 I2=carry[15]
XU52 XOR3 $PINS O=DIFF[12] I1=n63 I2=A[12] I3=carry[12]
XU53 ND2 $PINS O=n22 I1=carry[12] I2=n63
XU54 ND2 $PINS O=n23 I1=carry[12] I2=A[12]
XU55 ND2 $PINS O=n24 I1=n63 I2=A[12]
XU57 XNR2HS $PINS O=n25 I1=n82 I2=A[31]
XU58 XOR2HS $PINS O=n26 I1=n80 I2=A[29]
XU59 XOR2HS $PINS O=DIFF[29] I1=carry[29] I2=n26
XU60 ND2 $PINS O=n27 I1=carry[29] I2=n80
XU61 ND2 $PINS O=n28 I1=carry[29] I2=A[29]
XU62 ND2S $PINS O=n29 I1=n80 I2=A[29]
XU63 XNR2HS $PINS O=DIFF[30] I1=carry[30] I2=n7
XU64 ND2 $PINS O=n31 I1=carry[8] I2=A[8]
XU65 ND2 $PINS O=n32 I1=B[8] I2=carry[8]
XU66 XOR2HS $PINS O=n33 I1=A[9] I2=n60
XU67 XOR2HS $PINS O=DIFF[9] I1=n33 I2=carry[9]
XU68 ND2S $PINS O=n34 I1=A[9] I2=n60
XU69 ND2 $PINS O=n35 I1=A[9] I2=carry[9]
XU70 ND2 $PINS O=n36 I1=n60 I2=carry[9]
XU71 ND2 $PINS O=n38 I1=A[6] I2=carry[6]
XU72 ND2 $PINS O=n39 I1=n57 I2=carry[6]
XU73 XOR2HS $PINS O=n40 I1=A[7] I2=n58
XU74 XOR2HS $PINS O=DIFF[7] I1=n40 I2=carry[7]
XU75 ND2S $PINS O=n41 I1=A[7] I2=n58
XU76 ND2 $PINS O=n42 I1=A[7] I2=carry[7]
XU77 ND2 $PINS O=n43 I1=n58 I2=carry[7]
XU79 ND2 $PINS O=n44 I1=carry[28] I2=n79
XU80 ND2 $PINS O=n45 I1=carry[28] I2=A[28]
XU81 ND2S $PINS O=n46 I1=n79 I2=A[28]
XU82 ND2 $PINS O=n47 I1=carry[30] I2=n81
XU83 ND2 $PINS O=n48 I1=carry[30] I2=A[30]
XU84 ND2S $PINS O=n49 I1=n81 I2=A[30]
XU86 INV1S $PINS O=n82 I=B[31]
XU89 INV1S $PINS O=n65 I=B[14]
XU90 INV1S $PINS O=n81 I=B[30]
XU91 INV1S $PINS O=n67 I=B[16]
XU93 INV1S $PINS O=n63 I=B[12]
XU94 INV1S $PINS O=n71 I=B[20]
XU95 INV1S $PINS O=n77 I=B[26]
XU96 INV1S $PINS O=n75 I=B[24]
XU97 INV1S $PINS O=n73 I=B[22]
XU98 INV1S $PINS O=n69 I=B[18]
XU99 INV1S $PINS O=n61 I=B[10]
XU101 INV1S $PINS O=n78 I=B[27]
XU102 INV1S $PINS O=n76 I=B[25]
XU103 INV1S $PINS O=n74 I=B[23]
XU104 INV1S $PINS O=n72 I=B[21]
XU105 INV1S $PINS O=n70 I=B[19]
XU106 INV1S $PINS O=n68 I=B[17]
XU107 INV1S $PINS O=n66 I=B[15]
XU108 INV1S $PINS O=n64 I=B[13]
XU109 INV1S $PINS O=n62 I=B[11]
XU113 XNR2HS $PINS O=DIFF[0] I1=n51 I2=A[0]
.ENDS

.SUBCKT Domain_Transfer_0_DW_cmp_4 A[31] A[30] A[29] A[28] A[27] A[26] A[25]
+ A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12]
+ A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] TC GE_LT GE_GT_EQ GE_LT_GT_LE EQ_NE p1
XFE_RC_2406_0 AO12 $PINS O=n331 A1=n339 B1=n327 B2=n340
XFE_RC_2401_0 AO12 $PINS O=n292 A1=n301 B1=n300 B2=n302
XU161 INV1S $PINS O=n242 I=B[18]
XU162 INV1S $PINS O=n240 I=B[14]
XU163 INV1S $PINS O=n248 I=B[30]
XU164 INV1S $PINS O=n244 I=B[22]
XU165 INV1S $PINS O=n262 I=n317
XU166 INV1S $PINS O=n239 I=B[12]
XU167 INV1S $PINS O=n234 I=B[2]
XU168 INV1S $PINS O=n236 I=B[6]
XU169 INV1S $PINS O=n235 I=B[4]
XU170 INV1S $PINS O=n243 I=B[20]
XU171 INV1S $PINS O=n238 I=B[10]
XU173 INV1S $PINS O=n246 I=B[26]
XU174 INV1S $PINS O=n245 I=B[24]
XU175 INV1S $PINS O=n241 I=B[16]
XU176 INV1S $PINS O=n247 I=B[28]
XU178 INV1S $PINS O=n255 I=n283
XU179 MAOI1S $PINS O=n323 A1=A[2] A2=n230 B1=B[3] B2=A[3]
XU180 AN2 $PINS O=n230 I1=n325 I2=n234
XU181 MAOI1 $PINS O=n335 A1=A[14] A2=n231 B1=B[15] B2=A[15]
XU182 AN2 $PINS O=n231 I1=n338 I2=n240
XU183 MAOI1 $PINS O=n296 A1=A[30] A2=n232 B1=B[31] B2=A[31]
XU184 AN2 $PINS O=n232 I1=n299 I2=n248
XU201 INV1S $PINS O=n233 I=B[0]
XU202 MOAI1S $PINS O=GE_LT_GT_LE A1=n268 A2=n269 B1=n270 B2=n271
XU203 ND3 $PINS O=n271 I1=n272 I2=n273 I3=n274
XU204 OAI22S $PINS O=n273 A1=n275 A2=n276 B1=n276 B2=n277
XU205 MOAI1S $PINS O=n277 A1=B[21] A2=A[21] B1=A[20] B2=n278
XU206 AN2 $PINS O=n278 I1=n279 I2=n243
XU207 MOAI1S $PINS O=n276 A1=B[23] A2=A[23] B1=A[22] B2=n280
XU208 AN2 $PINS O=n280 I1=n281 I2=n244
XU209 OAI112HS $PINS O=n272 A1=n284 B1=n285 C1=n282 C2=n283
XU210 OAI112HS $PINS O=n284 A1=n286 B1=n255 C1=B[17] C2=A[17]
XU211 ND3 $PINS O=n286 I1=n287 I2=n241 I3=A[16]
XU212 MOAI1S $PINS O=n283 A1=B[19] A2=A[19] B1=A[18] B2=n288
XU213 AN2 $PINS O=n288 I1=n289 I2=n242
XU214 ND2 $PINS O=n270 I1=n274 I2=n290
XU215 AOI22S $PINS O=n274 A1=n291 A2=n292 B1=n293 B2=n294
XU216 OAI112HS $PINS O=n294 A1=n295 B1=n296 C1=B[29] C2=A[29]
XU217 ND3 $PINS O=n295 I1=n297 I2=n247 I3=A[28]
XU218 OR2B1S $PINS O=n293 I1=n298 B1=n296
XU220 MOAI1S $PINS O=n302 A1=B[25] A2=A[25] B1=A[24] B2=n303
XU221 AN2 $PINS O=n303 I1=n304 I2=n245
XU222 MOAI1S $PINS O=n301 A1=B[27] A2=A[27] B1=A[26] B2=n305
XU223 AN2 $PINS O=n305 I1=n306 I2=n246
XU224 OR3B2 $PINS O=n269 I1=n290 B1=n285 B2=n282
XU225 OA12 $PINS O=n282 A1=n289 B1=A[18] B2=n242
XU226 ND2 $PINS O=n289 I1=B[19] I2=A[19]
XU227 OA112 $PINS O=n285 A1=n279 B1=n275 C1=A[20] C2=n243
XU228 OA12 $PINS O=n275 A1=n281 B1=A[22] B2=n244
XU229 ND2 $PINS O=n281 I1=B[23] I2=A[23]
XU230 ND2 $PINS O=n279 I1=B[21] I2=A[21]
XU231 ND3 $PINS O=n290 I1=n300 I2=n291 I3=n307
XU232 OA12 $PINS O=n307 A1=n304 B1=A[24] B2=n245
XU233 ND2 $PINS O=n304 I1=B[25] I2=A[25]
XU234 OA112 $PINS O=n291 A1=n297 B1=n298 C1=A[28] C2=n247
XU235 OA12 $PINS O=n298 A1=n299 B1=A[30] B2=n248
XU236 ND2 $PINS O=n299 I1=B[31] I2=A[31]
XU237 ND2 $PINS O=n297 I1=B[29] I2=A[29]
XU238 OA12 $PINS O=n300 A1=n306 B1=A[26] B2=n246
XU239 ND2 $PINS O=n306 I1=B[27] I2=A[27]
XU240 OAI112HS $PINS O=n268 A1=n287 B1=n308 C1=A[16] C2=n241
XU241 AOI22S $PINS O=n308 A1=n309 A2=n310 B1=n311 B2=n309
XU242 AOI13HS $PINS O=n311 A1=n314 B1=n262 B2=n312 B3=n313
XU243 AOI22S $PINS O=n314 A1=n315 A2=n316 B1=n316 B2=n317
XU244 OA22 $PINS O=n316 A1=B[7] A2=A[7] B1=p1 B2=n318
XU245 ND2 $PINS O=n318 I1=n319 I2=n236
XU246 AOI13HS $PINS O=n315 A1=n321 B1=n320 B2=n235 B3=A[4]
XU247 NR2 $PINS O=n321 I1=B[5] I2=A[5]
XU248 OA112 $PINS O=n313 A1=n320 B1=n322 C1=A[4] C2=n235
XU249 ND2 $PINS O=n322 I1=n323 I2=n324
XU250 OAI12HS $PINS O=n324 A1=n325 B1=A[2] B2=n234
XU251 ND2 $PINS O=n320 I1=B[5] I2=A[5]
XU252 OAI112HS $PINS O=n312 A1=n326 B1=n323 C1=B[1] C2=A[1]
XU253 ND2 $PINS O=n325 I1=B[3] I2=A[3]
XU254 MOAI1S $PINS O=n326 A1=A[0] A2=n233 B1=A[1] B2=B[1]
XU255 OAI12HS $PINS O=n317 A1=n319 B1=A[6] B2=n236
XU256 ND2 $PINS O=n319 I1=B[7] I2=A[7]
XU257 ND3 $PINS O=n310 I1=n327 I2=n328 I3=n329
XU258 OA12 $PINS O=n329 A1=n330 B1=A[8] B2=B[8]
XU259 AOI22S $PINS O=n309 A1=n328 A2=n331 B1=n332 B2=n333
XU260 OAI112HS $PINS O=n333 A1=n334 B1=n335 C1=B[13] C2=A[13]
XU261 ND3 $PINS O=n334 I1=n336 I2=n239 I3=A[12]
XU262 OR2B1S $PINS O=n332 I1=n337 B1=n335
XU264 MOAI1S $PINS O=n340 A1=B[9] A2=A[9] B1=A[8] B2=n341
XU265 AN2 $PINS O=n341 I1=n330 I2=B[8]
XU266 ND2 $PINS O=n330 I1=B[9] I2=A[9]
XU267 MOAI1S $PINS O=n339 A1=B[11] A2=A[11] B1=A[10] B2=n342
XU268 AN2 $PINS O=n342 I1=n343 I2=n238
XU269 OA12 $PINS O=n327 A1=n343 B1=A[10] B2=n238
XU270 ND2 $PINS O=n343 I1=B[11] I2=A[11]
XU271 OA112 $PINS O=n328 A1=n336 B1=n337 C1=A[12] C2=n239
XU272 OA12 $PINS O=n337 A1=n338 B1=A[14] B2=n240
XU273 ND2 $PINS O=n338 I1=B[15] I2=A[15]
XU274 ND2 $PINS O=n336 I1=B[13] I2=A[13]
XU275 ND2 $PINS O=n287 I1=B[17] I2=A[17]
.ENDS

.SUBCKT Domain_Transfer_0_DW01_sub_5 A[31] A[30] A[29] A[28] A[27] A[26] A[25]
+ A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12]
+ A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] CI DIFF[31] DIFF[30] DIFF[29] DIFF[28] DIFF[27] DIFF[26]
+ DIFF[25] DIFF[24] DIFF[23] DIFF[22] DIFF[21] DIFF[20] DIFF[19] DIFF[18]
+ DIFF[17] DIFF[16] DIFF[15] DIFF[14] DIFF[13] DIFF[12] DIFF[11] DIFF[10]
+ DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3] DIFF[2] DIFF[1]
+ DIFF[0] CO p1 FE_DBTN59_x3_w_9
XFE_RC_2372_0 OR2 $PINS O=FE_RN_1588_0 I1=FE_DBTN59_x3_w_9 I2=FE_RN_1576_0
XFE_RC_2371_0 ND2P $PINS O=carry[10] I1=FE_RN_1587_0 I2=FE_RN_1588_0
XFE_RC_2370_0 INV1S $PINS O=FE_RN_1576_0 I=n69
XFE_RC_2368_0 NR2 $PINS O=FE_RN_1578_0 I1=FE_RN_1576_0 I2=FE_DBTN59_x3_w_9
XFE_RC_2367_0 INV1S $PINS O=FE_RN_1579_0 I=FE_RN_1586_0
XFE_RC_2366_0 NR2 $PINS O=FE_RN_1580_0 I1=FE_RN_1578_0 I2=FE_RN_1579_0
XFE_RC_2363_0 AOI22S $PINS O=FE_RN_1583_0 A1=FE_DBTN59_x3_w_9 A2=n69 B1=A[9]
+ B2=FE_RN_1576_0
XFE_RC_2362_0 MXL2HS $PINS OB=DIFF[9] S=carry[9] A=FE_RN_1583_0 B=FE_RN_1580_0
XFE_RC_2359_0 OR2 $PINS O=FE_RN_1586_0 I1=n69 I2=A[9]
XFE_RC_2358_0 ND2 $PINS O=FE_RN_1587_0 I1=FE_RN_1586_0 I2=carry[9]
XFE_RC_2343_0 ND3P $PINS O=carry[9] I1=n22 I2=n23 I3=n24
XFE_RC_2342_0 ND3P $PINS O=carry[17] I1=n54 I2=n55 I3=n53
XFE_RC_2341_0 ND3P $PINS O=carry[14] I1=n39 I2=n40 I3=FE_RN_97_0
XFE_OFC629_FE_OFN87_n312 INV1S $PINS O=n61 I=B[1]
XFE_OCPC462_carry_24 BUF1S $PINS O=FE_OCPN462_carry_24 I=carry[24]
XFE_OCPC417_carry_12 BUF1S $PINS O=FE_OCPN417_carry_12 I=carry[12]
XFE_OCPC411_carry_7 BUF1S $PINS O=FE_OCPN411_carry_7 I=carry[7]
XFE_OCPC401_carry_15 BUF1S $PINS O=FE_OCPN401_carry_15 I=carry[15]
XFE_OCPC393_carry_13 BUF1S $PINS O=FE_OCPN393_carry_13 I=carry[13]
XFE_RC_2330_0 XOR3 $PINS O=DIFF[4] I1=A[4] I2=n64 I3=carry[4]
XFE_RC_2329_0 MAO222 $PINS O=carry[5] A1=A[4] B1=n64 C1=carry[4]
XFE_RC_2276_0 XOR3 $PINS O=DIFF[24] I1=A[24] I2=n84 I3=FE_OCPN462_carry_24
XFE_RC_2275_0 MAO222 $PINS O=carry[25] A1=A[24] B1=n84 C1=carry[24]
XFE_OCPC323_carry_18 BUF1S $PINS O=FE_OCPN323_carry_18 I=carry[18]
XFE_OCPC243_carry_17 BUF1S $PINS O=FE_OCPN243_carry_17 I=carry[17]
XFE_OCPC177_carry_29 BUF1 $PINS O=FE_OCPN177_carry_29 I=carry[29]
XFE_OCPC164_carry_23 BUF1S $PINS O=FE_OCPN164_carry_23 I=carry[23]
XFE_RC_2055_0 ND3 $PINS O=carry[18] I1=n57 I2=n58 I3=FE_RN_1191_0
XFE_RC_2004_0 ND2S $PINS O=FE_RN_1357_0 I1=A[25] I2=n85
XFE_RC_2003_0 AN2 $PINS O=FE_RN_1358_0 I1=FE_RN_1361_0 I2=FE_RN_1357_0
XFE_RC_2002_0 XNR2HS $PINS O=FE_RN_1359_0 I1=n85 I2=A[25]
XFE_RC_2001_0 MXL2HS $PINS OB=DIFF[25] S=carry[25] A=FE_RN_1359_0
+ B=FE_RN_1358_0
XFE_RC_1999_0 OR2 $PINS O=FE_RN_1361_0 I1=n85 I2=A[25]
XFE_RC_1998_0 ND2 $PINS O=FE_RN_1362_0 I1=FE_RN_1361_0 I2=carry[25]
XFE_RC_1997_0 ND2P $PINS O=carry[26] I1=FE_RN_1362_0 I2=FE_RN_1357_0
XFE_RC_1778_0 INV1S $PINS O=FE_RN_1191_0 I=n52
XFE_RC_1774_0 ND2S $PINS O=FE_RN_1184_0 I1=A[26] I2=n86
XFE_RC_1773_0 AN2 $PINS O=FE_RN_1185_0 I1=FE_RN_1188_0 I2=FE_RN_1184_0
XFE_RC_1772_0 XNR2HS $PINS O=FE_RN_1186_0 I1=n86 I2=A[26]
XFE_RC_1771_0 MXL2HS $PINS OB=DIFF[26] S=carry[26] A=FE_RN_1186_0
+ B=FE_RN_1185_0
XFE_RC_1769_0 OR2S $PINS O=FE_RN_1188_0 I1=n86 I2=A[26]
XFE_RC_1768_0 ND2 $PINS O=FE_RN_1189_0 I1=FE_RN_1188_0 I2=carry[26]
XFE_RC_1767_0 ND2P $PINS O=carry[27] I1=FE_RN_1189_0 I2=FE_RN_1184_0
XFE_RC_1575_0 INV1S $PINS O=FE_RN_1038_0 I=FE_RN_1042_0
XFE_RC_1574_0 AOI12HS $PINS O=FE_RN_1039_0 A1=FE_RN_1038_0 B1=A[18] B2=n78
XFE_RC_1573_0 XNR2HS $PINS O=FE_RN_1040_0 I1=n78 I2=A[18]
XFE_RC_1572_0 MXL2HS $PINS OB=DIFF[18] S=FE_OCPN323_carry_18 A=FE_RN_1040_0
+ B=FE_RN_1039_0
XFE_RC_1571_0 ND2S $PINS O=FE_RN_1041_0 I1=A[18] I2=n78
XFE_RC_1570_0 OR2S $PINS O=FE_RN_1042_0 I1=n78 I2=A[18]
XFE_RC_1569_0 ND2 $PINS O=FE_RN_1043_0 I1=FE_RN_1042_0 I2=carry[18]
XFE_RC_1568_0 ND2 $PINS O=carry[19] I1=FE_RN_1043_0 I2=FE_RN_1041_0
XFE_RC_1320_0 ND2S $PINS O=FE_RN_845_0 I1=A[19] I2=n79
XFE_RC_1319_0 AN2 $PINS O=FE_RN_846_0 I1=FE_RN_849_0 I2=FE_RN_845_0
XFE_RC_1318_0 XNR2HS $PINS O=FE_RN_847_0 I1=n79 I2=A[19]
XFE_RC_1317_0 MXL2HS $PINS OB=DIFF[19] S=carry[19] A=FE_RN_847_0 B=FE_RN_846_0
XFE_RC_1315_0 OR2 $PINS O=FE_RN_849_0 I1=n79 I2=A[19]
XFE_RC_1314_0 ND2 $PINS O=FE_RN_850_0 I1=FE_RN_849_0 I2=carry[19]
XFE_RC_1313_0 ND2P $PINS O=carry[20] I1=FE_RN_850_0 I2=FE_RN_845_0
XFE_RC_1109_0 ND2S $PINS O=FE_RN_699_0 I1=A[20] I2=n80
XFE_RC_1108_0 AN2 $PINS O=FE_RN_700_0 I1=FE_RN_703_0 I2=FE_RN_699_0
XFE_RC_1107_0 XNR2HS $PINS O=FE_RN_701_0 I1=n80 I2=A[20]
XFE_RC_1106_0 MXL2HS $PINS OB=DIFF[20] S=carry[20] A=FE_RN_701_0 B=FE_RN_700_0
XFE_RC_1104_0 OR2S $PINS O=FE_RN_703_0 I1=n80 I2=A[20]
XFE_RC_1103_0 ND2 $PINS O=FE_RN_704_0 I1=FE_RN_703_0 I2=carry[20]
XFE_RC_1102_0 ND2P $PINS O=carry[21] I1=FE_RN_704_0 I2=FE_RN_699_0
XFE_RC_943_0 ND2S $PINS O=FE_RN_575_0 I1=A[27] I2=n87
XFE_RC_942_0 AN2 $PINS O=FE_RN_576_0 I1=FE_RN_579_0 I2=FE_RN_575_0
XFE_RC_941_0 XNR2HS $PINS O=FE_RN_577_0 I1=n87 I2=A[27]
XFE_RC_940_0 MXL2HS $PINS OB=DIFF[27] S=carry[27] A=FE_RN_577_0 B=FE_RN_576_0
XFE_RC_938_0 OR2 $PINS O=FE_RN_579_0 I1=n87 I2=A[27]
XFE_RC_937_0 ND2 $PINS O=FE_RN_580_0 I1=FE_RN_579_0 I2=carry[27]
XFE_RC_936_0 ND2P $PINS O=carry[28] I1=FE_RN_580_0 I2=FE_RN_575_0
XFE_RC_766_0 ND2S $PINS O=FE_RN_444_0 I1=A[5] I2=n65
XFE_RC_765_0 AN2 $PINS O=FE_RN_445_0 I1=FE_RN_448_0 I2=FE_RN_444_0
XFE_RC_764_0 XNR2HS $PINS O=FE_RN_446_0 I1=n65 I2=A[5]
XFE_RC_763_0 MXL2HS $PINS OB=DIFF[5] S=carry[5] A=FE_RN_446_0 B=FE_RN_445_0
XFE_RC_761_0 OR2 $PINS O=FE_RN_448_0 I1=n65 I2=A[5]
XFE_RC_760_0 ND2 $PINS O=FE_RN_449_0 I1=FE_RN_448_0 I2=carry[5]
XFE_RC_759_0 ND2P $PINS O=carry[6] I1=FE_RN_449_0 I2=FE_RN_444_0
XFE_RC_588_0 ND2 $PINS O=FE_RN_317_0 I1=A[21] I2=n81
XFE_RC_587_0 AN2 $PINS O=FE_RN_318_0 I1=FE_RN_321_0 I2=FE_RN_317_0
XFE_RC_586_0 XNR2HS $PINS O=FE_RN_319_0 I1=n81 I2=A[21]
XFE_RC_585_0 MXL2HS $PINS OB=DIFF[21] S=carry[21] A=FE_RN_319_0 B=FE_RN_318_0
XFE_RC_583_0 OR2S $PINS O=FE_RN_321_0 I1=n81 I2=A[21]
XFE_RC_582_0 ND2 $PINS O=FE_RN_322_0 I1=FE_RN_321_0 I2=carry[21]
XFE_RC_581_0 ND2P $PINS O=carry[22] I1=FE_RN_322_0 I2=FE_RN_317_0
XFE_RC_410_0 ND2S $PINS O=FE_RN_194_0 I1=A[10] I2=n70
XFE_RC_409_0 AN2 $PINS O=FE_RN_195_0 I1=FE_RN_198_0 I2=FE_RN_194_0
XFE_RC_408_0 XNR2HS $PINS O=FE_RN_196_0 I1=n70 I2=A[10]
XFE_RC_407_0 MXL2HS $PINS OB=DIFF[10] S=carry[10] A=FE_RN_196_0 B=FE_RN_195_0
XFE_RC_405_0 OR2 $PINS O=FE_RN_198_0 I1=n70 I2=A[10]
XFE_RC_404_0 ND2 $PINS O=FE_RN_199_0 I1=FE_RN_198_0 I2=carry[10]
XFE_RC_403_0 ND2P $PINS O=carry[11] I1=FE_RN_199_0 I2=FE_RN_194_0
XFE_RC_375_0 ND3P $PINS O=carry[23] I1=n10 I2=n9 I3=n8
XFE_RC_318_0 ND3P $PINS O=carry[15] I1=n2 I2=n1 I3=n3
XFE_RC_313_0 ND3P $PINS O=carry[12] I1=n19 I2=n18 I3=n20
XFE_RC_311_0 ND3 $PINS O=carry[24] I1=n13 I2=n14 I3=n12
XFE_RC_300_0 ND3P $PINS O=carry[8] I1=n30 I2=n31 I3=n29
XFE_RC_241_0 INV1S $PINS O=FE_RN_97_0 I=n21
XFE_RC_216_0 ND3P $PINS O=carry[7] I1=n27 I2=n26 I3=n25
XFE_RC_157_0 ND3P $PINS O=carry[13] I1=n37 I2=n36 I3=n35
XFE_OFC280_raw_prime_3 INV1S $PINS O=n63 I=B[3]
XFE_OFC220_raw_prime_5 INV1S $PINS O=n65 I=B[5]
XFE_OFC198_raw_prime_9 INV1S $PINS O=n69 I=B[9]
XFE_OFC170_raw_prime_7 INV1S $PINS O=n67 I=B[7]
XFE_OFC150_raw_prime_6 INV1S $PINS O=n66 I=B[6]
XFE_OFC97_raw_prime_4 INV1S $PINS O=n64 I=B[4]
XU2_3 FA1 $PINS S=DIFF[3] CO=carry[4] A=A[3] B=n63 CI=carry[3]
XU2_2 FA1 $PINS S=DIFF[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU2_1 FA1 $PINS S=DIFF[1] CO=carry[2] A=A[1] B=n61 CI=carry[1]
XU1 ND2P $PINS O=n45 I1=carry[15] I2=A[15]
XU2 ND2S $PINS O=n16 I1=carry[29] I2=A[29]
XU3 XOR3 $PINS O=DIFF[29] I1=n89 I2=A[29] I3=FE_OCPN177_carry_29
XU4 XOR3 $PINS O=DIFF[14] I1=n74 I2=A[14] I3=carry[14]
XU5 XOR3 $PINS O=DIFF[8] I1=B[8] I2=A[8] I3=carry[8]
XU7 XOR3 $PINS O=DIFF[12] I1=A[12] I2=n72 I3=FE_OCPN417_carry_12
XU9 ND2 $PINS O=n46 I1=n75 I2=A[15]
XU10 ND2P $PINS O=n15 I1=carry[29] I2=n89
XU11 ND2P $PINS O=n42 I1=carry[30] I2=A[30]
XU12 ND2 $PINS O=n17 I1=n89 I2=A[29]
XU13 INV2 $PINS O=n7 I=n6
XU14 ND2P $PINS O=carry[30] I1=n16 I2=n5
XU15 INV2 $PINS O=n5 I=n4
XU16 ND2P $PINS O=n4 I1=n15 I2=n17
XU17 XOR3 $PINS O=DIFF[16] I1=A[16] I2=n76 I3=carry[16]
XU18 XOR3 $PINS O=DIFF[30] I1=n90 I2=A[30] I3=carry[30]
XU19 INV1S $PINS O=n47 I=carry[31]
XU20 ND2 $PINS O=n1 I1=carry[14] I2=n74
XU21 ND2 $PINS O=n2 I1=carry[14] I2=A[14]
XU22 ND2 $PINS O=n3 I1=n74 I2=A[14]
XU24 ND2P $PINS O=n41 I1=carry[30] I2=n90
XU25 ND2P $PINS O=n6 I1=n45 I2=n46
XU26 ND2P $PINS O=carry[16] I1=n44 I2=n7
XU27 ND2S $PINS O=n44 I1=carry[15] I2=n75
XU33 INV1S $PINS O=n75 I=B[15]
XU34 ND2S $PINS O=n50 I1=n47 I2=n51
XU35 ND2 $PINS O=n25 I1=A[6] I2=n66
XU36 INV1S $PINS O=n71 I=B[11]
XU37 ND2 $PINS O=n35 I1=A[12] I2=n72
XU38 ND2 $PINS O=n8 I1=A[22] I2=n82
XU39 INV1S $PINS O=n88 I=B[28]
XU40 INV1S $PINS O=n89 I=B[29]
XU41 INV1S $PINS O=n90 I=B[30]
XU42 XOR2HS $PINS O=n51 I1=n91 I2=A[31]
XU43 INV1S $PINS O=n91 I=B[31]
XU44 XOR3 $PINS O=DIFF[6] I1=A[6] I2=n66 I3=carry[6]
XU45 XOR3 $PINS O=DIFF[11] I1=n71 I2=A[11] I3=carry[11]
XU47 XOR3 $PINS O=DIFF[15] I1=n75 I2=A[15] I3=FE_OCPN401_carry_15
XU48 XOR3 $PINS O=DIFF[22] I1=A[22] I2=n82 I3=carry[22]
XU49 XOR3 $PINS O=DIFF[28] I1=n88 I2=A[28] I3=carry[28]
XU52 ND2 $PINS O=DIFF[31] I1=n49 I2=n50
XU53 INV1S $PINS O=n60 I=B[0]
XU54 ND2 $PINS O=n9 I1=A[22] I2=carry[22]
XU55 ND2 $PINS O=n10 I1=n82 I2=carry[22]
XU56 XOR2HS $PINS O=n11 I1=A[23] I2=n83
XU57 XOR2HS $PINS O=DIFF[23] I1=n11 I2=FE_OCPN164_carry_23
XU58 ND2S $PINS O=n12 I1=A[23] I2=n83
XU59 ND2 $PINS O=n13 I1=A[23] I2=carry[23]
XU60 ND2 $PINS O=n14 I1=n83 I2=carry[23]
XU62 ND2 $PINS O=n18 I1=carry[11] I2=n71
XU63 ND2 $PINS O=n19 I1=carry[11] I2=A[11]
XU64 ND2S $PINS O=n20 I1=n71 I2=A[11]
XU66 AN2 $PINS O=n21 I1=A[13] I2=n73
XU67 ND2 $PINS O=n22 I1=carry[8] I2=B[8]
XU68 ND2 $PINS O=n23 I1=carry[8] I2=A[8]
XU69 ND2S $PINS O=n24 I1=B[8] I2=A[8]
XU70 ND2 $PINS O=n26 I1=A[6] I2=carry[6]
XU71 ND2 $PINS O=n27 I1=n66 I2=carry[6]
XU72 XOR2HS $PINS O=n28 I1=A[7] I2=n67
XU73 XOR2HS $PINS O=DIFF[7] I1=n28 I2=FE_OCPN411_carry_7
XU74 ND2S $PINS O=n29 I1=A[7] I2=n67
XU75 ND2 $PINS O=n30 I1=A[7] I2=carry[7]
XU76 ND2 $PINS O=n31 I1=n67 I2=carry[7]
XU77 ND2 $PINS O=n32 I1=carry[28] I2=n88
XU78 ND2 $PINS O=n33 I1=carry[28] I2=A[28]
XU79 ND2S $PINS O=n34 I1=n88 I2=A[28]
XU80 ND3P $PINS O=carry[29] I1=n32 I2=n33 I3=n34
XU81 ND2 $PINS O=n36 I1=A[12] I2=carry[12]
XU82 ND2 $PINS O=n37 I1=n72 I2=carry[12]
XU83 XOR2HS $PINS O=n38 I1=A[13] I2=n73
XU84 XOR2HS $PINS O=DIFF[13] I1=n38 I2=FE_OCPN393_carry_13
XU85 ND2 $PINS O=n39 I1=A[13] I2=carry[13]
XU86 ND2 $PINS O=n40 I1=n73 I2=carry[13]
XU87 ND2S $PINS O=n43 I1=n90 I2=A[30]
XU88 ND3P $PINS O=carry[31] I1=n41 I2=n42 I3=n43
XU89 ND2 $PINS O=n49 I1=carry[31] I2=n48
XU90 INV1S $PINS O=n48 I=n51
XU92 AN2 $PINS O=n52 I1=A[17] I2=n77
XU93 ND2 $PINS O=n53 I1=A[16] I2=n76
XU95 ND2 $PINS O=n54 I1=A[16] I2=carry[16]
XU96 ND2 $PINS O=n55 I1=n76 I2=carry[16]
XU97 XOR2HS $PINS O=n56 I1=A[17] I2=n77
XU98 XOR2HS $PINS O=DIFF[17] I1=n56 I2=FE_OCPN243_carry_17
XU99 ND2 $PINS O=n57 I1=carry[17] I2=A[17]
XU100 ND2 $PINS O=n58 I1=carry[17] I2=n77
XU103 INV1S $PINS O=n74 I=B[14]
XU104 INV1S $PINS O=n76 I=B[16]
XU106 INV1S $PINS O=n72 I=B[12]
XU107 INV1S $PINS O=n80 I=B[20]
XU108 INV1S $PINS O=n86 I=B[26]
XU109 INV1S $PINS O=n84 I=B[24]
XU110 INV1S $PINS O=n82 I=B[22]
XU111 INV1S $PINS O=n78 I=B[18]
XU112 INV1S $PINS O=n70 I=B[10]
XU113 INV1S $PINS O=n87 I=B[27]
XU114 INV1S $PINS O=n85 I=B[25]
XU115 INV1S $PINS O=n83 I=B[23]
XU116 INV1S $PINS O=n81 I=B[21]
XU117 INV1S $PINS O=n79 I=B[19]
XU118 INV1S $PINS O=n77 I=B[17]
XU119 INV1S $PINS O=n73 I=B[13]
XU123 XNR2HS $PINS O=DIFF[0] I1=n60 I2=p1
XU124 ND2 $PINS O=carry[1] I1=B[0] I2=A[0]
.ENDS

.SUBCKT Domain_Transfer_0_DW_cmp_5 A[31] A[30] A[29] A[28] A[27] A[26] A[25]
+ A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12]
+ A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] TC GE_LT GE_GT_EQ GE_LT_GT_LE EQ_NE p1
+ FE_OFN238_FE_OFN41_raw_prime_21
XFE_RC_2407_0 AO12 $PINS O=n331 A1=n339 B1=n327 B2=n340
XFE_RC_2402_0 AO12 $PINS O=n292 A1=n301 B1=n300 B2=n302
XU161 INV1S $PINS O=n242 I=B[18]
XU162 INV1S $PINS O=n240 I=B[14]
XU163 INV1S $PINS O=n248 I=B[30]
XU164 INV1S $PINS O=n244 I=B[22]
XU165 INV1S $PINS O=n262 I=n317
XU166 INV1S $PINS O=n239 I=B[12]
XU167 INV1S $PINS O=n234 I=B[2]
XU168 INV1S $PINS O=n236 I=B[6]
XU169 INV1S $PINS O=n247 I=B[28]
XU170 INV1S $PINS O=n235 I=B[4]
XU171 INV1S $PINS O=n243 I=B[20]
XU172 INV1S $PINS O=n238 I=B[10]
XU174 INV1S $PINS O=n246 I=B[26]
XU175 INV1S $PINS O=n245 I=B[24]
XU176 INV1S $PINS O=n241 I=B[16]
XU178 INV1S $PINS O=n255 I=n283
XU179 MAOI1S $PINS O=n323 A1=A[2] A2=n230 B1=B[3] B2=A[3]
XU180 AN2 $PINS O=n230 I1=n325 I2=n234
XU181 MAOI1 $PINS O=n335 A1=A[14] A2=n231 B1=B[15] B2=A[15]
XU182 AN2 $PINS O=n231 I1=n338 I2=n240
XU183 MAOI1 $PINS O=n296 A1=A[30] A2=n232 B1=B[31] B2=A[31]
XU184 AN2 $PINS O=n232 I1=n299 I2=n248
XU201 INV1S $PINS O=n233 I=B[0]
XU202 MOAI1S $PINS O=GE_LT_GT_LE A1=n268 A2=n269 B1=n270 B2=n271
XU203 ND3 $PINS O=n271 I1=n272 I2=n273 I3=n274
XU204 OAI22S $PINS O=n273 A1=n275 A2=n276 B1=n276 B2=n277
XU205 MOAI1S $PINS O=n277 A1=B[21] A2=A[21] B1=A[20] B2=n278
XU206 AN2 $PINS O=n278 I1=n279 I2=n243
XU207 MOAI1S $PINS O=n276 A1=B[23] A2=A[23] B1=A[22] B2=n280
XU208 AN2 $PINS O=n280 I1=n281 I2=n244
XU209 OAI112HS $PINS O=n272 A1=n284 B1=n285 C1=n282 C2=n283
XU210 OAI112HS $PINS O=n284 A1=n286 B1=n255 C1=B[17] C2=A[17]
XU211 ND3 $PINS O=n286 I1=n287 I2=n241 I3=A[16]
XU212 MOAI1S $PINS O=n283 A1=B[19] A2=A[19] B1=A[18] B2=n288
XU213 AN2 $PINS O=n288 I1=n289 I2=n242
XU214 ND2 $PINS O=n270 I1=n274 I2=n290
XU215 AOI22S $PINS O=n274 A1=n291 A2=n292 B1=n293 B2=n294
XU216 OAI112HS $PINS O=n294 A1=n295 B1=n296 C1=B[29] C2=A[29]
XU217 ND3 $PINS O=n295 I1=n297 I2=n247 I3=A[28]
XU218 OR2B1S $PINS O=n293 I1=n298 B1=n296
XU220 MOAI1S $PINS O=n302 A1=B[25] A2=A[25] B1=A[24] B2=n303
XU221 AN2 $PINS O=n303 I1=n304 I2=n245
XU222 MOAI1S $PINS O=n301 A1=B[27] A2=A[27] B1=A[26] B2=n305
XU223 AN2 $PINS O=n305 I1=n306 I2=n246
XU224 OR3B2 $PINS O=n269 I1=n290 B1=n285 B2=n282
XU225 OA12 $PINS O=n282 A1=n289 B1=A[18] B2=n242
XU226 ND2 $PINS O=n289 I1=B[19] I2=A[19]
XU227 OA112 $PINS O=n285 A1=n279 B1=n275 C1=A[20] C2=n243
XU228 OA12 $PINS O=n275 A1=n281 B1=A[22] B2=n244
XU229 ND2 $PINS O=n281 I1=B[23] I2=A[23]
XU230 ND2 $PINS O=n279 I1=FE_OFN238_FE_OFN41_raw_prime_21 I2=A[21]
XU231 ND3 $PINS O=n290 I1=n300 I2=n291 I3=n307
XU232 OA12 $PINS O=n307 A1=n304 B1=A[24] B2=n245
XU233 ND2 $PINS O=n304 I1=B[25] I2=A[25]
XU234 OA112 $PINS O=n291 A1=n297 B1=n298 C1=A[28] C2=n247
XU235 OA12 $PINS O=n298 A1=n299 B1=A[30] B2=n248
XU236 ND2 $PINS O=n299 I1=B[31] I2=A[31]
XU237 ND2 $PINS O=n297 I1=B[29] I2=A[29]
XU238 OA12 $PINS O=n300 A1=n306 B1=A[26] B2=n246
XU239 ND2 $PINS O=n306 I1=B[27] I2=A[27]
XU240 OAI112HS $PINS O=n268 A1=n287 B1=n308 C1=A[16] C2=n241
XU241 AOI22S $PINS O=n308 A1=n309 A2=n310 B1=n311 B2=n309
XU242 AOI13HS $PINS O=n311 A1=n314 B1=n262 B2=n312 B3=n313
XU243 AOI22S $PINS O=n314 A1=n315 A2=n316 B1=n316 B2=n317
XU244 OA22 $PINS O=n316 A1=B[7] A2=A[7] B1=p1 B2=n318
XU245 ND2 $PINS O=n318 I1=n319 I2=n236
XU246 AOI13HS $PINS O=n315 A1=n321 B1=n320 B2=n235 B3=A[4]
XU247 NR2 $PINS O=n321 I1=B[5] I2=A[5]
XU248 OA112 $PINS O=n313 A1=n320 B1=n322 C1=A[4] C2=n235
XU249 ND2 $PINS O=n322 I1=n323 I2=n324
XU250 OAI12HS $PINS O=n324 A1=n325 B1=A[2] B2=n234
XU251 ND2 $PINS O=n320 I1=B[5] I2=A[5]
XU252 OAI112HS $PINS O=n312 A1=n326 B1=n323 C1=B[1] C2=A[1]
XU253 ND2 $PINS O=n325 I1=B[3] I2=A[3]
XU254 MOAI1S $PINS O=n326 A1=A[0] A2=n233 B1=A[1] B2=B[1]
XU255 OAI12HS $PINS O=n317 A1=n319 B1=A[6] B2=n236
XU256 ND2 $PINS O=n319 I1=B[7] I2=A[7]
XU257 ND3 $PINS O=n310 I1=n327 I2=n328 I3=n329
XU258 OA12 $PINS O=n329 A1=n330 B1=A[8] B2=B[8]
XU259 AOI22S $PINS O=n309 A1=n328 A2=n331 B1=n332 B2=n333
XU260 OAI112HS $PINS O=n333 A1=n334 B1=n335 C1=B[13] C2=A[13]
XU261 ND3 $PINS O=n334 I1=n336 I2=n239 I3=A[12]
XU262 OR2B1S $PINS O=n332 I1=n337 B1=n335
XU264 MOAI1S $PINS O=n340 A1=B[9] A2=A[9] B1=A[8] B2=n341
XU265 AN2 $PINS O=n341 I1=n330 I2=B[8]
XU266 ND2 $PINS O=n330 I1=B[9] I2=A[9]
XU267 MOAI1S $PINS O=n339 A1=B[11] A2=A[11] B1=A[10] B2=n342
XU268 AN2 $PINS O=n342 I1=n343 I2=n238
XU269 OA12 $PINS O=n327 A1=n343 B1=A[10] B2=n238
XU270 ND2 $PINS O=n343 I1=B[11] I2=A[11]
XU271 OA112 $PINS O=n328 A1=n336 B1=n337 C1=A[12] C2=n239
XU272 OA12 $PINS O=n337 A1=n338 B1=A[14] B2=n240
XU273 ND2 $PINS O=n338 I1=B[15] I2=A[15]
XU274 ND2 $PINS O=n336 I1=B[13] I2=A[13]
XU275 ND2 $PINS O=n287 I1=B[17] I2=A[17]
.ENDS

.SUBCKT Domain_Transfer_0_DW01_add_0 A[32] A[31] A[30] A[29] A[28] A[27] A[26]
+ A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13]
+ A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[32]
+ B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19]
+ B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6]
+ B[5] B[4] B[3] B[2] B[1] B[0] CI SUM[32] SUM[31] SUM[30] SUM[29] SUM[28]
+ SUM[27] SUM[26] SUM[25] SUM[24] SUM[23] SUM[22] SUM[21] SUM[20] SUM[19]
+ SUM[18] SUM[17] SUM[16] SUM[15] SUM[14] SUM[13] SUM[12] SUM[11] SUM[10]
+ SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2] SUM[1] SUM[0] CO
.ENDS

.SUBCKT Domain_Transfer_0_DW01_add_1 A[32] A[31] A[30] A[29] A[28] A[27] A[26]
+ A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13]
+ A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[32]
+ B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19]
+ B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6]
+ B[5] B[4] B[3] B[2] B[1] B[0] CI SUM[32] SUM[31] SUM[30] SUM[29] SUM[28]
+ SUM[27] SUM[26] SUM[25] SUM[24] SUM[23] SUM[22] SUM[21] SUM[20] SUM[19]
+ SUM[18] SUM[17] SUM[16] SUM[15] SUM[14] SUM[13] SUM[12] SUM[11] SUM[10]
+ SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2] SUM[1] SUM[0] CO
+ FE_OFN251_FE_OFN36_raw_prime_26
XFE_OFC650_carry_18 INV2 $PINS O=FE_RN_721_0 I=carry[18]
XFE_OCPC426_carry_30 BUF1S $PINS O=FE_OCPN426_carry_30 I=carry[30]
XFE_OCPC368_carry_25 BUF1S $PINS O=FE_OCPN368_carry_25 I=carry[25]
XFE_RC_2292_0 ND2 $PINS O=FE_RN_1554_0 I1=A[22] I2=B[22]
XFE_RC_2291_0 AN2 $PINS O=FE_RN_1555_0 I1=FE_RN_1558_0 I2=FE_RN_1554_0
XFE_RC_2290_0 XNR2HS $PINS O=FE_RN_1556_0 I1=B[22] I2=A[22]
XFE_RC_2289_0 MXL2HS $PINS OB=SUM[22] S=carry[22] A=FE_RN_1556_0 B=FE_RN_1555_0
XFE_RC_2288_0 ND2 $PINS O=FE_RN_1557_0 I1=A[22] I2=B[22]
XFE_RC_2287_0 OR2S $PINS O=FE_RN_1558_0 I1=B[22] I2=A[22]
XFE_RC_2286_0 ND2 $PINS O=FE_RN_1559_0 I1=FE_RN_1558_0 I2=carry[22]
XFE_RC_2285_0 ND2P $PINS O=carry[23] I1=FE_RN_1559_0 I2=FE_RN_1557_0
XFE_RC_2155_0 ND2S $PINS O=FE_RN_1470_0 I1=A[23] I2=B[23]
XFE_RC_2154_0 AN2 $PINS O=FE_RN_1471_0 I1=FE_RN_1474_0 I2=FE_RN_1470_0
XFE_RC_2153_0 XNR2HS $PINS O=FE_RN_1472_0 I1=B[23] I2=A[23]
XFE_RC_2152_0 MXL2HS $PINS OB=SUM[23] S=carry[23] A=FE_RN_1472_0 B=FE_RN_1471_0
XFE_RC_2151_0 ND2S $PINS O=FE_RN_1473_0 I1=A[23] I2=B[23]
XFE_RC_2150_0 OR2S $PINS O=FE_RN_1474_0 I1=B[23] I2=A[23]
XFE_RC_2149_0 ND2 $PINS O=FE_RN_1475_0 I1=FE_RN_1474_0 I2=carry[23]
XFE_RC_2148_0 ND2P $PINS O=carry[24] I1=FE_RN_1475_0 I2=FE_RN_1473_0
XFE_RC_1969_0 INV1S $PINS O=FE_RN_1331_0 I=carry[24]
XFE_RC_1968_0 XOR2HS $PINS O=FE_RN_1332_0 I1=B[24] I2=A[24]
XFE_RC_1967_0 INV1S $PINS O=FE_RN_1333_0 I=FE_RN_1332_0
XFE_RC_1966_0 MXL2HS $PINS OB=SUM[24] S=FE_RN_1333_0 A=carry[24] B=FE_RN_1331_0
XFE_RC_1965_0 NR2 $PINS O=FE_RN_1334_0 I1=B[24] I2=A[24]
XFE_RC_1963_0 MOAI1 $PINS O=carry[25] A1=FE_RN_1331_0 A2=FE_RN_1334_0 B1=A[24]
+ B2=B[24]
XFE_RC_1766_0 ND2S $PINS O=FE_RN_1178_0 I1=A[25] I2=B[25]
XFE_RC_1765_0 AN2 $PINS O=FE_RN_1179_0 I1=FE_RN_1182_0 I2=FE_RN_1178_0
XFE_RC_1764_0 XNR2HS $PINS O=FE_RN_1180_0 I1=B[25] I2=A[25]
XFE_RC_1763_0 MXL2HS $PINS OB=SUM[25] S=FE_OCPN368_carry_25 A=FE_RN_1180_0
+ B=FE_RN_1179_0
XFE_RC_1762_0 ND2S $PINS O=FE_RN_1181_0 I1=A[25] I2=B[25]
XFE_RC_1761_0 OR2S $PINS O=FE_RN_1182_0 I1=B[25] I2=A[25]
XFE_RC_1760_0 ND2 $PINS O=FE_RN_1183_0 I1=FE_RN_1182_0 I2=carry[25]
XFE_RC_1759_0 ND2P $PINS O=carry[26] I1=FE_RN_1183_0 I2=FE_RN_1181_0
XFE_RC_1518_0 INV1S $PINS O=FE_RN_992_0 I=FE_RN_1000_0
XFE_RC_1517_0 AOI12HS $PINS O=FE_RN_993_0 A1=FE_RN_992_0 B1=A[16] B2=B[16]
XFE_RC_1516_0 INV1S $PINS O=FE_RN_994_0 I=A[16]
XFE_RC_1515_0 INV1S $PINS O=FE_RN_995_0 I=A[16]
XFE_RC_1514_0 NR2 $PINS O=FE_RN_996_0 I1=B[16] I2=FE_RN_995_0
XFE_RC_1513_0 AOI12HS $PINS O=FE_RN_997_0 A1=FE_RN_996_0 B1=FE_RN_994_0
+ B2=B[16]
XFE_RC_1512_0 MXL2HS $PINS OB=SUM[16] S=carry[16] A=FE_RN_997_0 B=FE_RN_993_0
XFE_RC_1511_0 ND2 $PINS O=FE_RN_998_0 I1=A[16] I2=B[16]
XFE_RC_1510_0 INV1S $PINS O=FE_RN_999_0 I=A[16]
XFE_RC_1509_0 OR2B1S $PINS O=FE_RN_1000_0 I1=B[16] B1=FE_RN_999_0
XFE_RC_1508_0 ND2 $PINS O=FE_RN_1001_0 I1=FE_RN_1000_0 I2=carry[16]
XFE_RC_1507_0 ND2P $PINS O=carry[17] I1=FE_RN_1001_0 I2=FE_RN_998_0
XFE_RC_1271_0 ND2S $PINS O=FE_RN_812_0 I1=A[17] I2=B[17]
XFE_RC_1270_0 AN2 $PINS O=FE_RN_813_0 I1=FE_RN_816_0 I2=FE_RN_812_0
XFE_RC_1269_0 XNR2HS $PINS O=FE_RN_814_0 I1=B[17] I2=A[17]
XFE_RC_1268_0 MXL2HS $PINS OB=SUM[17] S=carry[17] A=FE_RN_814_0 B=FE_RN_813_0
XFE_RC_1267_0 ND2S $PINS O=FE_RN_815_0 I1=A[17] I2=B[17]
XFE_RC_1266_0 OR2S $PINS O=FE_RN_816_0 I1=B[17] I2=A[17]
XFE_RC_1265_0 ND2 $PINS O=FE_RN_817_0 I1=FE_RN_816_0 I2=carry[17]
XFE_RC_1264_0 ND2P $PINS O=carry[18] I1=FE_RN_817_0 I2=FE_RN_815_0
XFE_RC_1136_0 INV1S $PINS O=FE_RN_718_0 I=FE_RN_722_0
XFE_RC_1135_0 AOI12HS $PINS O=FE_RN_719_0 A1=FE_RN_718_0 B1=A[18] B2=B[18]
XFE_RC_1134_0 XNR2HS $PINS O=FE_RN_720_0 I1=B[18] I2=A[18]
XFE_RC_1133_0 MXL2HS $PINS OB=SUM[18] S=carry[18] A=FE_RN_720_0 B=FE_RN_719_0
XFE_RC_1131_0 OR2S $PINS O=FE_RN_722_0 I1=B[18] I2=A[18]
XFE_RC_1129_0 MOAI1 $PINS O=carry[19] A1=FE_RN_718_0 A2=FE_RN_721_0 B1=A[18]
+ B2=B[18]
XFE_RC_914_0 ND2S $PINS O=FE_RN_553_0 I1=A[19] I2=B[19]
XFE_RC_913_0 AN2 $PINS O=FE_RN_554_0 I1=FE_RN_557_0 I2=FE_RN_553_0
XFE_RC_912_0 XNR2HS $PINS O=FE_RN_555_0 I1=B[19] I2=A[19]
XFE_RC_911_0 MXL2HS $PINS OB=SUM[19] S=carry[19] A=FE_RN_555_0 B=FE_RN_554_0
XFE_RC_910_0 ND2S $PINS O=FE_RN_556_0 I1=A[19] I2=B[19]
XFE_RC_909_0 OR2S $PINS O=FE_RN_557_0 I1=B[19] I2=A[19]
XFE_RC_908_0 ND2 $PINS O=FE_RN_558_0 I1=FE_RN_557_0 I2=carry[19]
XFE_RC_907_0 ND2P $PINS O=carry[20] I1=FE_RN_558_0 I2=FE_RN_556_0
XFE_RC_774_0 INV1S $PINS O=FE_RN_450_0 I=carry[20]
XFE_RC_773_0 XOR2HS $PINS O=FE_RN_451_0 I1=B[20] I2=A[20]
XFE_RC_772_0 INV1S $PINS O=FE_RN_452_0 I=FE_RN_451_0
XFE_RC_771_0 MXL2HS $PINS OB=SUM[20] S=FE_RN_452_0 A=carry[20] B=FE_RN_450_0
XFE_RC_770_0 NR2 $PINS O=FE_RN_453_0 I1=B[20] I2=A[20]
XFE_RC_768_0 MOAI1 $PINS O=carry[21] A1=FE_RN_450_0 A2=FE_RN_453_0 B1=A[20]
+ B2=B[20]
XFE_RC_596_0 ND2S $PINS O=FE_RN_323_0 I1=A[10] I2=B[10]
XFE_RC_595_0 AN2 $PINS O=FE_RN_324_0 I1=FE_RN_327_0 I2=FE_RN_323_0
XFE_RC_594_0 XNR2HS $PINS O=FE_RN_325_0 I1=B[10] I2=A[10]
XFE_RC_593_0 MXL2HS $PINS OB=SUM[10] S=carry[10] A=FE_RN_325_0 B=FE_RN_324_0
XFE_RC_592_0 ND2S $PINS O=FE_RN_326_0 I1=A[10] I2=B[10]
XFE_RC_591_0 OR2 $PINS O=FE_RN_327_0 I1=B[10] I2=A[10]
XFE_RC_590_0 ND2 $PINS O=FE_RN_328_0 I1=FE_RN_327_0 I2=carry[10]
XFE_RC_589_0 ND2 $PINS O=carry[11] I1=FE_RN_328_0 I2=FE_RN_326_0
XFE_RC_394_0 ND3P $PINS O=carry[30] I1=n8 I2=n7 I3=n6
XFE_RC_393_0 ND2S $PINS O=FE_RN_182_0 I1=A[26]
+ I2=FE_OFN251_FE_OFN36_raw_prime_26
XFE_RC_392_0 AN2 $PINS O=FE_RN_183_0 I1=FE_RN_186_0 I2=FE_RN_182_0
XFE_RC_391_0 XNR2HS $PINS O=FE_RN_184_0 I1=FE_OFN251_FE_OFN36_raw_prime_26
+ I2=A[26]
XFE_RC_390_0 MXL2HS $PINS OB=SUM[26] S=carry[26] A=FE_RN_184_0 B=FE_RN_183_0
XFE_RC_389_0 ND2S $PINS O=FE_RN_185_0 I1=A[26]
+ I2=FE_OFN251_FE_OFN36_raw_prime_26
XFE_RC_388_0 OR2S $PINS O=FE_RN_186_0 I1=B[26] I2=A[26]
XFE_RC_387_0 ND2 $PINS O=FE_RN_187_0 I1=FE_RN_186_0 I2=carry[26]
XFE_RC_386_0 ND2P $PINS O=carry[27] I1=FE_RN_187_0 I2=FE_RN_185_0
XFE_RC_156_0 ND2S $PINS O=FE_RN_47_0 I1=A[11] I2=B[11]
XFE_RC_155_0 AN2 $PINS O=FE_RN_48_0 I1=FE_RN_51_0 I2=FE_RN_47_0
XFE_RC_154_0 XNR2HS $PINS O=FE_RN_49_0 I1=B[11] I2=A[11]
XFE_RC_153_0 MXL2HS $PINS OB=SUM[11] S=carry[11] A=FE_RN_49_0 B=FE_RN_48_0
XFE_RC_152_0 ND2S $PINS O=FE_RN_50_0 I1=A[11] I2=B[11]
XFE_RC_151_0 OR2S $PINS O=FE_RN_51_0 I1=B[11] I2=A[11]
XFE_RC_150_0 ND2 $PINS O=FE_RN_52_0 I1=FE_RN_51_0 I2=carry[11]
XFE_RC_149_0 ND2P $PINS O=carry[12] I1=FE_RN_52_0 I2=FE_RN_50_0
XFE_RC_148_0 OR2 $PINS O=FE_RN_46_0 I1=A[14] I2=B[14]
XFE_RC_147_0 ND2P $PINS O=FE_RN_18_0 I1=carry[14] I2=FE_RN_46_0
XFE_RC_41_0 INV1S $PINS O=FE_RN_10_0 I=FE_RN_14_0
XFE_RC_40_0 INV1S $PINS O=FE_RN_11_0 I=A[14]
XFE_RC_39_0 INV1S $PINS O=FE_RN_12_0 I=A[14]
XFE_RC_38_0 ND2 $PINS O=FE_RN_13_0 I1=FE_RN_12_0 I2=B[14]
XFE_RC_37_0 OAI12HS $PINS O=FE_RN_14_0 A1=FE_RN_13_0 B1=FE_RN_11_0 B2=B[14]
XFE_RC_35_0 ND2 $PINS O=FE_RN_16_0 I1=FE_RN_10_0 I2=carry[14]
XFE_RC_34_0 OAI12HS $PINS O=SUM[14] A1=FE_RN_16_0 B1=FE_RN_10_0 B2=carry[14]
XFE_RC_33_0 ND2 $PINS O=FE_RN_17_0 I1=A[14] I2=B[14]
XFE_RC_31_0 ND2P $PINS O=carry[15] I1=FE_RN_18_0 I2=FE_RN_17_0
XFE_RC_18_0 ND3P $PINS O=carry[28] I1=n15 I2=n14 I3=n13
XFE_RC_17_0 XOR3 $PINS O=SUM[12] I1=A[12] I2=B[12] I3=carry[12]
XFE_RC_16_0 MAO222P $PINS O=carry[13] A1=A[12] B1=B[12] C1=carry[12]
XU1_21 FA1 $PINS S=SUM[21] CO=carry[22] A=A[21] B=B[21] CI=carry[21]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_8 FA1 $PINS S=SUM[8] CO=carry[9] A=A[8] B=B[8] CI=carry[8]
XU1_3 FA1 $PINS S=SUM[3] CO=carry[4] A=A[3] B=B[3] CI=carry[3]
XU1_2 FA1 $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1_1 FA1 $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=carry[1]
XU1 ND3P $PINS O=carry[31] I1=n12 I2=n11 I3=n10
XU2 XOR3 $PINS O=SUM[4] I1=B[4] I2=A[4] I3=carry[4]
XU3 ND2 $PINS O=n1 I1=carry[4] I2=B[4]
XU4 ND2 $PINS O=n2 I1=carry[4] I2=A[4]
XU5 ND2 $PINS O=n3 I1=B[4] I2=A[4]
XU6 ND3P $PINS O=carry[5] I1=n1 I2=n2 I3=n3
XU7 ND2 $PINS O=n29 I1=carry[31] I2=A[31]
XU8 ND2P $PINS O=n28 I1=carry[31] I2=B[31]
XU9 ND2 $PINS O=n20 I1=A[6] I2=B[6]
XU10 ND2 $PINS O=n6 I1=A[29] I2=B[29]
XU11 ND2 $PINS O=n13 I1=A[27] I2=B[27]
XU12 XOR3 $PINS O=SUM[6] I1=A[6] I2=B[6] I3=carry[6]
XU13 XOR3 $PINS O=SUM[5] I1=B[5] I2=A[5] I3=carry[5]
XU14 XOR3 $PINS O=SUM[15] I1=B[15] I2=A[15] I3=carry[15]
XU15 XOR3 $PINS O=SUM[27] I1=A[27] I2=B[27] I3=carry[27]
XU16 XOR3 $PINS O=SUM[29] I1=A[29] I2=B[29] I3=carry[29]
XU18 XOR3 $PINS O=SUM[13] I1=B[13] I2=A[13] I3=carry[13]
XU20 ND2 $PINS O=n7 I1=A[29] I2=carry[29]
XU21 ND2 $PINS O=n8 I1=B[29] I2=carry[29]
XU23 XOR2HS $PINS O=n9 I1=A[30] I2=B[30]
XU24 XOR2HS $PINS O=SUM[30] I1=n9 I2=FE_OCPN426_carry_30
XU25 ND2S $PINS O=n10 I1=A[30] I2=B[30]
XU26 ND2 $PINS O=n11 I1=A[30] I2=carry[30]
XU27 ND2 $PINS O=n12 I1=B[30] I2=carry[30]
XU28 ND2 $PINS O=n14 I1=A[27] I2=carry[27]
XU29 ND2 $PINS O=n15 I1=B[27] I2=carry[27]
XU31 XOR2HS $PINS O=n16 I1=A[28] I2=B[28]
XU32 XOR2HS $PINS O=SUM[28] I1=carry[28] I2=n16
XU33 ND2S $PINS O=n17 I1=A[28] I2=B[28]
XU34 ND2 $PINS O=n18 I1=A[28] I2=carry[28]
XU35 ND2 $PINS O=n19 I1=B[28] I2=carry[28]
XU36 ND3P $PINS O=carry[29] I1=n19 I2=n18 I3=n17
XU37 ND3 $PINS O=carry[8] I1=n25 I2=n26 I3=n24
XU38 ND2 $PINS O=n21 I1=A[6] I2=carry[6]
XU39 ND2 $PINS O=n22 I1=B[6] I2=carry[6]
XU40 ND3P $PINS O=carry[7] I1=n22 I2=n21 I3=n20
XU41 XOR2HS $PINS O=n23 I1=A[7] I2=B[7]
XU42 XOR2HS $PINS O=SUM[7] I1=n23 I2=carry[7]
XU43 ND2 $PINS O=n24 I1=A[7] I2=B[7]
XU44 ND2 $PINS O=n25 I1=A[7] I2=carry[7]
XU45 ND2 $PINS O=n26 I1=B[7] I2=carry[7]
XU46 XOR2HS $PINS O=n27 I1=B[31] I2=A[31]
XU47 XOR2HS $PINS O=SUM[31] I1=carry[31] I2=n27
XU48 ND2S $PINS O=n30 I1=B[31] I2=A[31]
XU49 ND3P $PINS O=SUM[32] I1=n29 I2=n28 I3=n30
XU50 ND2P $PINS O=n31 I1=carry[15] I2=B[15]
XU51 ND2 $PINS O=n32 I1=carry[15] I2=A[15]
XU52 ND2S $PINS O=n33 I1=B[15] I2=A[15]
XU53 ND3P $PINS O=carry[16] I1=n32 I2=n31 I3=n33
XU54 AN2T $PINS O=carry[1] I1=B[0] I2=A[0]
XU55 ND2 $PINS O=n34 I1=carry[5] I2=B[5]
XU56 ND2 $PINS O=n35 I1=carry[5] I2=A[5]
XU57 ND2 $PINS O=n36 I1=B[5] I2=A[5]
XU58 ND3P $PINS O=carry[6] I1=n35 I2=n34 I3=n36
XU59 ND2 $PINS O=n37 I1=carry[13] I2=B[13]
XU60 ND2 $PINS O=n38 I1=carry[13] I2=A[13]
XU61 ND2 $PINS O=n39 I1=B[13] I2=A[13]
XU62 ND3P $PINS O=carry[14] I1=n37 I2=n38 I3=n39
.ENDS

.SUBCKT Domain_Transfer_0_DW01_add_2 A[32] A[31] A[30] A[29] A[28] A[27] A[26]
+ A[25] A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13]
+ A[12] A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[32]
+ B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19]
+ B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6]
+ B[5] B[4] B[3] B[2] B[1] B[0] CI SUM[32] SUM[31] SUM[30] SUM[29] SUM[28]
+ SUM[27] SUM[26] SUM[25] SUM[24] SUM[23] SUM[22] SUM[21] SUM[20] SUM[19]
+ SUM[18] SUM[17] SUM[16] SUM[15] SUM[14] SUM[13] SUM[12] SUM[11] SUM[10]
+ SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2] SUM[1] SUM[0] CO
+ FE_OFN194_FE_OFN56_raw_prime_6 FE_OFN228_FE_OFN43_raw_prime_19
+ FE_OFN272_FE_OFN31_raw_prime_31 FE_OFN318_raw_prime_14
XFE_RC_2386_0 XNR2HS $PINS O=FE_RN_615_0 I1=A[18] I2=B[18]
XFE_OFC623_raw_prime_2 INV1S $PINS O=FE_OFN648_raw_prime_2 I=B[2]
XFE_OCPC449_carry_25 BUF1S $PINS O=FE_OCPN449_carry_25 I=carry[25]
XFE_OCPC371_carry_20 BUF1S $PINS O=FE_OCPN371_carry_20 I=carry[20]
XFE_RC_2326_0 INV1S $PINS O=FE_RN_1567_0 I=A[14]
XFE_RC_2325_0 INV2 $PINS O=FE_RN_1568_0 I=B[14]
XFE_RC_2324_0 OAI22H $PINS O=carry[15] A1=FE_RN_329_0 A2=FE_RN_332_0
+ B1=FE_RN_1568_0 B2=FE_RN_1567_0
XFE_OCPC292_carry_24 BUF1S $PINS O=FE_OCPN292_carry_24 I=carry[24]
XFE_RC_2256_0 INV1S $PINS O=FE_RN_1549_0 I=A[19]
XFE_RC_2255_0 INV2 $PINS O=FE_RN_1550_0 I=B[19]
XFE_RC_2254_0 OAI22H $PINS O=carry[20] A1=FE_RN_430_0 A2=FE_RN_427_0
+ B1=FE_RN_1550_0 B2=FE_RN_1549_0
XFE_RC_2235_0 INV1S $PINS O=FE_RN_1530_0 I=FE_RN_1534_0
XFE_RC_2234_0 AOI12HS $PINS O=FE_RN_1531_0 A1=FE_RN_1530_0 B1=A[31]
+ B2=FE_OFN272_FE_OFN31_raw_prime_31
XFE_RC_2233_0 XNR2HS $PINS O=FE_RN_1532_0 I1=FE_OFN272_FE_OFN31_raw_prime_31
+ I2=A[31]
XFE_RC_2232_0 MXL2HS $PINS OB=SUM[31] S=carry[31] A=FE_RN_1532_0 B=FE_RN_1531_0
XFE_RC_2231_0 ND2 $PINS O=FE_RN_1533_0 I1=A[31] I2=B[31]
XFE_RC_2230_0 OR2 $PINS O=FE_RN_1534_0 I1=FE_OFN272_FE_OFN31_raw_prime_31
+ I2=A[31]
XFE_RC_2229_0 ND2 $PINS O=FE_RN_1535_0 I1=FE_RN_1534_0 I2=carry[31]
XFE_RC_2228_0 ND2 $PINS O=SUM[32] I1=FE_RN_1535_0 I2=FE_RN_1533_0
XFE_RC_2227_0 INV1S $PINS O=FE_RN_1523_0 I=FE_RN_1524_0
XFE_RC_2226_0 XOR2HS $PINS O=FE_RN_1524_0 I1=B[3] I2=A[3]
XFE_RC_2224_0 ND2 $PINS O=FE_RN_1526_0 I1=FE_RN_1523_0 I2=carry[3]
XFE_RC_2223_0 OAI12HS $PINS O=SUM[3] A1=FE_RN_1526_0 B1=FE_RN_1523_0
+ B2=carry[3]
XFE_RC_2222_0 ND2 $PINS O=FE_RN_1527_0 I1=A[3] I2=B[3]
XFE_RC_2221_0 OR2 $PINS O=FE_RN_1528_0 I1=B[3] I2=A[3]
XFE_RC_2220_0 ND2 $PINS O=FE_RN_1529_0 I1=carry[3] I2=FE_RN_1528_0
XFE_RC_2219_0 ND2 $PINS O=carry[4] I1=FE_RN_1529_0 I2=FE_RN_1527_0
XFE_RC_2145_0 INV1S $PINS O=FE_RN_1463_0 I=FE_RN_1464_0
XFE_RC_2144_0 XOR2HS $PINS O=FE_RN_1464_0 I1=B[1] I2=A[1]
XFE_RC_2142_0 ND2 $PINS O=FE_RN_1466_0 I1=FE_RN_1463_0 I2=carry[1]
XFE_RC_2141_0 OAI12HS $PINS O=SUM[1] A1=FE_RN_1466_0 B1=FE_RN_1463_0
+ B2=carry[1]
XFE_RC_2140_0 ND2 $PINS O=FE_RN_1467_0 I1=A[1] I2=B[1]
XFE_RC_2139_0 OAI12HS $PINS O=FE_RN_1468_0 A1=carry[1] B1=A[1] B2=B[1]
XFE_RC_2138_0 ND2P $PINS O=carry[2] I1=FE_RN_1468_0 I2=FE_RN_1467_0
XFE_RC_2137_0 ND2 $PINS O=FE_RN_1457_0 I1=A[4] I2=B[4]
XFE_RC_2136_0 AN2 $PINS O=FE_RN_1458_0 I1=FE_RN_1461_0 I2=FE_RN_1457_0
XFE_RC_2135_0 XNR2HS $PINS O=FE_RN_1459_0 I1=B[4] I2=A[4]
XFE_RC_2134_0 MXL2HS $PINS OB=SUM[4] S=carry[4] A=FE_RN_1459_0 B=FE_RN_1458_0
XFE_RC_2133_0 ND2 $PINS O=FE_RN_1460_0 I1=A[4] I2=B[4]
XFE_RC_2132_0 OR2 $PINS O=FE_RN_1461_0 I1=B[4] I2=A[4]
XFE_RC_2131_0 ND2 $PINS O=FE_RN_1462_0 I1=FE_RN_1461_0 I2=carry[4]
XFE_RC_2130_0 ND2 $PINS O=carry[5] I1=FE_RN_1462_0 I2=FE_RN_1460_0
XFE_RC_2083_0 INV1S $PINS O=FE_RN_1420_0 I=A[6]
XFE_RC_2082_0 INV1S $PINS O=FE_RN_1421_0 I=B[6]
XFE_RC_2081_0 OAI22H $PINS O=carry[7] A1=FE_RN_1395_0 A2=FE_RN_1398_0
+ B1=FE_RN_1421_0 B2=FE_RN_1420_0
XFE_RC_2054_0 INV1S $PINS O=FE_RN_1395_0 I=FE_RN_1399_0
XFE_RC_2053_0 AOI12HS $PINS O=FE_RN_1396_0 A1=FE_RN_1395_0 B1=A[6]
+ B2=FE_OFN194_FE_OFN56_raw_prime_6
XFE_RC_2052_0 XNR2HS $PINS O=FE_RN_1397_0 I1=FE_OFN194_FE_OFN56_raw_prime_6
+ I2=A[6]
XFE_RC_2051_0 MXL2HS $PINS OB=SUM[6] S=carry[6] A=FE_RN_1397_0 B=FE_RN_1396_0
XFE_RC_2050_0 INV1S $PINS O=FE_RN_1398_0 I=carry[6]
XFE_RC_2049_0 OR2 $PINS O=FE_RN_1399_0 I1=FE_OFN194_FE_OFN56_raw_prime_6
+ I2=A[6]
XFE_RC_2046_0 ND2P $PINS O=FE_RN_1393_0 I1=carry[22] I2=B[22]
XFE_RC_2045_0 AOI22H $PINS O=FE_RN_1394_0 A1=B[22] A2=A[22] B1=carry[22]
+ B2=A[22]
XFE_RC_2044_0 ND2P $PINS O=carry[23] I1=FE_RN_1394_0 I2=FE_RN_1393_0
XFE_RC_1852_0 INV1S $PINS O=FE_RN_1238_0 I=FE_RN_1246_0
XFE_RC_1851_0 AOI12HS $PINS O=FE_RN_1239_0 A1=FE_RN_1238_0 B1=A[13] B2=B[13]
XFE_RC_1850_0 INV1S $PINS O=FE_RN_1240_0 I=A[13]
XFE_RC_1849_0 INV1S $PINS O=FE_RN_1241_0 I=A[13]
XFE_RC_1848_0 NR2 $PINS O=FE_RN_1242_0 I1=B[13] I2=FE_RN_1241_0
XFE_RC_1847_0 AOI12HS $PINS O=FE_RN_1243_0 A1=FE_RN_1242_0 B1=FE_RN_1240_0
+ B2=B[13]
XFE_RC_1846_0 MXL2HS $PINS OB=SUM[13] S=carry[13] A=FE_RN_1243_0 B=FE_RN_1239_0
XFE_RC_1845_0 ND2 $PINS O=FE_RN_1244_0 I1=A[13] I2=B[13]
XFE_RC_1844_0 INV1S $PINS O=FE_RN_1245_0 I=A[13]
XFE_RC_1843_0 OR2B1S $PINS O=FE_RN_1246_0 I1=B[13] B1=FE_RN_1245_0
XFE_RC_1842_0 ND2 $PINS O=FE_RN_1247_0 I1=FE_RN_1246_0 I2=carry[13]
XFE_RC_1841_0 ND2 $PINS O=carry[14] I1=FE_RN_1247_0 I2=FE_RN_1244_0
XFE_RC_1554_0 INV1S $PINS O=FE_RN_1022_0 I=FE_RN_1026_0
XFE_RC_1553_0 AOI12HS $PINS O=FE_RN_1023_0 A1=FE_RN_1022_0 B1=A[24] B2=B[24]
XFE_RC_1552_0 XNR2HS $PINS O=FE_RN_1024_0 I1=B[24] I2=A[24]
XFE_RC_1551_0 MXL2HS $PINS OB=SUM[24] S=FE_OCPN292_carry_24 A=FE_RN_1024_0
+ B=FE_RN_1023_0
XFE_RC_1550_0 ND2 $PINS O=FE_RN_1025_0 I1=A[24] I2=B[24]
XFE_RC_1549_0 OR2 $PINS O=FE_RN_1026_0 I1=B[24] I2=A[24]
XFE_RC_1548_0 ND2 $PINS O=FE_RN_1027_0 I1=FE_RN_1026_0 I2=carry[24]
XFE_RC_1547_0 ND2 $PINS O=carry[25] I1=FE_RN_1027_0 I2=FE_RN_1025_0
XFE_RC_1303_0 ND2S $PINS O=FE_RN_833_0 I1=A[25] I2=B[25]
XFE_RC_1302_0 AN2 $PINS O=FE_RN_834_0 I1=FE_RN_837_0 I2=FE_RN_833_0
XFE_RC_1301_0 XNR2HS $PINS O=FE_RN_835_0 I1=B[25] I2=A[25]
XFE_RC_1300_0 MXL2HS $PINS OB=SUM[25] S=FE_OCPN449_carry_25 A=FE_RN_835_0
+ B=FE_RN_834_0
XFE_RC_1299_0 ND2S $PINS O=FE_RN_836_0 I1=A[25] I2=B[25]
XFE_RC_1298_0 OR2S $PINS O=FE_RN_837_0 I1=B[25] I2=A[25]
XFE_RC_1297_0 ND2 $PINS O=FE_RN_838_0 I1=FE_RN_837_0 I2=carry[25]
XFE_RC_1296_0 ND2 $PINS O=carry[26] I1=FE_RN_838_0 I2=FE_RN_836_0
XFE_RC_1172_0 ND2S $PINS O=FE_RN_744_0 I1=A[26] I2=B[26]
XFE_RC_1171_0 AN2 $PINS O=FE_RN_745_0 I1=FE_RN_748_0 I2=FE_RN_744_0
XFE_RC_1170_0 XNR2HS $PINS O=FE_RN_746_0 I1=B[26] I2=A[26]
XFE_RC_1169_0 MXL2HS $PINS OB=SUM[26] S=carry[26] A=FE_RN_746_0 B=FE_RN_745_0
XFE_RC_1168_0 ND2S $PINS O=FE_RN_747_0 I1=A[26] I2=B[26]
XFE_RC_1167_0 OR2S $PINS O=FE_RN_748_0 I1=B[26] I2=A[26]
XFE_RC_1166_0 ND2 $PINS O=FE_RN_749_0 I1=FE_RN_748_0 I2=carry[26]
XFE_RC_1165_0 ND2P $PINS O=carry[27] I1=FE_RN_749_0 I2=FE_RN_747_0
XFE_RC_994_0 INV1S $PINS O=FE_RN_611_0 I=FE_RN_618_0
XFE_RC_993_0 AOI12HS $PINS O=FE_RN_612_0 A1=FE_RN_611_0 B1=A[18] B2=B[18]
XFE_RC_989_0 MXL2HS $PINS OB=SUM[18] S=carry[18] A=FE_RN_615_0 B=FE_RN_612_0
XFE_RC_988_0 ND2 $PINS O=FE_RN_616_0 I1=A[18] I2=B[18]
XFE_RC_987_0 INV1S $PINS O=FE_RN_617_0 I=A[18]
XFE_RC_986_0 OR2B1S $PINS O=FE_RN_618_0 I1=B[18] B1=FE_RN_617_0
XFE_RC_985_0 ND2 $PINS O=FE_RN_619_0 I1=FE_RN_618_0 I2=carry[18]
XFE_RC_984_0 ND2 $PINS O=carry[19] I1=FE_RN_619_0 I2=FE_RN_616_0
XFE_RC_741_0 INV1S $PINS O=FE_RN_427_0 I=carry[19]
XFE_RC_740_0 XOR2HS $PINS O=FE_RN_428_0 I1=FE_OFN228_FE_OFN43_raw_prime_19
+ I2=A[19]
XFE_RC_739_0 INV1S $PINS O=FE_RN_429_0 I=FE_RN_428_0
XFE_RC_738_0 MXL2HS $PINS OB=SUM[19] S=FE_RN_429_0 A=carry[19] B=FE_RN_427_0
XFE_RC_737_0 NR2 $PINS O=FE_RN_430_0 I1=FE_OFN228_FE_OFN43_raw_prime_19
+ I2=A[19]
XFE_RC_604_0 INV1S $PINS O=FE_RN_329_0 I=FE_RN_333_0
XFE_RC_603_0 AOI12HS $PINS O=FE_RN_330_0 A1=FE_RN_329_0 B1=A[14]
+ B2=FE_OFN318_raw_prime_14
XFE_RC_602_0 XNR2HS $PINS O=FE_RN_331_0 I1=FE_OFN318_raw_prime_14 I2=A[14]
XFE_RC_601_0 MXL2HS $PINS OB=SUM[14] S=carry[14] A=FE_RN_331_0 B=FE_RN_330_0
XFE_RC_600_0 INV1S $PINS O=FE_RN_332_0 I=carry[14]
XFE_RC_599_0 OR2S $PINS O=FE_RN_333_0 I1=FE_OFN318_raw_prime_14 I2=A[14]
XFE_RC_458_0 ND2S $PINS O=FE_RN_226_0 I1=A[15] I2=B[15]
XFE_RC_457_0 AN2 $PINS O=FE_RN_227_0 I1=FE_RN_230_0 I2=FE_RN_226_0
XFE_RC_456_0 XNR2HS $PINS O=FE_RN_228_0 I1=B[15] I2=A[15]
XFE_RC_455_0 MXL2HS $PINS OB=SUM[15] S=carry[15] A=FE_RN_228_0 B=FE_RN_227_0
XFE_RC_454_0 ND2S $PINS O=FE_RN_229_0 I1=A[15] I2=B[15]
XFE_RC_453_0 OR2S $PINS O=FE_RN_230_0 I1=B[15] I2=A[15]
XFE_RC_452_0 ND2 $PINS O=FE_RN_231_0 I1=FE_RN_230_0 I2=carry[15]
XFE_RC_451_0 ND2 $PINS O=carry[16] I1=FE_RN_231_0 I2=FE_RN_229_0
XFE_RC_264_0 INV1S $PINS O=FE_RN_105_0 I=FE_RN_110_0
XFE_RC_263_0 AOI12HS $PINS O=FE_RN_106_0 A1=FE_RN_105_0 B1=A[21] B2=B[21]
XFE_RC_262_0 XNR2HS $PINS O=FE_RN_107_0 I1=B[21] I2=A[21]
XFE_RC_261_0 MXL2HS $PINS OB=SUM[21] S=carry[21] A=FE_RN_107_0 B=FE_RN_106_0
XFE_RC_260_0 ND2 $PINS O=FE_RN_108_0 I1=A[21] I2=B[21]
XFE_RC_259_0 INV1S $PINS O=FE_RN_109_0 I=A[21]
XFE_RC_258_0 OR2B1S $PINS O=FE_RN_110_0 I1=B[21] B1=FE_RN_109_0
XFE_RC_257_0 ND2 $PINS O=FE_RN_111_0 I1=FE_RN_110_0 I2=carry[21]
XFE_RC_256_0 ND2P $PINS O=carry[22] I1=FE_RN_111_0 I2=FE_RN_108_0
XFE_RC_123_0 ND3P $PINS O=carry[11] I1=n20 I2=n21 I3=n19
XFE_RC_118_0 XOR3 $PINS O=SUM[22] I1=A[22] I2=B[22] I3=carry[22]
XFE_RC_94_0 ND3P $PINS O=carry[18] I1=n12 I2=n11 I3=n10
XFE_RC_62_0 ND3P $PINS O=carry[12] I1=n25 I2=n24 I3=n23
XFE_RC_50_0 ND3P $PINS O=carry[17] I1=n8 I2=n7 I3=n6
XU1_5 FA1 $PINS S=SUM[5] CO=carry[6] A=A[5] B=B[5] CI=carry[5]
XU1_2 FA1 $PINS S=SUM[2] CO=carry[3] A=A[2] B=FE_OFN648_raw_prime_2 CI=carry[2]
XU1 ND3P $PINS O=carry[8] I1=n1 I2=n2 I3=n3
XU2 ND3HT $PINS O=carry[30] I1=n42 I2=n41 I3=n40
XU3 XOR3 $PINS O=SUM[12] I1=B[12] I2=A[12] I3=carry[12]
XU4 XOR3 $PINS O=SUM[7] I1=B[7] I2=A[7] I3=carry[7]
XU5 ND2 $PINS O=n1 I1=carry[7] I2=B[7]
XU6 ND2 $PINS O=n2 I1=carry[7] I2=A[7]
XU7 ND2 $PINS O=n3 I1=B[7] I2=A[7]
XU9 ND2P $PINS O=n31 I1=carry[30] I2=A[30]
XU10 ND2 $PINS O=n36 I1=A[28] I2=B[28]
XU11 ND3P $PINS O=carry[9] I1=n13 I2=n14 I3=n15
XU12 ND2 $PINS O=n19 I1=A[10] I2=B[10]
XU13 ND2 $PINS O=n6 I1=A[16] I2=B[16]
XU14 XOR3 $PINS O=SUM[9] I1=B[9] I2=A[9] I3=carry[9]
XU15 XOR3 $PINS O=SUM[8] I1=B[8] I2=A[8] I3=carry[8]
XU16 XOR3 $PINS O=SUM[10] I1=A[10] I2=B[10] I3=carry[10]
XU17 XOR3 $PINS O=SUM[16] I1=A[16] I2=B[16] I3=carry[16]
XU18 XOR3 $PINS O=SUM[20] I1=B[20] I2=A[20] I3=FE_OCPN371_carry_20
XU19 XOR3 $PINS O=SUM[23] I1=B[23] I2=A[23] I3=carry[23]
XU20 XOR3 $PINS O=SUM[27] I1=B[27] I2=A[27] I3=carry[27]
XU21 XOR3 $PINS O=SUM[28] I1=A[28] I2=B[28] I3=carry[28]
XU22 ND2 $PINS O=n4 I1=n37 I2=n36
XU23 ND2P $PINS O=carry[29] I1=n38 I2=n5
XU24 INV2 $PINS O=n5 I=n4
XU25 ND2S $PINS O=n38 I1=B[28] I2=carry[28]
XU26 ND2S $PINS O=n37 I1=A[28] I2=carry[28]
XU28 ND2 $PINS O=n7 I1=A[16] I2=carry[16]
XU29 ND2 $PINS O=n8 I1=B[16] I2=carry[16]
XU31 XOR2HS $PINS O=n9 I1=A[17] I2=B[17]
XU32 XOR2HS $PINS O=SUM[17] I1=n9 I2=carry[17]
XU33 ND2 $PINS O=n10 I1=A[17] I2=B[17]
XU34 ND2 $PINS O=n11 I1=A[17] I2=carry[17]
XU35 ND2 $PINS O=n12 I1=B[17] I2=carry[17]
XU37 ND2 $PINS O=n13 I1=carry[8] I2=B[8]
XU38 ND2 $PINS O=n14 I1=carry[8] I2=A[8]
XU39 ND2 $PINS O=n15 I1=B[8] I2=A[8]
XU40 ND2 $PINS O=n16 I1=carry[27] I2=B[27]
XU41 ND2 $PINS O=n17 I1=carry[27] I2=A[27]
XU42 ND2S $PINS O=n18 I1=B[27] I2=A[27]
XU43 ND3P $PINS O=carry[28] I1=n16 I2=n17 I3=n18
XU44 ND2P $PINS O=n27 I1=carry[9] I2=A[9]
XU45 ND2P $PINS O=n26 I1=carry[9] I2=B[9]
XU46 ND2P $PINS O=n30 I1=carry[30] I2=B[30]
XU47 ND2 $PINS O=n20 I1=A[10] I2=carry[10]
XU48 ND2P $PINS O=n21 I1=carry[10] I2=B[10]
XU49 XOR2HS $PINS O=n22 I1=A[11] I2=B[11]
XU50 XOR2HS $PINS O=SUM[11] I1=n22 I2=carry[11]
XU51 ND2S $PINS O=n23 I1=A[11] I2=B[11]
XU52 ND2 $PINS O=n24 I1=A[11] I2=carry[11]
XU53 ND2 $PINS O=n25 I1=B[11] I2=carry[11]
XU54 ND2S $PINS O=n28 I1=B[9] I2=A[9]
XU55 ND3HT $PINS O=carry[10] I1=n26 I2=n27 I3=n28
XU56 XOR2HS $PINS O=n29 I1=B[30] I2=A[30]
XU57 XOR2HS $PINS O=SUM[30] I1=carry[30] I2=n29
XU58 ND2S $PINS O=n32 I1=B[30] I2=A[30]
XU59 ND3HT $PINS O=carry[31] I1=n30 I2=n31 I3=n32
XU60 ND2P $PINS O=n33 I1=carry[23] I2=B[23]
XU61 ND2 $PINS O=n34 I1=carry[23] I2=A[23]
XU62 ND2S $PINS O=n35 I1=B[23] I2=A[23]
XU63 ND3 $PINS O=carry[24] I1=n34 I2=n33 I3=n35
XU64 XOR2HS $PINS O=n39 I1=A[29] I2=B[29]
XU65 XOR2HS $PINS O=SUM[29] I1=n39 I2=carry[29]
XU66 ND2 $PINS O=n40 I1=A[29] I2=B[29]
XU67 ND2 $PINS O=n41 I1=A[29] I2=carry[29]
XU68 ND2 $PINS O=n42 I1=B[29] I2=carry[29]
XU69 ND2S $PINS O=n43 I1=carry[20] I2=B[20]
XU70 ND2 $PINS O=n44 I1=carry[20] I2=A[20]
XU71 ND2 $PINS O=n45 I1=B[20] I2=A[20]
XU72 ND3 $PINS O=carry[21] I1=n43 I2=n44 I3=n45
XU73 ND2 $PINS O=n46 I1=carry[12] I2=B[12]
XU74 ND2 $PINS O=n47 I1=carry[12] I2=A[12]
XU75 ND2 $PINS O=n48 I1=B[12] I2=A[12]
XU76 ND3P $PINS O=carry[13] I1=n46 I2=n47 I3=n48
XU77 AN2T $PINS O=carry[1] I1=B[0] I2=A[0]
.ENDS

.SUBCKT Domain_Transfer_0 reset ToMont in_sig Px_i[31] Px_i[30] Px_i[29]
+ Px_i[28] Px_i[27] Px_i[26] Px_i[25] Px_i[24] Px_i[23] Px_i[22] Px_i[21]
+ Px_i[20] Px_i[19] Px_i[18] Px_i[17] Px_i[16] Px_i[15] Px_i[14] Px_i[13]
+ Px_i[12] Px_i[11] Px_i[10] Px_i[9] Px_i[8] Px_i[7] Px_i[6] Px_i[5] Px_i[4]
+ Px_i[3] Px_i[2] Px_i[1] Px_i[0] Py_i[31] Py_i[30] Py_i[29] Py_i[28] Py_i[27]
+ Py_i[26] Py_i[25] Py_i[24] Py_i[23] Py_i[22] Py_i[21] Py_i[20] Py_i[19]
+ Py_i[18] Py_i[17] Py_i[16] Py_i[15] Py_i[14] Py_i[13] Py_i[12] Py_i[11]
+ Py_i[10] Py_i[9] Py_i[8] Py_i[7] Py_i[6] Py_i[5] Py_i[4] Py_i[3] Py_i[2]
+ Py_i[1] Py_i[0] A_i[31] A_i[30] A_i[29] A_i[28] A_i[27] A_i[26] A_i[25]
+ A_i[24] A_i[23] A_i[22] A_i[21] A_i[20] A_i[19] A_i[18] A_i[17] A_i[16]
+ A_i[15] A_i[14] A_i[13] A_i[12] A_i[11] A_i[10] A_i[9] A_i[8] A_i[7] A_i[6]
+ A_i[5] A_i[4] A_i[3] A_i[2] A_i[1] A_i[0] Prime[31] Prime[30] Prime[29]
+ Prime[28] Prime[27] Prime[26] Prime[25] Prime[24] Prime[23] Prime[22]
+ Prime[21] Prime[20] Prime[19] Prime[18] Prime[17] Prime[16] Prime[15]
+ Prime[14] Prime[13] Prime[12] Prime[11] Prime[10] Prime[9] Prime[8] Prime[7]
+ Prime[6] Prime[5] Prime[4] Prime[3] Prime[2] Prime[1] Prime[0] Px_out[31]
+ Px_out[30] Px_out[29] Px_out[28] Px_out[27] Px_out[26] Px_out[25] Px_out[24]
+ Px_out[23] Px_out[22] Px_out[21] Px_out[20] Px_out[19] Px_out[18] Px_out[17]
+ Px_out[16] Px_out[15] Px_out[14] Px_out[13] Px_out[12] Px_out[11] Px_out[10]
+ Px_out[9] Px_out[8] Px_out[7] Px_out[6] Px_out[5] Px_out[4] Px_out[3]
+ Px_out[2] Px_out[1] Px_out[0] Py_out[31] Py_out[30] Py_out[29] Py_out[28]
+ Py_out[27] Py_out[26] Py_out[25] Py_out[24] Py_out[23] Py_out[22] Py_out[21]
+ Py_out[20] Py_out[19] Py_out[18] Py_out[17] Py_out[16] Py_out[15] Py_out[14]
+ Py_out[13] Py_out[12] Py_out[11] Py_out[10] Py_out[9] Py_out[8] Py_out[7]
+ Py_out[6] Py_out[5] Py_out[4] Py_out[3] Py_out[2] Py_out[1] Py_out[0]
+ A_out[31] A_out[30] A_out[29] A_out[28] A_out[27] A_out[26] A_out[25]
+ A_out[24] A_out[23] A_out[22] A_out[21] A_out[20] A_out[19] A_out[18]
+ A_out[17] A_out[16] A_out[15] A_out[14] A_out[13] A_out[12] A_out[11]
+ A_out[10] A_out[9] A_out[8] A_out[7] A_out[6] A_out[5] A_out[4] A_out[3]
+ A_out[2] A_out[1] A_out[0] done p1 p2 p3 p4 p5 p6 p7 p8 p9 p10 p11 p12 p13
+ p14 p15 p16 p17 p18 p19 p20 p21 p22 p23 p24 p25 p26 p27 p28 p29 p30 p31 p32
+ p33 p34 p35 p36 FE_OFN45_FE_DBTN1_i_i_rst FE_OFN43_FE_DBTN1_i_i_rst
+ FE_OFN36_FE_DBTN1_i_i_rst FE_OFN31_FE_DBTN1_i_i_rst FE_OFN30_FE_DBTN1_i_i_rst
+ FE_OFN25_FE_DBTN1_i_i_rst FE_OFN21_FE_DBTN1_i_i_rst FE_OFN105_raw_prime_15
+ FE_OFN108_raw_prime_14 FE_OFN111_raw_prime_13 FE_OFN118_raw_prime_11
+ FE_OFN121_raw_prime_10 FE_OFN128_raw_prime_6 FE_OFN140_raw_prime_8
+ FE_OFN152_raw_prime_9 FE_OFN169_x3_w_0 n466 FE_OFN193_FE_OFN56_raw_prime_6
+ FE_OFN207_FE_OFN52_raw_prime_10 FE_OFN213_FE_OFN50_raw_prime_12
+ FE_OFN223_FE_OFN44_raw_prime_18 FE_OFN227_FE_OFN43_raw_prime_19
+ FE_OFN237_FE_OFN41_raw_prime_21 FE_OFN244_FE_OFN38_raw_prime_24
+ FE_OFN250_FE_OFN36_raw_prime_26 FE_OFN261_FE_OFN34_raw_prime_28
+ FE_OFN264_FE_OFN33_raw_prime_29 FE_OFN271_FE_OFN31_raw_prime_31
+ FE_OFN317_raw_prime_14 FE_OFN324_n FE_OFN333_n FE_OFN332_n
+ FE_OCPN349_FE_OFN345_FE_OFN325_n310 clk_clone5 clk_clone4 clk_clone3
+ clk_clone2 clk_clone1 clk FE_OCPN353_FE_OFN87_n312 p37 p38
XFE_PHC1592_final_output_1_21 BUF1CK $PINS O=FE_PHN1592_final_output_1_21
+ I=Px_out[21]
XFE_PHC1586_final_output_1_17 BUF1CK $PINS O=FE_PHN1586_final_output_1_17
+ I=Px_out[17]
XFE_PHC1583_final_output_1_7 BUF1CK $PINS O=FE_PHN1583_final_output_1_7
+ I=Px_out[7]
XFE_PHC1557_final_output_1_3 BUF1CK $PINS O=FE_PHN1557_final_output_1_3
+ I=Px_out[3]
XFE_PHC1547_final_output_2_27 BUF1CK $PINS O=FE_PHN1547_final_output_2_27
+ I=Py_out[27]
XFE_PHC1452_n803 BUF1CK $PINS O=FE_PHN1452_n803 I=n803
XFE_PHC1451_n740 BUF1CK $PINS O=n740 I=FE_PHN1451_n740
XFE_PHC1449_n738 BUF1CK $PINS O=FE_PHN1449_n738 I=n738
XFE_PHC1323_final_output_1_11 BUF1CK $PINS O=Px_out[11] I=FE_PSRN_28
XFE_PHC1315_final_output_2_3 BUF1CK $PINS O=Py_out[3] I=FE_PSRN_26
XFE_PHC1309_final_output_2_2 BUF1CK $PINS O=Py_out[2] I=FE_PSRN_24
XFE_PHC1297_final_output_2_1 BUF1CK $PINS O=Py_out[1]
+ I=FE_PHN1297_final_output_2_1
XFE_PHC1294_final_output_2_5 BUF1CK $PINS O=Py_out[5] I=FE_PSRN_21
XFE_PHC1261_final_output_2_8 BUF1CK $PINS O=FE_PHN1261_final_output_2_8
+ I=Py_out[8]
XFE_PHC1232_final_output_2_21 BUF1CK $PINS O=Py_out[21]
+ I=FE_PHN1232_final_output_2_21
XFE_PHC1202_final_output_1_16 BUF1CK $PINS O=FE_PHN1202_final_output_1_16
+ I=Px_out[16]
XFE_PHC1200_final_output_1_7 BUF1CK $PINS O=FE_PHN1200_final_output_1_7
+ I=Px_out[7]
XFE_PHC1197_final_output_2_19 BUF1CK $PINS O=FE_PHN1197_final_output_2_19
+ I=Py_out[19]
XFE_PHC1196_final_output_1_17 BUF1CK $PINS O=FE_PHN1196_final_output_1_17
+ I=Px_out[17]
XFE_PHC1195_final_output_1_19 BUF1CK $PINS O=FE_PHN1195_final_output_1_19
+ I=Px_out[19]
XFE_PHC1191_final_output_1_23 BUF1CK $PINS O=FE_PHN1191_final_output_1_23
+ I=Px_out[23]
XFE_PHC1190_final_output_2_29 BUF1CK $PINS O=FE_PHN1190_final_output_2_29
+ I=Py_out[29]
XFE_PHC1189_final_output_2_27 BUF2CK $PINS O=FE_PHN1189_final_output_2_27
+ I=Py_out[27]
XFE_PHC1187_final_output_2_9 BUF3 $PINS O=FE_PHN1187_final_output_2_9
+ I=Py_out[9]
XFE_PHC1186_final_output_1_3 BUF1CK $PINS O=FE_PHN1186_final_output_1_3
+ I=Px_out[3]
XFE_PHC1181_final_output_1_2 BUF1CK $PINS O=FE_PHN1181_final_output_1_2
+ I=Px_out[2]
XFE_PHC1178_final_output_2_28 BUF1CK $PINS O=FE_PHN1178_final_output_2_28
+ I=Py_out[28]
XFE_PHC1177_final_output_1_5 BUF2 $PINS O=FE_PHN1177_final_output_1_5
+ I=Px_out[5]
XFE_PHC1173_final_output_1_10 BUF1CK $PINS O=FE_PHN1173_final_output_1_10
+ I=Px_out[10]
XFE_PHC1162_final_output_1_9 BUF1CK $PINS O=FE_PHN1162_final_output_1_9
+ I=Px_out[9]
XFE_PHC1152_final_output_1_0 BUF1CK $PINS O=FE_PHN1152_final_output_1_0
+ I=Px_out[0]
XFE_PHC1143_counter_0 BUF4 $PINS O=FE_PHN1143_counter_0 I=counter[0]
XFE_PHC972_n531 BUF3CK $PINS O=FE_PHN972_n531 I=n531
XFE_PHC964_counter_3 BUF1S $PINS O=counter[3] I=FE_PHN964_counter_3
XFE_PHC752_n530 BUF3 $PINS O=FE_PHN752_n530 I=n530
XFE_PHC742_counter_4 BUF1S $PINS O=counter[4] I=FE_PHN742_counter_4
XFE_OFC639_FE_OFN59_raw_prime_3 BUF1 $PINS O=FE_OFN654_FE_OFN59_raw_prime_3
+ I=Prime[3]
XFE_OFC630_FE_OFN87_n312 BUF6 $PINS O=FE_OFN652_FE_OFN87_n312 I=Prime[1]
XFE_OFC624_raw_prime_2 INV2CK $PINS O=FE_OFN649_raw_prime_2
+ I=FE_OFN646_raw_prime_2
XFE_OFC621_raw_prime_2 INV3 $PINS O=FE_OFN646_raw_prime_2 I=Prime[2]
XFE_OFC595_n830 BUF1 $PINS O=FE_OFN628_n830 I=n830
XFE_OFC594_n828 BUF1 $PINS O=FE_OFN627_n828 I=n828
XFE_OFC593_n732 BUF1 $PINS O=FE_OFN626_n732 I=n732
XFE_OFC592_n46 BUF1 $PINS O=FE_OFN625_n46 I=n46
XFE_OFC563_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN596_n I=FE_OFN332_n
XFE_OFC511_n831 BUF2CK $PINS O=FE_OFN544_n831 I=n831
XFE_OFC510_n829 BUF1 $PINS O=FE_OFN543_n829 I=n829
XFE_OFC509_n731 BUF1 $PINS O=FE_OFN542_n731 I=n731
XFE_OFC508_n730 BUF2CK $PINS O=FE_OFN541_n730 I=n730
XFE_OFC507_n729 BUF2CK $PINS O=FE_OFN540_n729 I=n729
XFE_OFC506_n45 BUF1 $PINS O=FE_OFN539_n45 I=n45
XFE_OFC505_n9 BUF1 $PINS O=FE_OFN538_n9 I=n9
XFE_OFC504_n7 BUF1 $PINS O=FE_OFN537_n7 I=n7
XFE_OFC414_FE_OFN15_FE_DBTN1_i_i_rst INV1S $PINS
+ O=FE_OFN447_FE_OFN15_FE_DBTN1_i_i_rst I=FE_OFN445_FE_OFN15_FE_DBTN1_i_i_rst
XFE_OFC413_FE_OFN15_FE_DBTN1_i_i_rst INV1S $PINS
+ O=FE_OFN446_FE_OFN15_FE_DBTN1_i_i_rst I=FE_OFN445_FE_OFN15_FE_DBTN1_i_i_rst
XFE_OFC412_FE_OFN15_FE_DBTN1_i_i_rst INV1S $PINS
+ O=FE_OFN445_FE_OFN15_FE_DBTN1_i_i_rst I=FE_OFN31_FE_DBTN1_i_i_rst
XFE_OFC405_FE_OFN33_raw_prime_29 INV1S $PINS O=FE_OFN438_FE_OFN33_raw_prime_29
+ I=FE_OFN264_FE_OFN33_raw_prime_29
XFE_OFC376_FE_OFN46_raw_prime_16 INV2 $PINS O=FE_OFN409_FE_OFN46_raw_prime_16
+ I=Prime[16]
XFE_OFC368_FE_OFN51_raw_prime_11 INV2 $PINS O=FE_OFN401_FE_OFN51_raw_prime_11
+ I=FE_OFN118_raw_prime_11
XFE_OFC347_FE_OFN65_n933 INV1S $PINS O=FE_OFN380_FE_OFN65_n933
+ I=FE_OFN377_FE_OFN65_n933
XFE_OFC346_FE_OFN65_n933 INV1S $PINS O=FE_OFN379_FE_OFN65_n933
+ I=FE_OFN377_FE_OFN65_n933
XFE_OFC345_FE_OFN65_n933 BUF1 $PINS O=FE_OFN378_FE_OFN65_n933 I=FE_OFN65_n933
XFE_OFC344_FE_OFN65_n933 INV1S $PINS O=FE_OFN377_FE_OFN65_n933 I=FE_OFN65_n933
XFE_RC_626_0 AOI222HS $PINS O=n28 A1=FE_OFN380_FE_OFN65_n933 A2=Py_out[30]
+ B1=N156 B2=FE_OFN628_n830 C1=N355 C2=FE_OFN544_n831
XFE_OFC63_n933 BUF1CK $PINS O=FE_OFN65_n933 I=n933
XU257 OR3B2 $PINS O=n940 I1=ToMont B1=n526 B2=in_sig
XU326 OR3B2 $PINS O=n599 I1=n825 B1=n824 B2=n823
XU327 AO222 $PINS O=n825 A1=N354 A2=FE_OFN544_n831 B1=N155 B2=FE_OFN628_n830
+ C1=Py_out[29] C2=FE_OFN380_FE_OFN65_n933
XU328 OR3B2 $PINS O=n598 I1=n822 B1=n821 B2=n820
XU329 AO222 $PINS O=n822 A1=N353 A2=FE_OFN544_n831 B1=N154 B2=FE_OFN628_n830
+ C1=Py_out[28] C2=FE_OFN380_FE_OFN65_n933
XU330 OR3B2 $PINS O=n597 I1=n819 B1=n818 B2=n817
XU331 AO222 $PINS O=n819 A1=N352 A2=FE_OFN544_n831 B1=N153 B2=FE_OFN628_n830
+ C1=Py_out[27] C2=FE_OFN380_FE_OFN65_n933
XU332 OR3B2 $PINS O=n596 I1=n816 B1=n815 B2=n814
XU333 AO222 $PINS O=n816 A1=N351 A2=FE_OFN544_n831 B1=N152 B2=FE_OFN628_n830
+ C1=Py_out[26] C2=FE_OFN380_FE_OFN65_n933
XU334 OR3B2 $PINS O=n595 I1=n813 B1=n812 B2=n811
XU335 AO222 $PINS O=n813 A1=N350 A2=FE_OFN544_n831 B1=N151 B2=FE_OFN628_n830
+ C1=Py_out[25] C2=FE_OFN380_FE_OFN65_n933
XU336 OR3B2 $PINS O=n594 I1=n810 B1=n809 B2=n808
XU337 AO222 $PINS O=n810 A1=N349 A2=FE_OFN544_n831 B1=N150 B2=FE_OFN628_n830
+ C1=Py_out[24] C2=FE_OFN380_FE_OFN65_n933
XU338 OR3B2 $PINS O=n593 I1=n807 B1=n806 B2=n805
XU339 AO222 $PINS O=n807 A1=N348 A2=FE_OFN544_n831 B1=N149 B2=FE_OFN628_n830
+ C1=Py_out[23] C2=FE_OFN380_FE_OFN65_n933
XU340 OR3B2 $PINS O=n592 I1=n804 B1=FE_PHN1452_n803 B2=n802
XU341 AO222 $PINS O=n804 A1=N347 A2=FE_OFN544_n831 B1=N148 B2=FE_OFN628_n830
+ C1=Py_out[22] C2=FE_OFN380_FE_OFN65_n933
XU342 OR3B2 $PINS O=n591 I1=n801 B1=n800 B2=n799
XU343 AO222 $PINS O=n801 A1=N346 A2=FE_OFN544_n831 B1=N147 B2=FE_OFN628_n830
+ C1=Py_out[21] C2=FE_OFN380_FE_OFN65_n933
XU344 OR3B2 $PINS O=n590 I1=n798 B1=n797 B2=n796
XU345 AO222 $PINS O=n798 A1=N345 A2=FE_OFN544_n831 B1=N146 B2=FE_OFN628_n830
+ C1=Py_out[20] C2=FE_OFN380_FE_OFN65_n933
XU346 OR3B2 $PINS O=n589 I1=n795 B1=n794 B2=n793
XU347 AO222 $PINS O=n795 A1=N344 A2=FE_OFN544_n831 B1=N145 B2=FE_OFN628_n830
+ C1=Py_out[19] C2=FE_OFN380_FE_OFN65_n933
XU348 OR3B2 $PINS O=n588 I1=n792 B1=n791 B2=n790
XU349 AO222 $PINS O=n792 A1=N343 A2=FE_OFN544_n831 B1=N144 B2=FE_OFN628_n830
+ C1=Py_out[18] C2=FE_OFN380_FE_OFN65_n933
XU350 OR3B2 $PINS O=n587 I1=n789 B1=n788 B2=n787
XU351 AO222 $PINS O=n789 A1=N342 A2=FE_OFN544_n831 B1=N143 B2=FE_OFN628_n830
+ C1=Py_out[17] C2=FE_OFN380_FE_OFN65_n933
XU352 OR3B2 $PINS O=n586 I1=n786 B1=n785 B2=n784
XU353 AO222 $PINS O=n786 A1=N341 A2=FE_OFN544_n831 B1=N142 B2=FE_OFN628_n830
+ C1=Py_out[16] C2=FE_OFN380_FE_OFN65_n933
XU354 OR3B2 $PINS O=n585 I1=n783 B1=n782 B2=n781
XU355 AO222 $PINS O=n783 A1=N340 A2=FE_OFN544_n831 B1=N141 B2=n830
+ C1=Py_out[15] C2=FE_OFN379_FE_OFN65_n933
XU356 OR3B2 $PINS O=n584 I1=n780 B1=n779 B2=n778
XU357 AO222 $PINS O=n780 A1=N339 A2=FE_OFN544_n831 B1=N140 B2=n830
+ C1=Py_out[14] C2=FE_OFN379_FE_OFN65_n933
XU358 OR3B2 $PINS O=n583 I1=n777 B1=n776 B2=n775
XU359 AO222 $PINS O=n777 A1=N338 A2=n831 B1=N139 B2=n830 C1=Py_out[13]
+ C2=FE_OFN379_FE_OFN65_n933
XU360 OR3B2 $PINS O=n582 I1=n774 B1=n773 B2=n772
XU361 AO222 $PINS O=n774 A1=N337 A2=n831 B1=N138 B2=n830 C1=Py_out[12]
+ C2=FE_OFN379_FE_OFN65_n933
XU362 OR3B2 $PINS O=n581 I1=n771 B1=n770 B2=n769
XU363 AO222 $PINS O=n771 A1=N336 A2=n831 B1=N137 B2=n830 C1=Py_out[11]
+ C2=FE_OFN379_FE_OFN65_n933
XU364 OR3B2 $PINS O=n580 I1=n768 B1=n767 B2=n766
XU365 AO222 $PINS O=n768 A1=N335 A2=n831 B1=N136 B2=n830 C1=Py_out[10]
+ C2=FE_OFN379_FE_OFN65_n933
XU366 OR3B2 $PINS O=n579 I1=n765 B1=n764 B2=n763
XU367 AO222 $PINS O=n765 A1=N334 A2=n831 B1=N135 B2=n830 C1=Py_out[9]
+ C2=FE_OFN379_FE_OFN65_n933
XU368 OR3B2 $PINS O=n578 I1=n762 B1=n761 B2=n760
XU369 AO222 $PINS O=n762 A1=N333 A2=n831 B1=N134 B2=n830
+ C1=FE_PHN1261_final_output_2_8 C2=FE_OFN379_FE_OFN65_n933
XU370 OR3B2 $PINS O=n577 I1=n759 B1=n758 B2=n757
XU371 AO222 $PINS O=n759 A1=N332 A2=n831 B1=N133 B2=n830 C1=Py_out[7]
+ C2=FE_OFN379_FE_OFN65_n933
XU372 OR3B2 $PINS O=n576 I1=n756 B1=n755 B2=n754
XU373 AO222 $PINS O=n756 A1=N331 A2=n831 B1=N132 B2=n830 C1=Py_out[6]
+ C2=FE_OFN379_FE_OFN65_n933
XU374 OR3B2 $PINS O=n575 I1=n753 B1=n752 B2=n751
XU375 AO222 $PINS O=n753 A1=N330 A2=n831 B1=N131 B2=n830 C1=Py_out[5]
+ C2=FE_OFN379_FE_OFN65_n933
XU376 OR3B2 $PINS O=n574 I1=n750 B1=n749 B2=n748
XU377 AO222 $PINS O=n750 A1=N329 A2=n831 B1=N130 B2=n830 C1=Py_out[4]
+ C2=FE_OFN379_FE_OFN65_n933
XU378 OR3B2 $PINS O=n573 I1=n747 B1=n746 B2=n745
XU379 AO222 $PINS O=n747 A1=N328 A2=n831 B1=N129 B2=n830 C1=Py_out[3]
+ C2=FE_OFN379_FE_OFN65_n933
XU380 OR3B2 $PINS O=n572 I1=n744 B1=n743 B2=n742
XU381 AO222 $PINS O=n744 A1=N327 A2=n831 B1=N128 B2=n830 C1=Py_out[2]
+ C2=FE_OFN379_FE_OFN65_n933
XU382 OR3B2 $PINS O=n571 I1=n741 B1=n740 B2=n739
XU383 AO222 $PINS O=n741 A1=N326 A2=n831 B1=N127 B2=n830 C1=Py_out[1]
+ C2=FE_OFN380_FE_OFN65_n933
XU384 ND2 $PINS O=n737 I1=Py_i[0] I2=n828
XU385 AO12 $PINS O=n735 A1=FE_OFN380_FE_OFN65_n933 B1=Py_add[1] B2=n840
XU386 AO222 $PINS O=n733 A1=N91 A2=FE_OFN626_n732 B1=Px_i[31] B2=FE_OFN542_n731
+ C1=Px_out[31] C2=FE_OFN378_FE_OFN65_n933
XU388 OR3B2 $PINS O=n568 I1=n728 B1=n727 B2=n726
XU389 AO222 $PINS O=n728 A1=N90 A2=FE_OFN626_n732 B1=Px_i[30] B2=FE_OFN542_n731
+ C1=Px_out[30] C2=FE_OFN378_FE_OFN65_n933
XU390 OR3B2 $PINS O=n567 I1=n725 B1=n724 B2=n723
XU391 AO222 $PINS O=n725 A1=N89 A2=FE_OFN626_n732 B1=Px_i[29] B2=FE_OFN542_n731
+ C1=Px_out[29] C2=FE_OFN378_FE_OFN65_n933
XU392 OR3B2 $PINS O=n566 I1=n722 B1=n721 B2=n720
XU393 AO222 $PINS O=n722 A1=N88 A2=FE_OFN626_n732 B1=Px_i[28] B2=FE_OFN542_n731
+ C1=Px_out[28] C2=FE_OFN378_FE_OFN65_n933
XU394 OR3B2 $PINS O=n565 I1=n719 B1=n718 B2=n717
XU395 AO222 $PINS O=n719 A1=N87 A2=FE_OFN626_n732 B1=Px_i[27] B2=FE_OFN542_n731
+ C1=Px_out[27] C2=FE_OFN378_FE_OFN65_n933
XU396 OR3B2 $PINS O=n564 I1=n716 B1=n715 B2=n714
XU397 AO222 $PINS O=n716 A1=N86 A2=FE_OFN626_n732 B1=Px_i[26] B2=FE_OFN542_n731
+ C1=Px_out[26] C2=FE_OFN378_FE_OFN65_n933
XU398 OR3B2 $PINS O=n563 I1=n713 B1=n712 B2=n711
XU399 AO222 $PINS O=n713 A1=N85 A2=FE_OFN626_n732 B1=Px_i[25] B2=FE_OFN542_n731
+ C1=Px_out[25] C2=FE_OFN378_FE_OFN65_n933
XU400 OR3B2 $PINS O=n562 I1=n710 B1=n709 B2=n708
XU401 AO222 $PINS O=n710 A1=N84 A2=FE_OFN626_n732 B1=Px_i[24] B2=FE_OFN542_n731
+ C1=Px_out[24] C2=FE_OFN378_FE_OFN65_n933
XU402 OR3B2 $PINS O=n561 I1=n707 B1=n706 B2=n705
XU403 AO222 $PINS O=n707 A1=N83 A2=FE_OFN626_n732 B1=Px_i[23] B2=FE_OFN542_n731
+ C1=Px_out[23] C2=FE_OFN378_FE_OFN65_n933
XU404 OR3B2 $PINS O=n560 I1=n704 B1=n703 B2=n702
XU405 AO222 $PINS O=n704 A1=N82 A2=FE_OFN626_n732 B1=Px_i[22] B2=FE_OFN542_n731
+ C1=Px_out[22] C2=FE_OFN378_FE_OFN65_n933
XU406 OR3B2 $PINS O=n559 I1=n701 B1=n700 B2=n699
XU407 AO222 $PINS O=n701 A1=N81 A2=FE_OFN626_n732 B1=Px_i[21] B2=FE_OFN542_n731
+ C1=Px_out[21] C2=FE_OFN378_FE_OFN65_n933
XU408 OR3B2 $PINS O=n558 I1=n698 B1=n697 B2=n696
XU409 AO222 $PINS O=n698 A1=N80 A2=FE_OFN626_n732 B1=Px_i[20] B2=FE_OFN542_n731
+ C1=Px_out[20] C2=FE_OFN378_FE_OFN65_n933
XU410 OR3B2 $PINS O=n557 I1=n695 B1=n694 B2=n693
XU411 AO222 $PINS O=n695 A1=N79 A2=FE_OFN626_n732 B1=Px_i[19] B2=FE_OFN542_n731
+ C1=Px_out[19] C2=FE_OFN378_FE_OFN65_n933
XU412 OR3B2 $PINS O=n556 I1=n692 B1=n691 B2=n690
XU413 AO222 $PINS O=n692 A1=N78 A2=FE_OFN626_n732 B1=Px_i[18] B2=FE_OFN542_n731
+ C1=Px_out[18] C2=FE_OFN378_FE_OFN65_n933
XU414 OR3B2 $PINS O=n555 I1=n689 B1=n688 B2=n687
XU415 AO222 $PINS O=n689 A1=N77 A2=FE_OFN626_n732 B1=Px_i[17] B2=FE_OFN542_n731
+ C1=Px_out[17] C2=FE_OFN378_FE_OFN65_n933
XU416 OR3B2 $PINS O=n554 I1=n686 B1=n685 B2=n684
XU417 AO222 $PINS O=n686 A1=N76 A2=FE_OFN626_n732 B1=Px_i[16] B2=FE_OFN542_n731
+ C1=Px_out[16] C2=FE_OFN378_FE_OFN65_n933
XU418 OR3B2 $PINS O=n553 I1=n683 B1=n682 B2=n681
XU419 AO222 $PINS O=n683 A1=N75 A2=FE_OFN626_n732 B1=Px_i[15] B2=FE_OFN542_n731
+ C1=Px_out[15] C2=FE_OFN378_FE_OFN65_n933
XU420 OR3B2 $PINS O=n552 I1=n680 B1=n679 B2=n678
XU421 AO222 $PINS O=n680 A1=N74 A2=FE_OFN626_n732 B1=Px_i[14] B2=FE_OFN542_n731
+ C1=Px_out[14] C2=FE_OFN378_FE_OFN65_n933
XU422 OR3B2 $PINS O=n551 I1=n677 B1=n676 B2=n675
XU423 AO222 $PINS O=n677 A1=N73 A2=FE_OFN626_n732 B1=Px_i[13] B2=FE_OFN542_n731
+ C1=Px_out[13] C2=FE_OFN378_FE_OFN65_n933
XU424 OR3B2 $PINS O=n550 I1=n674 B1=n673 B2=n672
XU425 AO222 $PINS O=n674 A1=N72 A2=FE_OFN626_n732 B1=Px_i[12] B2=n731
+ C1=Px_out[12] C2=FE_OFN378_FE_OFN65_n933
XU426 OR3B2 $PINS O=n549 I1=n671 B1=n670 B2=n669
XU427 AO222 $PINS O=n671 A1=N71 A2=n732 B1=Px_i[11] B2=n731 C1=Px_out[11]
+ C2=FE_OFN65_n933
XU428 OR3B2 $PINS O=n548 I1=n668 B1=n667 B2=n666
XU429 AO222 $PINS O=n668 A1=N70 A2=n732 B1=Px_i[10] B2=n731 C1=Px_out[10]
+ C2=FE_OFN65_n933
XU430 OR3B2 $PINS O=n547 I1=n665 B1=n664 B2=n663
XU431 AO222 $PINS O=n665 A1=N69 A2=n732 B1=Px_i[9] B2=n731 C1=Px_out[9]
+ C2=FE_OFN65_n933
XU432 OR3B2 $PINS O=n546 I1=n662 B1=n661 B2=n660
XU433 AO222 $PINS O=n662 A1=N68 A2=n732 B1=Px_i[8] B2=n731 C1=Px_out[8]
+ C2=FE_OFN65_n933
XU434 OR3B2 $PINS O=n545 I1=n659 B1=n658 B2=n657
XU435 AO222 $PINS O=n659 A1=N67 A2=n732 B1=Px_i[7] B2=n731 C1=Px_out[7]
+ C2=FE_OFN65_n933
XU436 OR3B2P $PINS O=n544 I1=n656 B1=n655 B2=n654
XU437 AO222 $PINS O=n656 A1=N66 A2=n732 B1=Px_i[6] B2=n731 C1=Px_out[6]
+ C2=FE_OFN65_n933
XU438 OR3B2 $PINS O=n543 I1=n653 B1=n652 B2=n651
XU439 AO222 $PINS O=n653 A1=N65 A2=n732 B1=Px_i[5] B2=n731 C1=Px_out[5]
+ C2=FE_OFN65_n933
XU440 OR3B2 $PINS O=n542 I1=n650 B1=n649 B2=n648
XU441 AO222 $PINS O=n650 A1=N64 A2=n732 B1=Px_i[4] B2=n731 C1=Px_out[4]
+ C2=FE_OFN65_n933
XU442 OR3B2 $PINS O=n541 I1=n647 B1=n646 B2=n645
XU443 AO222 $PINS O=n647 A1=N63 A2=n732 B1=Px_i[3] B2=n731 C1=Px_out[3]
+ C2=FE_OFN65_n933
XU444 OR3B2 $PINS O=n540 I1=n644 B1=n643 B2=n642
XU445 AO222 $PINS O=n644 A1=N62 A2=n732 B1=Px_i[2] B2=n731 C1=Px_out[2]
+ C2=FE_OFN65_n933
XU446 OR3B2 $PINS O=n539 I1=n641 B1=n640 B2=n639
XU447 AO222 $PINS O=n641 A1=N61 A2=n732 B1=Px_i[1] B2=n731 C1=Px_out[1]
+ C2=FE_OFN65_n933
XU449 AO12 $PINS O=n635 A1=FE_OFN65_n933 B1=Px_add[1] B2=n840
XU450 AO22 $PINS O=n537 A1=counter[3] A2=done B1=N43 B2=n634
XU451 AO22 $PINS O=n533 A1=counter[4] A2=done B1=N44 B2=n634
XU452 ND2 $PINS O=n634 I1=n524 I2=n527
Xsub_2791_S2 Domain_Transfer_0_DW01_sub_0 $PINS A[31]=A_out[30] A[30]=A_out[29]
+ A[29]=A_out[28] A[28]=A_out[27] A[27]=A_out[26] A[26]=A_out[25] A[25]=A_out[24]
+ A[24]=A_out[23] A[23]=A_out[22] A[22]=A_out[21] A[21]=A_out[20] A[20]=A_out[19]
+ A[19]=A_out[18] A[18]=A_out[17] A[17]=A_out[16] A[16]=A_out[15] A[15]=A_out[14]
+ A[14]=A_out[13] A[13]=A_out[12] A[12]=A_out[11] A[11]=A_out[10] A[10]=A_out[9]
+ A[9]=A_out[8] A[8]=A_out[7] A[7]=A_out[6] A[6]=A_out[5] A[5]=A_out[4]
+ A[4]=A_out[3] A[3]=A_out[2] A[2]=A_out[1] A[1]=A_out[0] A[0]=n21
+ B[31]=Prime[31] B[30]=Prime[30] B[29]=Prime[29] B[28]=Prime[28] B[27]=Prime[27]
+ B[26]=Prime[26] B[25]=Prime[25] B[24]=Prime[24] B[23]=Prime[23] B[22]=Prime[22]
+ B[21]=Prime[21] B[20]=Prime[20] B[19]=Prime[19] B[18]=Prime[18] B[17]=Prime[17]
+ B[16]=Prime[16] B[15]=Prime[15] B[14]=Prime[14] B[13]=Prime[13] B[12]=Prime[12]
+ B[11]=Prime[11] B[10]=Prime[10] B[9]=Prime[9] B[8]=FE_OFN140_raw_prime_8
+ B[7]=Prime[7] B[6]=Prime[6] B[5]=Prime[5] B[4]=Prime[4] B[3]=Prime[3]
+ B[2]=Prime[2] B[1]=Prime[1] B[0]=Prime[0] CI=n21 DIFF[31]=N422 DIFF[30]=N421
+ DIFF[29]=N420 DIFF[28]=N419 DIFF[27]=N418 DIFF[26]=N417 DIFF[25]=N416
+ DIFF[24]=N415 DIFF[23]=N414 DIFF[22]=N413 DIFF[21]=N412 DIFF[20]=N411
+ DIFF[19]=N410 DIFF[18]=N409 DIFF[17]=N408 DIFF[16]=N407 DIFF[15]=N406
+ DIFF[14]=N405 DIFF[13]=N404 DIFF[12]=N403 DIFF[11]=N402 DIFF[10]=N401
+ DIFF[9]=N400 DIFF[8]=N399 DIFF[7]=N398 DIFF[6]=N397 DIFF[5]=N396 DIFF[4]=N395
+ DIFF[3]=N394 DIFF[2]=N393 DIFF[1]=N392 DIFF[0]=N391
Xgte_2791 Domain_Transfer_0_DW_cmp_0 $PINS A[32]=A_out[31] A[31]=A_out[30]
+ A[30]=A_out[29] A[29]=A_out[28] A[28]=A_out[27] A[27]=A_out[26] A[26]=A_out[25]
+ A[25]=A_out[24] A[24]=A_out[23] A[23]=A_out[22] A[22]=A_out[21] A[21]=A_out[20]
+ A[20]=A_out[19] A[19]=A_out[18] A[18]=A_out[17] A[17]=A_out[16] A[16]=A_out[15]
+ A[15]=A_out[14] A[14]=A_out[13] A[13]=A_out[12] A[12]=A_out[11] A[11]=A_out[10]
+ A[10]=A_out[9] A[9]=A_out[8] A[8]=A_out[7] A[7]=A_out[6] A[6]=A_out[5]
+ A[5]=A_out[4] A[4]=A_out[3] A[3]=A_out[2] A[2]=A_out[1] A[1]=A_out[0] A[0]=n21
+ B[32]=n21 B[31]=Prime[31] B[30]=Prime[30] B[29]=Prime[29] B[28]=Prime[28]
+ B[27]=Prime[27] B[26]=Prime[26] B[25]=Prime[25] B[24]=Prime[24] B[23]=Prime[23]
+ B[22]=Prime[22] B[21]=Prime[21] B[20]=Prime[20] B[19]=Prime[19] B[18]=Prime[18]
+ B[17]=Prime[17] B[16]=Prime[16] B[15]=Prime[15] B[14]=Prime[14] B[13]=Prime[13]
+ B[12]=Prime[12] B[11]=Prime[11] B[10]=Prime[10] B[9]=Prime[9] B[8]=Prime[8]
+ B[7]=Prime[7] B[6]=Prime[6] B[5]=Prime[5] B[4]=Prime[4] B[3]=Prime[3]
+ B[2]=Prime[2] B[1]=Prime[1] B[0]=Prime[0] TC=n21 GE_LT=n942 GE_GT_EQ=n942
+ GE_LT_GT_LE=N389
Xsub_2789_S2 Domain_Transfer_0_DW01_sub_1 $PINS A[31]=Py_out[30]
+ A[30]=Py_out[29] A[29]=Py_out[28] A[28]=Py_out[27] A[27]=Py_out[26]
+ A[26]=Py_out[25] A[25]=Py_out[24] A[24]=Py_out[23] A[23]=Py_out[22]
+ A[22]=Py_out[21] A[21]=Py_out[20] A[20]=Py_out[19] A[19]=Py_out[18]
+ A[18]=Py_out[17] A[17]=Py_out[16] A[16]=Py_out[15] A[15]=Py_out[14]
+ A[14]=Py_out[13] A[13]=Py_out[12] A[12]=Py_out[11] A[11]=Py_out[10]
+ A[10]=Py_out[9] A[9]=Py_out[8] A[8]=Py_out[7] A[7]=Py_out[6] A[6]=Py_out[5]
+ A[5]=Py_out[4] A[4]=Py_out[3] A[3]=Py_out[2] A[2]=Py_out[1] A[1]=Py_out[0]
+ A[0]=n21 B[31]=Prime[31] B[30]=Prime[30] B[29]=Prime[29] B[28]=Prime[28]
+ B[27]=Prime[27] B[26]=FE_OFN250_FE_OFN36_raw_prime_26 B[25]=Prime[25]
+ B[24]=Prime[24] B[23]=Prime[23] B[22]=Prime[22] B[21]=Prime[21] B[20]=Prime[20]
+ B[19]=FE_OFN227_FE_OFN43_raw_prime_19 B[18]=FE_OFN223_FE_OFN44_raw_prime_18
+ B[17]=Prime[17] B[16]=FE_OFN409_FE_OFN46_raw_prime_16 B[15]=Prime[15]
+ B[14]=FE_OFN317_raw_prime_14 B[13]=Prime[13]
+ B[12]=FE_OFN213_FE_OFN50_raw_prime_12 B[11]=Prime[11] B[10]=Prime[10]
+ B[9]=FE_OFN152_raw_prime_9 B[8]=FE_OFN140_raw_prime_8 B[7]=Prime[7]
+ B[6]=FE_OFN193_FE_OFN56_raw_prime_6 B[5]=Prime[5] B[4]=Prime[4]
+ B[3]=FE_OFN654_FE_OFN59_raw_prime_3 B[2]=FE_OFN649_raw_prime_2
+ B[1]=FE_OFN652_FE_OFN87_n312 B[0]=Prime[0] CI=n21 DIFF[31]=N356 DIFF[30]=N355
+ DIFF[29]=N354 DIFF[28]=N353 DIFF[27]=N352 DIFF[26]=N351 DIFF[25]=N350
+ DIFF[24]=N349 DIFF[23]=N348 DIFF[22]=N347 DIFF[21]=N346 DIFF[20]=N345
+ DIFF[19]=N344 DIFF[18]=N343 DIFF[17]=N342 DIFF[16]=N341 DIFF[15]=N340
+ DIFF[14]=N339 DIFF[13]=N338 DIFF[12]=N337 DIFF[11]=N336 DIFF[10]=N335
+ DIFF[9]=N334 DIFF[8]=N333 DIFF[7]=N332 DIFF[6]=N331 DIFF[5]=N330 DIFF[4]=N329
+ DIFF[3]=N328 DIFF[2]=N327 DIFF[1]=N326 DIFF[0]=N325
Xgte_2789 Domain_Transfer_0_DW_cmp_1 $PINS A[32]=Py_out[31] A[31]=Py_out[30]
+ A[30]=Py_out[29] A[29]=Py_out[28] A[28]=Py_out[27] A[27]=Py_out[26]
+ A[26]=Py_out[25] A[25]=Py_out[24] A[24]=Py_out[23] A[23]=Py_out[22]
+ A[22]=Py_out[21] A[21]=Py_out[20] A[20]=Py_out[19] A[19]=Py_out[18]
+ A[18]=Py_out[17] A[17]=Py_out[16] A[16]=Py_out[15] A[15]=Py_out[14]
+ A[14]=Py_out[13] A[13]=Py_out[12] A[12]=Py_out[11] A[11]=Py_out[10]
+ A[10]=Py_out[9] A[9]=Py_out[8] A[8]=Py_out[7] A[7]=Py_out[6] A[6]=Py_out[5]
+ A[5]=Py_out[4] A[4]=Py_out[3] A[3]=Py_out[2] A[2]=Py_out[1] A[1]=Py_out[0]
+ A[0]=n21 B[32]=n21 B[31]=Prime[31] B[30]=Prime[30] B[29]=Prime[29]
+ B[28]=Prime[28] B[27]=Prime[27] B[26]=FE_OFN250_FE_OFN36_raw_prime_26
+ B[25]=Prime[25] B[24]=Prime[24] B[23]=Prime[23] B[22]=Prime[22] B[21]=Prime[21]
+ B[20]=Prime[20] B[19]=FE_OFN227_FE_OFN43_raw_prime_19
+ B[18]=FE_OFN223_FE_OFN44_raw_prime_18 B[17]=Prime[17]
+ B[16]=FE_OFN409_FE_OFN46_raw_prime_16 B[15]=Prime[15]
+ B[14]=FE_OFN317_raw_prime_14 B[13]=Prime[13]
+ B[12]=FE_OFN213_FE_OFN50_raw_prime_12 B[11]=Prime[11] B[10]=Prime[10]
+ B[9]=FE_OFN152_raw_prime_9 B[8]=Prime[8] B[7]=Prime[7]
+ B[6]=FE_OFN193_FE_OFN56_raw_prime_6 B[5]=Prime[5] B[4]=Prime[4]
+ B[3]=FE_OFN654_FE_OFN59_raw_prime_3 B[2]=FE_OFN649_raw_prime_2
+ B[1]=FE_OFN652_FE_OFN87_n312 B[0]=Prime[0] TC=n21 GE_LT=n942 GE_GT_EQ=n942
+ GE_LT_GT_LE=N323
Xsub_2787_S2 Domain_Transfer_0_DW01_sub_2 $PINS A[31]=Px_out[30]
+ A[30]=Px_out[29] A[29]=Px_out[28] A[28]=Px_out[27] A[27]=Px_out[26]
+ A[26]=Px_out[25] A[25]=Px_out[24] A[24]=Px_out[23] A[23]=Px_out[22]
+ A[22]=Px_out[21] A[21]=Px_out[20] A[20]=Px_out[19] A[19]=Px_out[18]
+ A[18]=Px_out[17] A[17]=Px_out[16] A[16]=Px_out[15] A[15]=Px_out[14]
+ A[14]=Px_out[13] A[13]=Px_out[12] A[12]=Px_out[11] A[11]=Px_out[10]
+ A[10]=Px_out[9] A[9]=Px_out[8] A[8]=Px_out[7] A[7]=Px_out[6] A[6]=Px_out[5]
+ A[5]=Px_out[4] A[4]=Px_out[3] A[3]=Px_out[2] A[2]=Px_out[1] A[1]=Px_out[0]
+ A[0]=n21 B[31]=FE_OFN271_FE_OFN31_raw_prime_31 B[30]=Prime[30]
+ B[29]=FE_OFN438_FE_OFN33_raw_prime_29 B[28]=FE_OFN261_FE_OFN34_raw_prime_28
+ B[27]=Prime[27] B[26]=FE_OFN250_FE_OFN36_raw_prime_26 B[25]=Prime[25]
+ B[24]=FE_OFN244_FE_OFN38_raw_prime_24 B[23]=Prime[23] B[22]=Prime[22]
+ B[21]=Prime[21] B[20]=Prime[20] B[19]=FE_OFN227_FE_OFN43_raw_prime_19
+ B[18]=FE_OFN223_FE_OFN44_raw_prime_18 B[17]=Prime[17]
+ B[16]=FE_OFN409_FE_OFN46_raw_prime_16 B[15]=Prime[15]
+ B[14]=FE_OFN317_raw_prime_14 B[13]=FE_OFN111_raw_prime_13 B[12]=Prime[12]
+ B[11]=FE_OFN401_FE_OFN51_raw_prime_11 B[10]=FE_OFN207_FE_OFN52_raw_prime_10
+ B[9]=Prime[9] B[8]=FE_OFN140_raw_prime_8 B[7]=Prime[7]
+ B[6]=FE_OFN193_FE_OFN56_raw_prime_6 B[5]=Prime[5] B[4]=Prime[4]
+ B[3]=FE_OFN654_FE_OFN59_raw_prime_3 B[2]=FE_OFN646_raw_prime_2
+ B[1]=FE_OFN652_FE_OFN87_n312 B[0]=Prime[0] CI=n21 DIFF[31]=N290 DIFF[30]=N289
+ DIFF[29]=N288 DIFF[28]=N287 DIFF[27]=N286 DIFF[26]=N285 DIFF[25]=N284
+ DIFF[24]=N283 DIFF[23]=N282 DIFF[22]=N281 DIFF[21]=N280 DIFF[20]=N279
+ DIFF[19]=N278 DIFF[18]=N277 DIFF[17]=N276 DIFF[16]=N275 DIFF[15]=N274
+ DIFF[14]=N273 DIFF[13]=N272 DIFF[12]=N271 DIFF[11]=N270 DIFF[10]=N269
+ DIFF[9]=N268 DIFF[8]=N267 DIFF[7]=N266 DIFF[6]=N265 DIFF[5]=N264 DIFF[4]=N263
+ DIFF[3]=N262 DIFF[2]=N261 DIFF[1]=N260 DIFF[0]=N259
Xgte_2787 Domain_Transfer_0_DW_cmp_2 $PINS A[32]=Px_out[31] A[31]=Px_out[30]
+ A[30]=Px_out[29] A[29]=Px_out[28] A[28]=Px_out[27] A[27]=Px_out[26]
+ A[26]=Px_out[25] A[25]=Px_out[24] A[24]=Px_out[23] A[23]=Px_out[22]
+ A[22]=Px_out[21] A[21]=Px_out[20] A[20]=Px_out[19] A[19]=Px_out[18]
+ A[18]=Px_out[17] A[17]=Px_out[16] A[16]=Px_out[15] A[15]=Px_out[14]
+ A[14]=Px_out[13] A[13]=Px_out[12] A[12]=Px_out[11] A[11]=Px_out[10]
+ A[10]=Px_out[9] A[9]=Px_out[8] A[8]=Px_out[7] A[7]=Px_out[6] A[6]=Px_out[5]
+ A[5]=Px_out[4] A[4]=Px_out[3] A[3]=Px_out[2] A[2]=Px_out[1] A[1]=Px_out[0]
+ A[0]=n21 B[32]=n21 B[31]=Prime[31] B[30]=Prime[30] B[29]=Prime[29]
+ B[28]=Prime[28] B[27]=Prime[27] B[26]=FE_OFN250_FE_OFN36_raw_prime_26
+ B[25]=Prime[25] B[24]=Prime[24] B[23]=Prime[23] B[22]=Prime[22] B[21]=Prime[21]
+ B[20]=Prime[20] B[19]=FE_OFN227_FE_OFN43_raw_prime_19
+ B[18]=FE_OFN223_FE_OFN44_raw_prime_18 B[17]=Prime[17]
+ B[16]=FE_OFN409_FE_OFN46_raw_prime_16 B[15]=Prime[15]
+ B[14]=FE_OFN317_raw_prime_14 B[13]=FE_OFN111_raw_prime_13 B[12]=Prime[12]
+ B[11]=FE_OFN401_FE_OFN51_raw_prime_11 B[10]=FE_OFN207_FE_OFN52_raw_prime_10
+ B[9]=Prime[9] B[8]=Prime[8] B[7]=Prime[7] B[6]=FE_OFN193_FE_OFN56_raw_prime_6
+ B[5]=Prime[5] B[4]=Prime[4] B[3]=FE_OFN654_FE_OFN59_raw_prime_3
+ B[2]=FE_OFN646_raw_prime_2 B[1]=FE_OFN652_FE_OFN87_n312 B[0]=Prime[0] TC=n21
+ GE_LT=n942 GE_GT_EQ=n942 GE_LT_GT_LE=N257
Xsub_2776_S2 Domain_Transfer_0_DW01_sub_3 $PINS A[31]=A_i[31] A[30]=A_i[30]
+ A[29]=A_i[29] A[28]=A_i[28] A[27]=A_i[27] A[26]=A_i[26] A[25]=A_i[25]
+ A[24]=A_i[24] A[23]=A_i[23] A[22]=A_i[22] A[21]=A_i[21] A[20]=A_i[20]
+ A[19]=A_i[19] A[18]=A_i[18] A[17]=A_i[17] A[16]=A_i[16] A[15]=A_i[15]
+ A[14]=A_i[14] A[13]=A_i[13] A[12]=A_i[12] A[11]=A_i[11] A[10]=A_i[10]
+ A[9]=A_i[9] A[8]=A_i[8] A[7]=A_i[7] A[6]=A_i[6] A[5]=A_i[5] A[4]=A_i[4]
+ A[3]=A_i[3] A[2]=A_i[2] A[1]=A_i[1] A[0]=A_i[0] B[31]=Prime[31] B[30]=Prime[30]
+ B[29]=Prime[29] B[28]=Prime[28] B[27]=Prime[27] B[26]=Prime[26] B[25]=Prime[25]
+ B[24]=Prime[24] B[23]=Prime[23] B[22]=Prime[22] B[21]=Prime[21] B[20]=Prime[20]
+ B[19]=Prime[19] B[18]=Prime[18] B[17]=Prime[17] B[16]=Prime[16] B[15]=Prime[15]
+ B[14]=Prime[14] B[13]=Prime[13] B[12]=Prime[12] B[11]=Prime[11] B[10]=Prime[10]
+ B[9]=Prime[9] B[8]=FE_OFN140_raw_prime_8 B[7]=Prime[7] B[6]=Prime[6]
+ B[5]=Prime[5] B[4]=Prime[4] B[3]=Prime[3] B[2]=Prime[2] B[1]=Prime[1]
+ B[0]=Prime[0] CI=n21 DIFF[31]=N223 DIFF[30]=N222 DIFF[29]=N221 DIFF[28]=N220
+ DIFF[27]=N219 DIFF[26]=N218 DIFF[25]=N217 DIFF[24]=N216 DIFF[23]=N215
+ DIFF[22]=N214 DIFF[21]=N213 DIFF[20]=N212 DIFF[19]=N211 DIFF[18]=N210
+ DIFF[17]=N209 DIFF[16]=N208 DIFF[15]=N207 DIFF[14]=N206 DIFF[13]=N205
+ DIFF[12]=N204 DIFF[11]=N203 DIFF[10]=N202 DIFF[9]=N201 DIFF[8]=N200
+ DIFF[7]=N199 DIFF[6]=N198 DIFF[5]=N197 DIFF[4]=N196 DIFF[3]=N195 DIFF[2]=N194
+ DIFF[1]=N193 DIFF[0]=N192
Xgte_2776 Domain_Transfer_0_DW_cmp_3 $PINS A[31]=A_i[31] A[30]=A_i[30]
+ A[29]=A_i[29] A[28]=A_i[28] A[27]=A_i[27] A[26]=A_i[26] A[25]=A_i[25]
+ A[24]=A_i[24] A[23]=A_i[23] A[22]=A_i[22] A[21]=A_i[21] A[20]=A_i[20]
+ A[19]=A_i[19] A[18]=A_i[18] A[17]=A_i[17] A[16]=A_i[16] A[15]=A_i[15]
+ A[14]=A_i[14] A[13]=A_i[13] A[12]=A_i[12] A[11]=A_i[11] A[10]=A_i[10]
+ A[9]=A_i[9] A[8]=A_i[8] A[7]=A_i[7] A[6]=A_i[6] A[5]=A_i[5] A[4]=A_i[4]
+ A[3]=A_i[3] A[2]=A_i[2] A[1]=A_i[1] A[0]=A_i[0] B[31]=Prime[31] B[30]=Prime[30]
+ B[29]=Prime[29] B[28]=Prime[28] B[27]=Prime[27] B[26]=Prime[26] B[25]=Prime[25]
+ B[24]=Prime[24] B[23]=Prime[23] B[22]=Prime[22] B[21]=Prime[21] B[20]=Prime[20]
+ B[19]=Prime[19] B[18]=Prime[18] B[17]=Prime[17] B[16]=Prime[16] B[15]=Prime[15]
+ B[14]=Prime[14] B[13]=Prime[13] B[12]=Prime[12] B[11]=Prime[11] B[10]=Prime[10]
+ B[9]=Prime[9] B[8]=FE_OFN140_raw_prime_8 B[7]=Prime[7] B[6]=Prime[6]
+ B[5]=Prime[5] B[4]=Prime[4] B[3]=Prime[3] B[2]=Prime[2] B[1]=Prime[1]
+ B[0]=Prime[0] TC=n21 GE_LT=n942 GE_GT_EQ=n942 GE_LT_GT_LE=N190
Xsub_2774_S2 Domain_Transfer_0_DW01_sub_4 $PINS A[31]=Py_i[31] A[30]=Py_i[30]
+ A[29]=Py_i[29] A[28]=Py_i[28] A[27]=Py_i[27] A[26]=Py_i[26] A[25]=Py_i[25]
+ A[24]=Py_i[24] A[23]=Py_i[23] A[22]=Py_i[22] A[21]=Py_i[21] A[20]=Py_i[20]
+ A[19]=Py_i[19] A[18]=Py_i[18] A[17]=Py_i[17] A[16]=Py_i[16] A[15]=Py_i[15]
+ A[14]=Py_i[14] A[13]=Py_i[13] A[12]=Py_i[12] A[11]=Py_i[11] A[10]=Py_i[10]
+ A[9]=Py_i[9] A[8]=Py_i[8] A[7]=Py_i[7] A[6]=Py_i[6] A[5]=Py_i[5] A[4]=Py_i[4]
+ A[3]=Py_i[3] A[2]=Py_i[2] A[1]=Py_i[1] A[0]=Py_i[0] B[31]=Prime[31]
+ B[30]=Prime[30] B[29]=Prime[29] B[28]=Prime[28] B[27]=Prime[27] B[26]=Prime[26]
+ B[25]=Prime[25] B[24]=Prime[24] B[23]=Prime[23] B[22]=Prime[22] B[21]=Prime[21]
+ B[20]=Prime[20] B[19]=FE_OFN227_FE_OFN43_raw_prime_19 B[18]=Prime[18]
+ B[17]=Prime[17] B[16]=FE_OFN409_FE_OFN46_raw_prime_16 B[15]=Prime[15]
+ B[14]=FE_OFN317_raw_prime_14 B[13]=Prime[13]
+ B[12]=FE_OFN213_FE_OFN50_raw_prime_12 B[11]=Prime[11] B[10]=Prime[10]
+ B[9]=FE_OFN152_raw_prime_9 B[8]=FE_OFN140_raw_prime_8 B[7]=Prime[7]
+ B[6]=FE_OFN193_FE_OFN56_raw_prime_6 B[5]=Prime[5] B[4]=Prime[4]
+ B[3]=FE_OFN654_FE_OFN59_raw_prime_3 B[2]=FE_OFN646_raw_prime_2
+ B[1]=FE_OFN652_FE_OFN87_n312 B[0]=Prime[0] CI=n21 DIFF[31]=N157 DIFF[30]=N156
+ DIFF[29]=N155 DIFF[28]=N154 DIFF[27]=N153 DIFF[26]=N152 DIFF[25]=N151
+ DIFF[24]=N150 DIFF[23]=N149 DIFF[22]=N148 DIFF[21]=N147 DIFF[20]=N146
+ DIFF[19]=N145 DIFF[18]=N144 DIFF[17]=N143 DIFF[16]=N142 DIFF[15]=N141
+ DIFF[14]=N140 DIFF[13]=N139 DIFF[12]=N138 DIFF[11]=N137 DIFF[10]=N136
+ DIFF[9]=N135 DIFF[8]=N134 DIFF[7]=N133 DIFF[6]=N132 DIFF[5]=N131 DIFF[4]=N130
+ DIFF[3]=N129 DIFF[2]=N128 DIFF[1]=N127 DIFF[0]=N126 p1=p1 n466=n466
+ p2=FE_OCPN366_FE_OFN325_n310
Xgte_2774 Domain_Transfer_0_DW_cmp_4 $PINS A[31]=p18 A[30]=Py_i[30] A[29]=p17
+ A[28]=Py_i[28] A[27]=p16 A[26]=Py_i[26] A[25]=p15 A[24]=Py_i[24] A[23]=p14
+ A[22]=Py_i[22] A[21]=p13 A[20]=Py_i[20] A[19]=p12 A[18]=Py_i[18] A[17]=p11
+ A[16]=Py_i[16] A[15]=p10 A[14]=Py_i[14] A[13]=p9 A[12]=Py_i[12] A[11]=p8
+ A[10]=Py_i[10] A[9]=p7 A[8]=Py_i[8] A[7]=p6 A[6]=Py_i[6] A[5]=p4 A[4]=Py_i[4]
+ A[3]=p3 A[2]=Py_i[2] A[1]=p2 A[0]=Py_i[0] B[31]=Prime[31] B[30]=Prime[30]
+ B[29]=Prime[29] B[28]=FE_OFN261_FE_OFN34_raw_prime_28 B[27]=Prime[27]
+ B[26]=FE_OFN250_FE_OFN36_raw_prime_26 B[25]=Prime[25]
+ B[24]=FE_OFN244_FE_OFN38_raw_prime_24 B[23]=Prime[23] B[22]=Prime[22]
+ B[21]=Prime[21] B[20]=Prime[20] B[19]=FE_OFN227_FE_OFN43_raw_prime_19
+ B[18]=FE_OFN223_FE_OFN44_raw_prime_18 B[17]=Prime[17]
+ B[16]=FE_OFN409_FE_OFN46_raw_prime_16 B[15]=FE_OFN105_raw_prime_15
+ B[14]=FE_OFN108_raw_prime_14 B[13]=FE_OFN111_raw_prime_13 B[12]=Prime[12]
+ B[11]=FE_OFN401_FE_OFN51_raw_prime_11 B[10]=FE_OFN207_FE_OFN52_raw_prime_10
+ B[9]=Prime[9] B[8]=FE_OFN140_raw_prime_8 B[7]=Prime[7]
+ B[6]=FE_OFN193_FE_OFN56_raw_prime_6 B[5]=Prime[5] B[4]=Prime[4] B[3]=Prime[3]
+ B[2]=Prime[2] B[1]=FE_OCPN353_FE_OFN87_n312
+ B[0]=FE_OCPN349_FE_OFN345_FE_OFN325_n310 TC=n21 GE_LT=n942 GE_GT_EQ=n942
+ GE_LT_GT_LE=N124 p1=p5
Xsub_2772_S2 Domain_Transfer_0_DW01_sub_5 $PINS A[31]=Px_i[31] A[30]=Px_i[30]
+ A[29]=Px_i[29] A[28]=Px_i[28] A[27]=Px_i[27] A[26]=Px_i[26] A[25]=Px_i[25]
+ A[24]=Px_i[24] A[23]=Px_i[23] A[22]=Px_i[22] A[21]=Px_i[21] A[20]=Px_i[20]
+ A[19]=Px_i[19] A[18]=Px_i[18] A[17]=Px_i[17] A[16]=Px_i[16] A[15]=Px_i[15]
+ A[14]=Px_i[14] A[13]=Px_i[13] A[12]=Px_i[12] A[11]=Px_i[11] A[10]=Px_i[10]
+ A[9]=Px_i[9] A[8]=Px_i[8] A[7]=Px_i[7] A[6]=Px_i[6] A[5]=Px_i[5] A[4]=Px_i[4]
+ A[3]=Px_i[3] A[2]=Px_i[2] A[1]=Px_i[1] A[0]=FE_OFN169_x3_w_0 B[31]=Prime[31]
+ B[30]=Prime[30] B[29]=Prime[29] B[28]=FE_OFN261_FE_OFN34_raw_prime_28
+ B[27]=Prime[27] B[26]=FE_OFN250_FE_OFN36_raw_prime_26 B[25]=Prime[25]
+ B[24]=FE_OFN244_FE_OFN38_raw_prime_24 B[23]=Prime[23] B[22]=Prime[22]
+ B[21]=Prime[21] B[20]=Prime[20] B[19]=FE_OFN227_FE_OFN43_raw_prime_19
+ B[18]=FE_OFN223_FE_OFN44_raw_prime_18 B[17]=Prime[17]
+ B[16]=FE_OFN409_FE_OFN46_raw_prime_16 B[15]=Prime[15]
+ B[14]=FE_OFN317_raw_prime_14 B[13]=FE_OFN111_raw_prime_13 B[12]=Prime[12]
+ B[11]=FE_OFN401_FE_OFN51_raw_prime_11 B[10]=FE_OFN207_FE_OFN52_raw_prime_10
+ B[9]=Prime[9] B[8]=FE_OFN140_raw_prime_8 B[7]=Prime[7]
+ B[6]=FE_OFN193_FE_OFN56_raw_prime_6 B[5]=Prime[5] B[4]=Prime[4] B[3]=Prime[3]
+ B[2]=FE_OFN646_raw_prime_2 B[1]=Prime[1] B[0]=Prime[0] CI=n21 DIFF[31]=N91
+ DIFF[30]=N90 DIFF[29]=N89 DIFF[28]=N88 DIFF[27]=N87 DIFF[26]=N86 DIFF[25]=N85
+ DIFF[24]=N84 DIFF[23]=N83 DIFF[22]=N82 DIFF[21]=N81 DIFF[20]=N80 DIFF[19]=N79
+ DIFF[18]=N78 DIFF[17]=N77 DIFF[16]=N76 DIFF[15]=N75 DIFF[14]=N74 DIFF[13]=N73
+ DIFF[12]=N72 DIFF[11]=N71 DIFF[10]=N70 DIFF[9]=N69 DIFF[8]=N68 DIFF[7]=N67
+ DIFF[6]=N66 DIFF[5]=N65 DIFF[4]=N64 DIFF[3]=N63 DIFF[2]=N62 DIFF[1]=N61
+ DIFF[0]=N60 p1=p19 FE_DBTN59_x3_w_9=p25
Xgte_2772 Domain_Transfer_0_DW_cmp_5 $PINS A[31]=p36 A[30]=Px_i[30] A[29]=p35
+ A[28]=Px_i[28] A[27]=p34 A[26]=Px_i[26] A[25]=p33 A[24]=Px_i[24] A[23]=p32
+ A[22]=Px_i[22] A[21]=p31 A[20]=Px_i[20] A[19]=p30 A[18]=Px_i[18] A[17]=p29
+ A[16]=Px_i[16] A[15]=p28 A[14]=p38 A[13]=p27 A[12]=p37 A[11]=p26 A[10]=Px_i[10]
+ A[9]=p25 A[8]=Px_i[8] A[7]=p24 A[6]=Px_i[6] A[5]=p22 A[4]=Px_i[4] A[3]=p21
+ A[2]=Px_i[2] A[1]=p20 A[0]=Px_i[0] B[31]=Prime[31] B[30]=Prime[30]
+ B[29]=Prime[29] B[28]=FE_OFN261_FE_OFN34_raw_prime_28 B[27]=Prime[27]
+ B[26]=FE_OFN250_FE_OFN36_raw_prime_26 B[25]=Prime[25]
+ B[24]=FE_OFN244_FE_OFN38_raw_prime_24 B[23]=Prime[23] B[22]=Prime[22]
+ B[21]=Prime[21] B[20]=Prime[20] B[19]=FE_OFN227_FE_OFN43_raw_prime_19
+ B[18]=FE_OFN223_FE_OFN44_raw_prime_18 B[17]=Prime[17]
+ B[16]=FE_OFN409_FE_OFN46_raw_prime_16 B[15]=FE_OFN324_n
+ B[14]=FE_OFN108_raw_prime_14 B[13]=FE_OFN111_raw_prime_13 B[12]=Prime[12]
+ B[11]=FE_OFN401_FE_OFN51_raw_prime_11 B[10]=FE_OFN207_FE_OFN52_raw_prime_10
+ B[9]=Prime[9] B[8]=FE_OFN140_raw_prime_8 B[7]=Prime[7]
+ B[6]=FE_OFN193_FE_OFN56_raw_prime_6 B[5]=Prime[5] B[4]=Prime[4] B[3]=Prime[3]
+ B[2]=Prime[2] B[1]=FE_OCPN353_FE_OFN87_n312
+ B[0]=FE_OCPN349_FE_OFN345_FE_OFN325_n310 TC=n21 GE_LT=n942 GE_GT_EQ=n942
+ GE_LT_GT_LE=N58 p1=p23
+ FE_OFN238_FE_OFN41_raw_prime_21=FE_OFN237_FE_OFN41_raw_prime_21
Xadd_2735 Domain_Transfer_0_DW01_add_0 $PINS A[32]=n21 A[31]=A_out[31]
+ A[30]=A_out[30] A[29]=A_out[29] A[28]=A_out[28] A[27]=A_out[27] A[26]=A_out[26]
+ A[25]=A_out[25] A[24]=A_out[24] A[23]=A_out[23] A[22]=A_out[22] A[21]=A_out[21]
+ A[20]=A_out[20] A[19]=A_out[19] A[18]=A_out[18] A[17]=A_out[17] A[16]=A_out[16]
+ A[15]=A_out[15] A[14]=A_out[14] A[13]=A_out[13] A[12]=A_out[12] A[11]=A_out[11]
+ A[10]=A_out[10] A[9]=A_out[9] A[8]=A_out[8] A[7]=A_out[7] A[6]=A_out[6]
+ A[5]=A_out[5] A[4]=A_out[4] A[3]=A_out[3] A[2]=A_out[2] A[1]=A_out[1]
+ A[0]=A_out[0] B[32]=n21 B[31]=Prime[31] B[30]=Prime[30] B[29]=Prime[29]
+ B[28]=Prime[28] B[27]=Prime[27] B[26]=Prime[26] B[25]=Prime[25] B[24]=Prime[24]
+ B[23]=Prime[23] B[22]=Prime[22] B[21]=Prime[21] B[20]=Prime[20] B[19]=Prime[19]
+ B[18]=Prime[18] B[17]=Prime[17] B[16]=Prime[16] B[15]=Prime[15] B[14]=Prime[14]
+ B[13]=Prime[13] B[12]=Prime[12] B[11]=Prime[11] B[10]=Prime[10] B[9]=Prime[9]
+ B[8]=Prime[8] B[7]=Prime[7] B[6]=Prime[6] B[5]=Prime[5] B[4]=Prime[4]
+ B[3]=Prime[3] B[2]=Prime[2] B[1]=Prime[1] B[0]=Prime[0] CI=n21
+ SUM[32]=A_add[32] SUM[31]=A_add[31] SUM[30]=A_add[30] SUM[29]=A_add[29]
+ SUM[28]=A_add[28] SUM[27]=A_add[27] SUM[26]=A_add[26] SUM[25]=A_add[25]
+ SUM[24]=A_add[24] SUM[23]=A_add[23] SUM[22]=A_add[22] SUM[21]=A_add[21]
+ SUM[20]=A_add[20] SUM[19]=A_add[19] SUM[18]=A_add[18] SUM[17]=A_add[17]
+ SUM[16]=A_add[16] SUM[15]=A_add[15] SUM[14]=A_add[14] SUM[13]=A_add[13]
+ SUM[12]=A_add[12] SUM[11]=A_add[11] SUM[10]=A_add[10] SUM[9]=A_add[9]
+ SUM[8]=A_add[8] SUM[7]=A_add[7] SUM[6]=A_add[6] SUM[5]=A_add[5] SUM[4]=A_add[4]
+ SUM[3]=A_add[3] SUM[2]=A_add[2] SUM[1]=A_add[1] SUM[0]=SYNOPSYS_UNCONNECTED__0
Xadd_2734 Domain_Transfer_0_DW01_add_1 $PINS A[32]=n21 A[31]=Py_out[31]
+ A[30]=Py_out[30] A[29]=Py_out[29] A[28]=Py_out[28] A[27]=Py_out[27]
+ A[26]=Py_out[26] A[25]=Py_out[25] A[24]=Py_out[24] A[23]=Py_out[23]
+ A[22]=Py_out[22] A[21]=Py_out[21] A[20]=Py_out[20] A[19]=Py_out[19]
+ A[18]=Py_out[18] A[17]=Py_out[17] A[16]=Py_out[16] A[15]=Py_out[15]
+ A[14]=Py_out[14] A[13]=Py_out[13] A[12]=Py_out[12] A[11]=Py_out[11]
+ A[10]=Py_out[10] A[9]=Py_out[9] A[8]=FE_PHN1261_final_output_2_8 A[7]=Py_out[7]
+ A[6]=Py_out[6] A[5]=Py_out[5] A[4]=Py_out[4] A[3]=Py_out[3] A[2]=Py_out[2]
+ A[1]=Py_out[1] A[0]=Py_out[0] B[32]=n21 B[31]=Prime[31] B[30]=Prime[30]
+ B[29]=Prime[29] B[28]=Prime[28] B[27]=Prime[27] B[26]=Prime[26] B[25]=Prime[25]
+ B[24]=Prime[24] B[23]=Prime[23] B[22]=Prime[22] B[21]=Prime[21] B[20]=Prime[20]
+ B[19]=FE_OFN227_FE_OFN43_raw_prime_19 B[18]=Prime[18] B[17]=Prime[17]
+ B[16]=FE_OFN409_FE_OFN46_raw_prime_16 B[15]=Prime[15]
+ B[14]=FE_OFN317_raw_prime_14 B[13]=Prime[13]
+ B[12]=FE_OFN213_FE_OFN50_raw_prime_12 B[11]=Prime[11] B[10]=Prime[10]
+ B[9]=FE_OFN152_raw_prime_9 B[8]=Prime[8] B[7]=Prime[7]
+ B[6]=FE_OFN193_FE_OFN56_raw_prime_6 B[5]=Prime[5] B[4]=Prime[4]
+ B[3]=FE_OFN654_FE_OFN59_raw_prime_3 B[2]=FE_OFN649_raw_prime_2
+ B[1]=FE_OFN652_FE_OFN87_n312 B[0]=Prime[0] CI=n21 SUM[32]=Py_add[32]
+ SUM[31]=Py_add[31] SUM[30]=Py_add[30] SUM[29]=Py_add[29] SUM[28]=Py_add[28]
+ SUM[27]=Py_add[27] SUM[26]=Py_add[26] SUM[25]=Py_add[25] SUM[24]=Py_add[24]
+ SUM[23]=Py_add[23] SUM[22]=Py_add[22] SUM[21]=Py_add[21] SUM[20]=Py_add[20]
+ SUM[19]=Py_add[19] SUM[18]=Py_add[18] SUM[17]=Py_add[17] SUM[16]=Py_add[16]
+ SUM[15]=Py_add[15] SUM[14]=Py_add[14] SUM[13]=Py_add[13] SUM[12]=Py_add[12]
+ SUM[11]=Py_add[11] SUM[10]=Py_add[10] SUM[9]=Py_add[9] SUM[8]=Py_add[8]
+ SUM[7]=Py_add[7] SUM[6]=Py_add[6] SUM[5]=Py_add[5] SUM[4]=Py_add[4]
+ SUM[3]=Py_add[3] SUM[2]=Py_add[2] SUM[1]=Py_add[1]
+ SUM[0]=SYNOPSYS_UNCONNECTED__1
+ FE_OFN251_FE_OFN36_raw_prime_26=FE_OFN250_FE_OFN36_raw_prime_26
Xadd_2733 Domain_Transfer_0_DW01_add_2 $PINS A[32]=n21 A[31]=Px_out[31]
+ A[30]=Px_out[30] A[29]=Px_out[29] A[28]=Px_out[28] A[27]=Px_out[27]
+ A[26]=Px_out[26] A[25]=Px_out[25] A[24]=Px_out[24] A[23]=Px_out[23]
+ A[22]=Px_out[22] A[21]=Px_out[21] A[20]=Px_out[20] A[19]=Px_out[19]
+ A[18]=Px_out[18] A[17]=Px_out[17] A[16]=Px_out[16] A[15]=Px_out[15]
+ A[14]=Px_out[14] A[13]=Px_out[13] A[12]=Px_out[12] A[11]=Px_out[11]
+ A[10]=Px_out[10] A[9]=Px_out[9] A[8]=Px_out[8] A[7]=Px_out[7] A[6]=Px_out[6]
+ A[5]=Px_out[5] A[4]=Px_out[4] A[3]=Px_out[3] A[2]=Px_out[2] A[1]=Px_out[1]
+ A[0]=Px_out[0] B[32]=n21 B[31]=Prime[31] B[30]=Prime[30]
+ B[29]=FE_OFN438_FE_OFN33_raw_prime_29 B[28]=FE_OFN261_FE_OFN34_raw_prime_28
+ B[27]=Prime[27] B[26]=FE_OFN250_FE_OFN36_raw_prime_26 B[25]=Prime[25]
+ B[24]=FE_OFN244_FE_OFN38_raw_prime_24 B[23]=Prime[23] B[22]=Prime[22]
+ B[21]=Prime[21] B[20]=Prime[20] B[19]=Prime[19]
+ B[18]=FE_OFN223_FE_OFN44_raw_prime_18 B[17]=Prime[17]
+ B[16]=FE_OFN409_FE_OFN46_raw_prime_16 B[15]=Prime[15] B[14]=Prime[14]
+ B[13]=FE_OFN111_raw_prime_13 B[12]=Prime[12]
+ B[11]=FE_OFN401_FE_OFN51_raw_prime_11 B[10]=FE_OFN207_FE_OFN52_raw_prime_10
+ B[9]=Prime[9] B[8]=Prime[8] B[7]=Prime[7] B[6]=FE_OFN128_raw_prime_6
+ B[5]=Prime[5] B[4]=Prime[4] B[3]=FE_OFN654_FE_OFN59_raw_prime_3
+ B[2]=FE_OFN646_raw_prime_2 B[1]=FE_OFN652_FE_OFN87_n312 B[0]=Prime[0] CI=n21
+ SUM[32]=Px_add[32] SUM[31]=Px_add[31] SUM[30]=Px_add[30] SUM[29]=Px_add[29]
+ SUM[28]=Px_add[28] SUM[27]=Px_add[27] SUM[26]=Px_add[26] SUM[25]=Px_add[25]
+ SUM[24]=Px_add[24] SUM[23]=Px_add[23] SUM[22]=Px_add[22] SUM[21]=Px_add[21]
+ SUM[20]=Px_add[20] SUM[19]=Px_add[19] SUM[18]=Px_add[18] SUM[17]=Px_add[17]
+ SUM[16]=Px_add[16] SUM[15]=Px_add[15] SUM[14]=Px_add[14] SUM[13]=Px_add[13]
+ SUM[12]=Px_add[12] SUM[11]=Px_add[11] SUM[10]=Px_add[10] SUM[9]=Px_add[9]
+ SUM[8]=Px_add[8] SUM[7]=Px_add[7] SUM[6]=Px_add[6] SUM[5]=Px_add[5]
+ SUM[4]=Px_add[4] SUM[3]=Px_add[3] SUM[2]=Px_add[2] SUM[1]=Px_add[1]
+ SUM[0]=SYNOPSYS_UNCONNECTED__2
+ FE_OFN194_FE_OFN56_raw_prime_6=FE_OFN193_FE_OFN56_raw_prime_6
+ FE_OFN228_FE_OFN43_raw_prime_19=FE_OFN227_FE_OFN43_raw_prime_19
+ FE_OFN272_FE_OFN31_raw_prime_31=FE_OFN271_FE_OFN31_raw_prime_31
+ FE_OFN318_raw_prime_14=FE_OFN317_raw_prime_14
Xr341/U1_1_1 HA1 $PINS S=N41 C=r341/carry[2] A=counter[1] B=counter[0]
Xr341/U1_1_2 HA1 $PINS S=N42 C=r341/carry[3] A=counter[2] B=r341/carry[2]
Xr341/U1_1_3 HA1 $PINS S=N43 C=r341/carry[4] A=counter[3] B=r341/carry[3]
Xcounter_reg[4] QDFFRBN $PINS Q=FE_PHN742_counter_4 D=n533 CK=clk_clone5
+ RB=FE_OFN21_FE_DBTN1_i_i_rst
Xcounter_reg[1] QDFFRBN $PINS Q=counter[1] D=n535 CK=clk_clone5
+ RB=FE_OFN21_FE_DBTN1_i_i_rst
Xcounter_reg[2] QDFFRBN $PINS Q=counter[2] D=n536 CK=clk_clone5
+ RB=FE_OFN21_FE_DBTN1_i_i_rst
Xcounter_reg[0] QDFFRBN $PINS Q=counter[0] D=n534 CK=clk_clone5
+ RB=FE_OFN21_FE_DBTN1_i_i_rst
Xcounter_reg[3] QDFFRBN $PINS Q=FE_PHN964_counter_3 D=n537 CK=clk_clone5
+ RB=FE_OFN21_FE_DBTN1_i_i_rst
XPx_reg[31] QDFFRBS $PINS Q=Px_out[31] D=n569 CK=clk_clone1 RB=reset
XPy_reg[31] QDFFRBN $PINS Q=Py_out[31] D=n601 CK=clk RB=FE_OFN596_n
XPx_reg[30] QDFFRBN $PINS Q=Px_out[30] D=n568 CK=clk_clone1 RB=reset
XPy_reg[30] QDFFRBN $PINS Q=Py_out[30] D=n600 CK=clk RB=FE_OFN596_n
XPx_reg[27] QDFFRBN $PINS Q=Px_out[27] D=n565 CK=clk_clone1 RB=FE_OFN333_n
XPy_reg[27] QDFFRBN $PINS Q=Py_out[27] D=n597 CK=clk
+ RB=FE_OFN447_FE_OFN15_FE_DBTN1_i_i_rst
XPx_reg[29] QDFFRBN $PINS Q=Px_out[29] D=n567 CK=clk_clone1 RB=reset
XPy_reg[29] QDFFRBN $PINS Q=Py_out[29] D=n599 CK=clk RB=FE_OFN596_n
XPx_reg[28] QDFFRBN $PINS Q=Px_out[28] D=n566 CK=clk_clone1 RB=reset
XPy_reg[28] QDFFRBN $PINS Q=Py_out[28] D=n598 CK=clk
+ RB=FE_OFN447_FE_OFN15_FE_DBTN1_i_i_rst
Xstate_reg[1] QDFFRBN $PINS Q=state[1] D=state_nxt[1] CK=clk_clone5
+ RB=FE_OFN36_FE_DBTN1_i_i_rst
Xstate_reg[0] QDFFRBN $PINS Q=state[0] D=state_nxt[0] CK=clk_clone5
+ RB=FE_OFN21_FE_DBTN1_i_i_rst
XPx_reg[25] QDFFRBN $PINS Q=Px_out[25] D=n563 CK=clk_clone1 RB=FE_OFN333_n
XPy_reg[25] QDFFRBN $PINS Q=Py_out[25] D=n595 CK=clk
+ RB=FE_OFN447_FE_OFN15_FE_DBTN1_i_i_rst
XPx_reg[23] QDFFRBN $PINS Q=Px_out[23] D=n561 CK=clk RB=FE_OFN333_n
XPy_reg[23] QDFFRBN $PINS Q=Py_out[23] D=n593 CK=clk
+ RB=FE_OFN447_FE_OFN15_FE_DBTN1_i_i_rst
XPx_reg[24] QDFFRBN $PINS Q=Px_out[24] D=n562 CK=clk RB=FE_OFN333_n
XPx_reg[26] QDFFRBN $PINS Q=Px_out[26] D=n564 CK=clk_clone1 RB=FE_OFN333_n
XPy_reg[24] QDFFRBN $PINS Q=Py_out[24] D=n594 CK=clk
+ RB=FE_OFN447_FE_OFN15_FE_DBTN1_i_i_rst
XPy_reg[26] QDFFRBN $PINS Q=Py_out[26] D=n596 CK=clk
+ RB=FE_OFN447_FE_OFN15_FE_DBTN1_i_i_rst
XPx_reg[21] QDFFRBN $PINS Q=Px_out[21] D=n559 CK=clk RB=FE_OFN596_n
XPy_reg[21] QDFFRBN $PINS Q=FE_PHN1232_final_output_2_21 D=n591 CK=clk
+ RB=FE_OFN447_FE_OFN15_FE_DBTN1_i_i_rst
XPx_reg[22] QDFFRBN $PINS Q=Px_out[22] D=n560 CK=clk RB=FE_OFN596_n
XPy_reg[22] QDFFRBN $PINS Q=Py_out[22] D=n592 CK=clk
+ RB=FE_OFN447_FE_OFN15_FE_DBTN1_i_i_rst
XPy_reg[20] QDFFRBN $PINS Q=Py_out[20] D=n590 CK=clk
+ RB=FE_OFN447_FE_OFN15_FE_DBTN1_i_i_rst
XPx_reg[17] QDFFRBN $PINS Q=Px_out[17] D=n555 CK=clk RB=FE_OFN596_n
XPx_reg[19] QDFFRBN $PINS Q=Px_out[19] D=n557 CK=clk RB=FE_OFN596_n
XPy_reg[17] QDFFRBN $PINS Q=Py_out[17] D=n587 CK=clk
+ RB=FE_OFN447_FE_OFN15_FE_DBTN1_i_i_rst
XPy_reg[19] QDFFRBN $PINS Q=Py_out[19] D=n589 CK=clk
+ RB=FE_OFN447_FE_OFN15_FE_DBTN1_i_i_rst
XPx_reg[18] QDFFRBN $PINS Q=Px_out[18] D=n556 CK=clk RB=FE_OFN596_n
XPy_reg[18] QDFFRBN $PINS Q=Py_out[18] D=n588 CK=clk
+ RB=FE_OFN447_FE_OFN15_FE_DBTN1_i_i_rst
XPx_reg[16] QDFFRBN $PINS Q=Px_out[16] D=n554 CK=clk RB=FE_OFN596_n
XPy_reg[16] QDFFRBN $PINS Q=Py_out[16] D=n586 CK=clk_clone4
+ RB=FE_OFN446_FE_OFN15_FE_DBTN1_i_i_rst
XPx_reg[13] QDFFRBN $PINS Q=Px_out[13] D=n551 CK=clk RB=FE_OFN596_n
XPx_reg[15] QDFFRBN $PINS Q=Px_out[15] D=n553 CK=clk RB=FE_OFN596_n
XPy_reg[15] QDFFRBN $PINS Q=Py_out[15] D=n585 CK=clk_clone4
+ RB=FE_OFN446_FE_OFN15_FE_DBTN1_i_i_rst
XPx_reg[14] QDFFRBN $PINS Q=Px_out[14] D=n552 CK=clk RB=FE_OFN596_n
XPy_reg[14] QDFFRBN $PINS Q=Py_out[14] D=n584 CK=clk_clone4
+ RB=FE_OFN446_FE_OFN15_FE_DBTN1_i_i_rst
XPx_reg[9] QDFFRBN $PINS Q=Px_out[9] D=n547 CK=clk RB=FE_OFN43_FE_DBTN1_i_i_rst
XPx_reg[11] QDFFRBN $PINS Q=FE_PSRN_28 D=n549 CK=clk RB=FE_OFN596_n
XPy_reg[9] QDFFRBN $PINS Q=Py_out[9] D=n579 CK=clk_clone4
+ RB=FE_OFN446_FE_OFN15_FE_DBTN1_i_i_rst
XPy_reg[11] QDFFRBN $PINS Q=Py_out[11] D=n581 CK=clk_clone4
+ RB=FE_OFN30_FE_DBTN1_i_i_rst
XPx_reg[10] QDFFRBN $PINS Q=Px_out[10] D=n548 CK=clk RB=FE_OFN596_n
XPy_reg[10] QDFFRBN $PINS Q=Py_out[10] D=n580 CK=clk_clone4
+ RB=FE_OFN446_FE_OFN15_FE_DBTN1_i_i_rst
XPy_reg[12] QDFFRBN $PINS Q=Py_out[12] D=n582 CK=clk_clone4
+ RB=FE_OFN30_FE_DBTN1_i_i_rst
XPx_reg[7] QDFFRBN $PINS Q=Px_out[7] D=n545 CK=clk_clone3
+ RB=FE_OFN43_FE_DBTN1_i_i_rst
XPy_reg[7] QDFFRBN $PINS Q=Py_out[7] D=n577 CK=clk_clone2
+ RB=FE_OFN446_FE_OFN15_FE_DBTN1_i_i_rst
XPx_reg[8] QDFFRBN $PINS Q=Px_out[8] D=n546 CK=clk_clone3
+ RB=FE_OFN45_FE_DBTN1_i_i_rst
XPy_reg[8] QDFFRBN $PINS Q=Py_out[8] D=n578 CK=clk_clone4
+ RB=FE_OFN446_FE_OFN15_FE_DBTN1_i_i_rst
XPx_reg[6] QDFFRBN $PINS Q=Px_out[6] D=n544 CK=clk_clone3
+ RB=FE_OFN45_FE_DBTN1_i_i_rst
XPy_reg[6] QDFFRBN $PINS Q=Py_out[6] D=n576 CK=clk_clone2
+ RB=FE_OFN446_FE_OFN15_FE_DBTN1_i_i_rst
XPx_reg[3] QDFFRBN $PINS Q=Px_out[3] D=n541 CK=clk_clone3
+ RB=FE_OFN45_FE_DBTN1_i_i_rst
XPy_reg[3] QDFFRBN $PINS Q=FE_PSRN_26 D=n573 CK=clk_clone2
+ RB=FE_OFN447_FE_OFN15_FE_DBTN1_i_i_rst
XPx_reg[5] QDFFRBN $PINS Q=Px_out[5] D=n543 CK=clk_clone3
+ RB=FE_OFN45_FE_DBTN1_i_i_rst
XPx_reg[4] QDFFRBN $PINS Q=Px_out[4] D=n542 CK=clk_clone3
+ RB=FE_OFN45_FE_DBTN1_i_i_rst
XPy_reg[4] QDFFRBN $PINS Q=Py_out[4] D=n574 CK=clk_clone2
+ RB=FE_OFN446_FE_OFN15_FE_DBTN1_i_i_rst
XPx_reg[0] QDFFRBN $PINS Q=Px_out[0] D=n538 CK=clk_clone3
+ RB=FE_OFN31_FE_DBTN1_i_i_rst
XPx_reg[1] QDFFRBN $PINS Q=Px_out[1] D=n539 CK=clk_clone3
+ RB=FE_OFN25_FE_DBTN1_i_i_rst
XPx_reg[2] QDFFRBN $PINS Q=Px_out[2] D=n540 CK=clk_clone3
+ RB=FE_OFN45_FE_DBTN1_i_i_rst
XPy_reg[0] QDFFRBN $PINS Q=Py_out[0] D=n570 CK=clk
+ RB=FE_OFN447_FE_OFN15_FE_DBTN1_i_i_rst
XPy_reg[1] QDFFRBN $PINS Q=FE_PHN1297_final_output_2_1 D=n571 CK=clk
+ RB=FE_OFN447_FE_OFN15_FE_DBTN1_i_i_rst
XPy_reg[2] QDFFRBN $PINS Q=FE_PSRN_24 D=n572 CK=clk
+ RB=FE_OFN447_FE_OFN15_FE_DBTN1_i_i_rst
XPx_reg[12] QDFFRBN $PINS Q=Px_out[12] D=n550 CK=clk RB=FE_OFN596_n
XPx_reg[20] QDFFRBN $PINS Q=Px_out[20] D=n558 CK=clk RB=FE_OFN596_n
XPy_reg[13] QDFFRBN $PINS Q=Py_out[13] D=n583 CK=clk_clone4
+ RB=FE_OFN446_FE_OFN15_FE_DBTN1_i_i_rst
XPy_reg[5] QDFFRBN $PINS Q=FE_PSRN_21 D=n575 CK=clk_clone2
+ RB=FE_OFN446_FE_OFN15_FE_DBTN1_i_i_rst
XU7 ND2P $PINS O=n42 I1=N157 I2=FE_OFN628_n830
XU10 AOI22S $PINS O=n826 A1=Py_add[31] A2=FE_OFN543_n829 B1=Py_i[30]
+ B2=FE_OFN627_n828
XU17 ND2P $PINS O=n4 I1=n28 I2=n827
XU18 ND2S $PINS O=n600 I1=n826 I2=n5
XU19 INV1S $PINS O=n5 I=n4
XU31 ND2 $PINS O=n34 I1=Py_i[31] I2=FE_OFN627_n828
XU34 ND3P $PINS O=n832 I1=n41 I2=n42 I3=n43
XU35 ND2 $PINS O=n33 I1=Py_out[30] I2=FE_OFN538_n9
XU39 NR2 $PINS O=n7 I1=n524 I2=N257
XU41 NR2P $PINS O=n9 I1=n524 I2=N323
XU64 ND2 $PINS O=n40 I1=N290 I2=FE_OFN540_n729
XU65 ND3P $PINS O=n833 I1=n32 I2=n33 I3=n34
XU66 ND2P $PINS O=n32 I1=Py_add[32] I2=FE_OFN543_n829
XU68 OR2T $PINS O=n601 I1=n833 I2=n832
XU71 ND2P $PINS O=n38 I1=Px_add[32] I2=FE_OFN541_n730
XU72 ND2 $PINS O=n39 I1=Px_out[30] I2=FE_OFN537_n7
XU73 ND3 $PINS O=n734 I1=n40 I2=n39 I3=n38
XU74 ND2P $PINS O=n41 I1=N356 I2=FE_OFN544_n831
XU75 ND2 $PINS O=n43 I1=Py_out[31] I2=FE_OFN380_FE_OFN65_n933
XU78 OR2 $PINS O=n569 I1=n734 I2=n733
XU85 NR2P $PINS O=n45 I1=n527 I2=Py_out[0]
XU86 NR2 $PINS O=n46 I1=n527 I2=Px_out[0]
XU97 NR2 $PINS O=n731 I1=n523 I2=N58
XU99 NR2 $PINS O=n828 I1=n523 I2=N124
XU110 INV1S $PINS O=n525 I=done
XU117 AOI12HS $PINS O=n933 A1=n634 B1=in_sig B2=n528
XU118 INV1S $PINS O=n523 I=n835
XU120 AN2 $PINS O=n830 I1=N124 I2=n835
XU121 AN2 $PINS O=n732 I1=N58 I2=n835
XU124 INV1S $PINS O=n527 I=n840
XU125 INV1S $PINS O=n524 I=n836
XU126 AN2 $PINS O=n729 I1=N257 I2=n836
XU130 AN2 $PINS O=n831 I1=N323 I2=n836
XU132 NR2 $PINS O=done I1=n526 I2=n528
XU133 MOAI1S $PINS O=n536 A1=FE_PHN972_n531 A2=n525 B1=N42 B2=n634
XU134 MOAI1S $PINS O=n535 A1=FE_PHN752_n530 A2=n525 B1=N41 B2=n634
XU149 AOI22S $PINS O=n827 A1=Py_out[29] A2=FE_OFN538_n9 B1=FE_OFN539_n45
+ B2=Py_out[31]
XU150 AOI22S $PINS O=n821 A1=FE_PHN1547_final_output_2_27 A2=FE_OFN538_n9
+ B1=FE_OFN539_n45 B2=FE_PHN1190_final_output_2_29
XU151 AOI22S $PINS O=n820 A1=Py_add[29] A2=FE_OFN543_n829 B1=Py_i[28]
+ B2=FE_OFN627_n828
XU152 AOI22S $PINS O=n815 A1=Py_out[25] A2=FE_OFN538_n9
+ B1=FE_PHN1189_final_output_2_27 B2=FE_OFN539_n45
XU153 AOI22S $PINS O=n814 A1=Py_add[27] A2=FE_OFN543_n829 B1=Py_i[26]
+ B2=FE_OFN627_n828
XU154 AOI22S $PINS O=n824 A1=Py_out[28] A2=FE_OFN538_n9 B1=FE_OFN539_n45
+ B2=Py_out[30]
XU155 AOI22S $PINS O=n823 A1=Py_add[30] A2=FE_OFN543_n829 B1=Py_i[29]
+ B2=FE_OFN627_n828
XU156 AOI22S $PINS O=n818 A1=Py_out[26] A2=FE_OFN538_n9
+ B1=FE_PHN1178_final_output_2_28 B2=FE_OFN539_n45
XU157 AOI22S $PINS O=n817 A1=Py_add[28] A2=FE_OFN543_n829 B1=Py_i[27]
+ B2=FE_OFN627_n828
XU158 AOI22S $PINS O=n721 A1=Px_out[27] A2=FE_OFN537_n7 B1=FE_OFN625_n46
+ B2=Px_out[29]
XU159 AOI22S $PINS O=n720 A1=Px_add[29] A2=FE_OFN541_n730 B1=N287
+ B2=FE_OFN540_n729
XU160 AOI22S $PINS O=n727 A1=Px_out[29] A2=FE_OFN537_n7 B1=FE_OFN625_n46
+ B2=Px_out[31]
XU161 AOI22S $PINS O=n726 A1=Px_add[31] A2=FE_OFN541_n730 B1=N289
+ B2=FE_OFN540_n729
XU162 AOI22S $PINS O=n724 A1=Px_out[28] A2=FE_OFN537_n7 B1=FE_OFN625_n46
+ B2=Px_out[30]
XU163 AOI22S $PINS O=n723 A1=Px_add[30] A2=FE_OFN541_n730 B1=N288
+ B2=FE_OFN540_n729
XU164 AOI22S $PINS O=n718 A1=Px_out[26] A2=FE_OFN537_n7 B1=Px_out[28]
+ B2=FE_OFN625_n46
XU165 AOI22S $PINS O=n717 A1=Px_add[28] A2=FE_OFN541_n730 B1=N286
+ B2=FE_OFN540_n729
XU166 AOI22S $PINS O=n715 A1=Px_out[25] A2=FE_OFN537_n7 B1=Px_out[27]
+ B2=FE_OFN625_n46
XU167 AOI22S $PINS O=n714 A1=Px_add[27] A2=FE_OFN541_n730 B1=N285
+ B2=FE_OFN540_n729
XU177 AOI22S $PINS O=n809 A1=Py_out[23] A2=FE_OFN538_n9 B1=Py_out[25]
+ B2=FE_OFN539_n45
XU178 AOI22S $PINS O=n808 A1=Py_add[25] A2=FE_OFN543_n829 B1=Py_i[24]
+ B2=FE_OFN627_n828
XU179 AOI22S $PINS O=n803 A1=Py_out[21] A2=FE_OFN538_n9 B1=Py_out[23]
+ B2=FE_OFN539_n45
XU180 AOI22S $PINS O=n802 A1=Py_add[23] A2=FE_OFN543_n829 B1=Py_i[22]
+ B2=FE_OFN627_n828
XU181 AOI22S $PINS O=n812 A1=Py_out[24] A2=FE_OFN538_n9 B1=Py_out[26]
+ B2=FE_OFN539_n45
XU182 AOI22S $PINS O=n811 A1=Py_add[26] A2=FE_OFN543_n829 B1=Py_i[25]
+ B2=FE_OFN627_n828
XU183 AOI22S $PINS O=n806 A1=Py_out[22] A2=FE_OFN538_n9 B1=Py_out[24]
+ B2=FE_OFN539_n45
XU184 AOI22S $PINS O=n805 A1=Py_add[24] A2=FE_OFN543_n829 B1=Py_i[23]
+ B2=FE_OFN627_n828
XU185 AOI22S $PINS O=n712 A1=Px_out[24] A2=FE_OFN537_n7 B1=Px_out[26]
+ B2=FE_OFN625_n46
XU186 AOI22S $PINS O=n711 A1=Px_add[26] A2=FE_OFN541_n730 B1=N284
+ B2=FE_OFN540_n729
XU187 AOI22S $PINS O=n709 A1=Px_out[23] A2=FE_OFN537_n7 B1=Px_out[25]
+ B2=FE_OFN625_n46
XU188 AOI22S $PINS O=n708 A1=Px_add[25] A2=FE_OFN541_n730 B1=N283
+ B2=FE_OFN540_n729
XU189 AOI22S $PINS O=n706 A1=Px_out[22] A2=FE_OFN537_n7 B1=Px_out[24]
+ B2=FE_OFN625_n46
XU190 AOI22S $PINS O=n705 A1=Px_add[24] A2=FE_OFN541_n730 B1=N282
+ B2=FE_OFN540_n729
XU191 AOI22S $PINS O=n703 A1=FE_PHN1592_final_output_1_21 A2=FE_OFN537_n7
+ B1=FE_PHN1191_final_output_1_23 B2=FE_OFN625_n46
XU192 AOI22S $PINS O=n702 A1=Px_add[23] A2=FE_OFN541_n730 B1=N281
+ B2=FE_OFN540_n729
XU197 AOI22S $PINS O=n797 A1=Py_out[19] A2=FE_OFN538_n9 B1=Py_out[21]
+ B2=FE_OFN539_n45
XU198 AOI22S $PINS O=n796 A1=Py_add[21] A2=FE_OFN543_n829 B1=Py_i[20]
+ B2=FE_OFN627_n828
XU199 AOI22S $PINS O=n800 A1=Py_out[20] A2=FE_OFN538_n9 B1=Py_out[22]
+ B2=FE_OFN539_n45
XU200 AOI22S $PINS O=n799 A1=Py_add[22] A2=FE_OFN543_n829 B1=Py_i[21]
+ B2=FE_OFN627_n828
XU201 AOI22S $PINS O=n700 A1=Px_out[20] A2=FE_OFN537_n7 B1=Px_out[22]
+ B2=FE_OFN625_n46
XU202 AOI22S $PINS O=n699 A1=Px_add[22] A2=FE_OFN541_n730 B1=N280
+ B2=FE_OFN540_n729
XU203 AOI22S $PINS O=n697 A1=Px_out[19] A2=FE_OFN537_n7 B1=Px_out[21]
+ B2=FE_OFN625_n46
XU204 AOI22S $PINS O=n696 A1=Px_add[21] A2=FE_OFN541_n730 B1=N279
+ B2=FE_OFN540_n729
XU207 AOI22S $PINS O=n794 A1=Py_out[18] A2=FE_OFN538_n9 B1=Py_out[20]
+ B2=FE_OFN539_n45
XU208 AOI22S $PINS O=n793 A1=Py_add[20] A2=FE_OFN543_n829 B1=Py_i[19]
+ B2=FE_OFN627_n828
XU209 AOI22S $PINS O=n694 A1=Px_out[18] A2=FE_OFN537_n7 B1=Px_out[20]
+ B2=FE_OFN625_n46
XU210 AOI22S $PINS O=n693 A1=Px_add[20] A2=FE_OFN541_n730 B1=N278
+ B2=FE_OFN540_n729
XU217 AOI22S $PINS O=n791 A1=Py_out[17] A2=FE_OFN538_n9
+ B1=FE_PHN1197_final_output_2_19 B2=FE_OFN539_n45
XU218 AOI22S $PINS O=n790 A1=Py_add[19] A2=FE_OFN543_n829 B1=Py_i[18]
+ B2=FE_OFN627_n828
XU219 AOI22S $PINS O=n788 A1=Py_out[16] A2=FE_OFN538_n9 B1=Py_out[18]
+ B2=FE_OFN539_n45
XU220 AOI22S $PINS O=n787 A1=Py_add[18] A2=FE_OFN543_n829 B1=Py_i[17]
+ B2=FE_OFN627_n828
XU221 AOI22S $PINS O=n785 A1=Py_out[15] A2=FE_OFN538_n9 B1=Py_out[17] B2=n45
XU222 AOI22S $PINS O=n784 A1=Py_add[17] A2=FE_OFN543_n829 B1=Py_i[16]
+ B2=FE_OFN627_n828
XU223 AOI22S $PINS O=n691 A1=FE_PHN1586_final_output_1_17 A2=FE_OFN537_n7
+ B1=FE_PHN1195_final_output_1_19 B2=FE_OFN625_n46
XU224 AOI22S $PINS O=n690 A1=Px_add[19] A2=FE_OFN541_n730 B1=N277
+ B2=FE_OFN540_n729
XU225 AOI22S $PINS O=n688 A1=Px_out[16] A2=FE_OFN537_n7 B1=Px_out[18]
+ B2=FE_OFN625_n46
XU226 AOI22S $PINS O=n687 A1=Px_add[18] A2=FE_OFN541_n730 B1=N276
+ B2=FE_OFN540_n729
XU227 AOI22S $PINS O=n685 A1=Px_out[15] A2=FE_OFN537_n7
+ B1=FE_PHN1196_final_output_1_17 B2=FE_OFN625_n46
XU228 AOI22S $PINS O=n684 A1=Px_add[17] A2=FE_OFN541_n730 B1=N275
+ B2=FE_OFN540_n729
XU230 AOI22S $PINS O=n682 A1=Px_out[14] A2=FE_OFN537_n7
+ B1=FE_PHN1202_final_output_1_16 B2=FE_OFN625_n46
XU231 AOI22S $PINS O=n681 A1=Px_add[16] A2=FE_OFN541_n730 B1=N274
+ B2=FE_OFN540_n729
XU232 AOI22S $PINS O=n679 A1=Px_out[13] A2=FE_OFN537_n7 B1=Px_out[15]
+ B2=FE_OFN625_n46
XU233 AOI22S $PINS O=n678 A1=Px_add[15] A2=FE_OFN541_n730 B1=N273
+ B2=FE_OFN540_n729
XU234 AOI22S $PINS O=n676 A1=Px_out[12] A2=FE_OFN537_n7 B1=Px_out[14]
+ B2=FE_OFN625_n46
XU235 AOI22S $PINS O=n675 A1=Px_add[14] A2=FE_OFN541_n730 B1=N272
+ B2=FE_OFN540_n729
XU236 AOI22S $PINS O=n673 A1=Px_out[11] A2=n7 B1=Px_out[13] B2=FE_OFN625_n46
XU237 AOI22S $PINS O=n672 A1=Px_add[13] A2=FE_OFN541_n730 B1=N271 B2=n729
XU246 AOI22S $PINS O=n782 A1=Py_out[14] A2=FE_OFN538_n9 B1=Py_out[16] B2=n45
XU247 AOI22S $PINS O=n781 A1=Py_add[16] A2=n829 B1=Py_i[15] B2=FE_OFN627_n828
XU248 AOI22S $PINS O=n779 A1=Py_out[13] A2=FE_OFN538_n9 B1=Py_out[15] B2=n45
XU249 AOI22S $PINS O=n778 A1=Py_add[15] A2=n829 B1=Py_i[14] B2=FE_OFN627_n828
XU250 AOI22S $PINS O=n776 A1=Py_out[12] A2=n9 B1=Py_out[14] B2=n45
XU251 AOI22S $PINS O=n775 A1=Py_add[14] A2=n829 B1=Py_i[13] B2=FE_OFN627_n828
XU252 AOI22S $PINS O=n773 A1=Py_out[11] A2=n9 B1=Py_out[13] B2=n45
XU253 AOI22S $PINS O=n772 A1=Py_add[13] A2=n829 B1=Py_i[12] B2=n828
XU254 NR3 $PINS O=n835 I1=state[0] I2=state[1] I3=FE_OFN65_n933
XU255 AOI22S $PINS O=n670 A1=Px_out[10] A2=n7 B1=Px_out[12] B2=FE_OFN625_n46
XU256 AOI22S $PINS O=n669 A1=Px_add[12] A2=n730 B1=N270 B2=n729
XU258 AOI22S $PINS O=n667 A1=Px_out[9] A2=n7 B1=Px_out[11] B2=n46
XU259 AOI22S $PINS O=n666 A1=Px_add[11] A2=n730 B1=N269 B2=n729
XU261 AOI22S $PINS O=n664 A1=Px_out[8] A2=n7 B1=FE_PHN1173_final_output_1_10
+ B2=n46
XU322 AOI22S $PINS O=n663 A1=Px_add[10] A2=n730 B1=N268 B2=n729
XU323 AOI22S $PINS O=n661 A1=FE_PHN1583_final_output_1_7 A2=n7
+ B1=FE_PHN1162_final_output_1_9 B2=n46
XU324 AOI22S $PINS O=n660 A1=Px_add[9] A2=n730 B1=N267 B2=n729
XU325 AOI22S $PINS O=n658 A1=Px_out[6] A2=n7 B1=Px_out[8] B2=n46
XU387 AOI22S $PINS O=n657 A1=Px_add[8] A2=n730 B1=N266 B2=n729
XU448 AOI22S $PINS O=n655 A1=Px_out[5] A2=n7 B1=FE_PHN1200_final_output_1_7
+ B2=n46
XU453 AOI22S $PINS O=n654 A1=Px_add[7] A2=n730 B1=N265 B2=n729
XU454 AOI22S $PINS O=n652 A1=Px_out[4] A2=n7 B1=Px_out[6] B2=n46
XU455 AOI22S $PINS O=n651 A1=Px_add[6] A2=n730 B1=N264 B2=n729
XU456 AOI22S $PINS O=n649 A1=FE_PHN1557_final_output_1_3 A2=n7
+ B1=FE_PHN1177_final_output_1_5 B2=n46
XU457 AOI22S $PINS O=n648 A1=Px_add[5] A2=n730 B1=N263 B2=n729
XU458 AOI22S $PINS O=n646 A1=Px_out[2] A2=n7 B1=Px_out[4] B2=n46
XU459 AOI22S $PINS O=n645 A1=Px_add[4] A2=n730 B1=N262 B2=n729
XU460 AOI22S $PINS O=n643 A1=Px_out[1] A2=n7 B1=FE_PHN1186_final_output_1_3
+ B2=n46
XU461 AOI22S $PINS O=n642 A1=Px_add[3] A2=n730 B1=N261 B2=n729
XU462 AOI22S $PINS O=n639 A1=Px_add[2] A2=n730 B1=N260 B2=n729
XU463 AOI22S $PINS O=n640 A1=FE_PHN1152_final_output_1_0 A2=n7
+ B1=FE_PHN1181_final_output_1_2 B2=n46
XU486 AOI22S $PINS O=n770 A1=Py_out[10] A2=n9 B1=Py_out[12] B2=n45
XU487 AOI22S $PINS O=n769 A1=Py_add[12] A2=n829 B1=Py_i[11] B2=n828
XU488 AOI22S $PINS O=n767 A1=Py_out[9] A2=n9 B1=Py_out[11] B2=n45
XU489 AOI22S $PINS O=n766 A1=Py_add[11] A2=n829 B1=Py_i[10] B2=n828
XU490 AOI22S $PINS O=n764 A1=FE_PHN1261_final_output_2_8 A2=n9 B1=Py_out[10]
+ B2=n45
XU491 AOI22S $PINS O=n763 A1=Py_add[10] A2=n829 B1=Py_i[9] B2=n828
XU492 AOI22S $PINS O=n761 A1=Py_out[7] A2=n9 B1=FE_PHN1187_final_output_2_9
+ B2=n45
XU493 AOI22S $PINS O=n760 A1=Py_add[9] A2=n829 B1=Py_i[8] B2=n828
XU494 AOI22S $PINS O=n758 A1=Py_out[6] A2=n9 B1=FE_PHN1261_final_output_2_8
+ B2=n45
XU495 AOI22S $PINS O=n757 A1=Py_add[8] A2=n829 B1=Py_i[7] B2=n828
XU496 AOI22S $PINS O=n755 A1=Py_out[5] A2=n9 B1=Py_out[7] B2=n45
XU497 AOI22S $PINS O=n754 A1=Py_add[7] A2=n829 B1=Py_i[6] B2=n828
XU498 AOI22S $PINS O=n752 A1=Py_out[4] A2=n9 B1=Py_out[6] B2=n45
XU499 AOI22S $PINS O=n751 A1=Py_add[6] A2=n829 B1=Py_i[5] B2=n828
XU500 AOI22S $PINS O=n749 A1=Py_out[3] A2=n9 B1=Py_out[5] B2=n45
XU501 AOI22S $PINS O=n748 A1=Py_add[5] A2=n829 B1=Py_i[4] B2=n828
XU502 AOI22S $PINS O=n746 A1=Py_out[2] A2=n9 B1=Py_out[4] B2=n45
XU503 AOI22S $PINS O=n745 A1=Py_add[4] A2=n829 B1=Py_i[3] B2=n828
XU504 AOI22S $PINS O=n743 A1=Py_out[1] A2=n9 B1=Py_out[3] B2=FE_OFN539_n45
XU505 AOI22S $PINS O=n742 A1=Py_add[3] A2=n829 B1=Py_i[2] B2=n828
XU506 AOI22S $PINS O=FE_PHN1451_n740 A1=Py_out[0] A2=n9 B1=Py_out[2]
+ B2=FE_OFN539_n45
XU507 AOI22S $PINS O=n739 A1=Py_add[2] A2=n829 B1=Py_i[1] B2=n828
XU509 NR2 $PINS O=n840 I1=n528 I2=state[0]
XU510 INV1S $PINS O=n528 I=state[1]
XU511 NR2 $PINS O=n836 I1=n526 I2=state[1]
XU512 INV1S $PINS O=n526 I=state[0]
XU513 ND3 $PINS O=n538 I1=n638 I2=n637 I3=n636
XU514 AOI22S $PINS O=n638 A1=FE_PHN1152_final_output_1_0 A2=n635 B1=Px_out[1]
+ B2=n46
XU515 AOI22S $PINS O=n636 A1=p19 A2=n731 B1=N60 B2=n732
XU519 ND3 $PINS O=n570 I1=FE_PHN1449_n738 I2=n737 I3=n736
XU520 AOI22S $PINS O=n738 A1=Py_out[0] A2=n735 B1=Py_out[1] B2=FE_OFN539_n45
XU521 AOI22S $PINS O=n736 A1=N126 A2=n830 B1=N325 B2=n831
XU522 OAI112HS $PINS O=state_nxt[1] A1=n940 B1=n527 C1=n524 C2=n941
XU524 OAI112HS $PINS O=state_nxt[0] A1=n939 B1=n524 C1=n941 C2=n527
XU525 ND3 $PINS O=n939 I1=in_sig I2=n528 I3=ToMont
XU526 AN2 $PINS O=n829 I1=Py_out[0] I2=n840
XU527 AN2 $PINS O=n730 I1=Px_out[0] I2=n840
XU528 ND3 $PINS O=n941 I1=counter[4] I2=counter[3] I3=n938
XU529 NR3 $PINS O=n938 I1=n531 I2=n529 I3=n530
XU530 MOAI1S $PINS O=n534 A1=n529 A2=n525 B1=n529 B2=n634
XU531 INV1S $PINS O=n531 I=counter[2]
XU532 INV1S $PINS O=n529 I=FE_PHN1143_counter_0
XU533 INV1S $PINS O=n530 I=counter[1]
XU537 ND2S $PINS O=n637 I1=Prime[0] I2=n729
XU538 XOR2HS $PINS O=N44 I1=r341/carry[4] I2=counter[4]
.ENDS

.SUBCKT lookup_table i_rst lookup_table_done_from_control P_sel[1] P_sel[0]
+ mode Px_in[31] Px_in[30] Px_in[29] Px_in[28] Px_in[27] Px_in[26] Px_in[25]
+ Px_in[24] Px_in[23] Px_in[22] Px_in[21] Px_in[20] Px_in[19] Px_in[18]
+ Px_in[17] Px_in[16] Px_in[15] Px_in[14] Px_in[13] Px_in[12] Px_in[11]
+ Px_in[10] Px_in[9] Px_in[8] Px_in[7] Px_in[6] Px_in[5] Px_in[4] Px_in[3]
+ Px_in[2] Px_in[1] Px_in[0] Py_in[31] Py_in[30] Py_in[29] Py_in[28] Py_in[27]
+ Py_in[26] Py_in[25] Py_in[24] Py_in[23] Py_in[22] Py_in[21] Py_in[20]
+ Py_in[19] Py_in[18] Py_in[17] Py_in[16] Py_in[15] Py_in[14] Py_in[13]
+ Py_in[12] Py_in[11] Py_in[10] Py_in[9] Py_in[8] Py_in[7] Py_in[6] Py_in[5]
+ Py_in[4] Py_in[3] Py_in[2] Py_in[1] Py_in[0] Px_out[31] Px_out[30] Px_out[29]
+ Px_out[28] Px_out[27] Px_out[26] Px_out[25] Px_out[24] Px_out[23] Px_out[22]
+ Px_out[21] Px_out[20] Px_out[19] Px_out[18] Px_out[17] Px_out[16] Px_out[15]
+ Px_out[14] Px_out[13] Px_out[12] Px_out[11] Px_out[10] Px_out[9] Px_out[8]
+ Px_out[7] Px_out[6] Px_out[5] Px_out[4] Px_out[3] Px_out[2] Px_out[1]
+ Px_out[0] Py_out[31] Py_out[30] Py_out[29] Py_out[28] Py_out[27] Py_out[26]
+ Py_out[25] Py_out[24] Py_out[23] Py_out[22] Py_out[21] Py_out[20] Py_out[19]
+ Py_out[18] Py_out[17] Py_out[16] Py_out[15] Py_out[14] Py_out[13] Py_out[12]
+ Py_out[11] Py_out[10] Py_out[9] Py_out[8] Py_out[7] Py_out[6] Py_out[5]
+ Py_out[4] Py_out[3] Py_out[2] Py_out[1] Py_out[0] Port99 p1
+ FE_OFN46_FE_DBTN1_i_i_rst FE_OFN44_FE_DBTN1_i_i_rst FE_OFN42_FE_DBTN1_i_i_rst
+ FE_OFN32_FE_DBTN1_i_i_rst FE_OFN29_FE_DBTN1_i_i_rst FE_OFN27_FE_DBTN1_i_i_rst
+ FE_OFN26_FE_DBTN1_i_i_rst FE_OFN24_FE_DBTN1_i_i_rst FE_OFN22_FE_DBTN1_i_i_rst
+ FE_OFN276_FE_OFN14_FE_DBTN1_i_i_rst FE_OFN275_FE_OFN14_FE_DBTN1_i_i_rst
+ FE_OFN278_FE_OFN13_FE_DBTN1_i_i_rst FE_OFN277_FE_OFN13_FE_DBTN1_i_i_rst
+ FE_OFN282_FE_OFN11_FE_DBTN1_i_i_rst FE_OFN281_FE_OFN11_FE_DBTN1_i_i_rst
+ FE_OFN280_FE_OFN11_FE_DBTN1_i_i_rst FE_OFN285_FE_OFN10_FE_DBTN1_i_i_rst
+ FE_OFN284_FE_OFN10_FE_DBTN1_i_i_rst FE_OFN283_FE_OFN10_FE_DBTN1_i_i_rst
+ FE_OFN287_FE_OFN9_FE_DBTN1_i_i_rst FE_OFN286_FE_OFN9_FE_DBTN1_i_i_rst
+ FE_OFN290_FE_OFN8_FE_DBTN1_i_i_rst FE_OFN289_FE_OFN8_FE_DBTN1_i_i_rst
+ FE_OFN288_FE_OFN8_FE_DBTN1_i_i_rst FE_OFN329_n FE_OFN328_n FE_OFN327_n
+ FE_OFN331_n FE_OFN330_n i_clk_clone10 i_clk_clone9 i_clk_clone8 i_clk_clone7
+ i_clk_clone6 i_clk_clone5 i_clk_clone4 i_clk_clone3 i_clk_clone2 i_clk_clone1
+ i_clk
XFE_PHC1632_n97 BUF1CK $PINS O=FE_PHN1632_n97 I=n97
XFE_PHC1631_n257 BUF1CK $PINS O=FE_PHN1631_n257 I=n257
XFE_PHC1630_n89 BUF1CK $PINS O=n89 I=FE_PHN1630_n89
XFE_PHC1628_n82 BUF1CK $PINS O=FE_PHN1628_n82 I=n82
XFE_PHC1627_n247 BUF1CK $PINS O=FE_PHN1627_n247 I=n247
XFE_PHC1626_n216 BUF1CK $PINS O=FE_PHN1626_n216 I=n216
XFE_PHC1625_n88 BUF1CK $PINS O=n88 I=FE_PHN1625_n88
XFE_PHC1624_n224 BUF1CK $PINS O=FE_PHN1624_n224 I=n224
XFE_PHC1623_n222 BUF1CK $PINS O=FE_PHN1623_n222 I=n222
XFE_PHC1622_n256 BUF1CK $PINS O=FE_PHN1622_n256 I=n256
XFE_PHC1621_n260 BUF1CK $PINS O=FE_PHN1621_n260 I=n260
XFE_PHC1620_n252 BUF1CK $PINS O=FE_PHN1620_n252 I=n252
XFE_PHC1619_n253 BUF1CK $PINS O=FE_PHN1619_n253 I=n253
XFE_PHC1618_n228 BUF1CK $PINS O=FE_PHN1618_n228 I=n228
XFE_PHC1617_n263 BUF1CK $PINS O=FE_PHN1617_n263 I=n263
XFE_PHC1616_n207 BUF1CK $PINS O=n207 I=FE_PHN1616_n207
XFE_PHC1615_n236 BUF1CK $PINS O=FE_PHN1615_n236 I=n236
XFE_PHC1614_n86 BUF1CK $PINS O=FE_PHN1614_n86 I=n86
XFE_PHC1613_n230 BUF1CK $PINS O=FE_PHN1613_n230 I=n230
XFE_PHC1612_n237 BUF1CK $PINS O=FE_PHN1612_n237 I=n237
XFE_PHC1611_n238 BUF1CK $PINS O=FE_PHN1611_n238 I=n238
XFE_PHC1610_n266 BUF1CK $PINS O=FE_PHN1610_n266 I=n266
XFE_PHC1609_n229 BUF1CK $PINS O=FE_PHN1609_n229 I=n229
XFE_PHC1608_n243 BUF1CK $PINS O=FE_PHN1608_n243 I=n243
XFE_PHC1607_n254 BUF1CK $PINS O=FE_PHN1607_n254 I=n254
XFE_PHC1606_n208 BUF1CK $PINS O=FE_PHN1606_n208 I=n208
XFE_PHC1600_Py_out_from_look_13 BUF1CK $PINS O=FE_PHN817_Py_out_from_look_13
+ I=FE_PHN1600_Py_out_from_look_13
XFE_PHC1599_Px_store_3_29 BUF1CK $PINS O=FE_PHN671_Px_store_3_29
+ I=FE_PHN1599_Px_store_3_29
XFE_PHC1598_Px_out_from_look_13 BUF1CK $PINS O=FE_PHN1598_Px_out_from_look_13
+ I=Px_out[13]
XFE_PHC1597_Px_store_1_5 BUF2CK $PINS O=FE_PHN1597_Px_store_1_5
+ I=FE_PHN689_Px_store_1_5
XFE_PHC1595_Px_store_1_14 BUF1CK $PINS O=FE_PHN1595_Px_store_1_14
+ I=FE_PHN941_Px_store_1_14
XFE_PHC1594_Px_store_3_21 BUF1CK $PINS O=FE_PHN1594_Px_store_3_21
+ I=Px_store_3[21]
XFE_PHC1593_Py_store_3_16 BUF1CK $PINS O=FE_PHN932_Py_store_3_16
+ I=FE_PHN1593_Py_store_3_16
XFE_PHC1590_Py_store_3_1 BUF1CK $PINS O=FE_PHN1590_Py_store_3_1
+ I=FE_PHN930_Py_store_3_1
XFE_PHC1589_Py_store_1_11 BUF3 $PINS O=FE_PHN1589_Py_store_1_11
+ I=FE_PHN673_Py_store_1_11
XFE_PHC1588_Px_out_from_look_10 BUF1CK $PINS O=FE_PHN1588_Px_out_from_look_10
+ I=Px_out[10]
XFE_PHC1584_Py_out_from_look_24 BUF1CK $PINS O=FE_PHN794_Py_out_from_look_24
+ I=FE_PHN1584_Py_out_from_look_24
XFE_PHC1582_Py_store_3_18 BUF2CK $PINS O=FE_PHN900_Py_store_3_18
+ I=FE_PHN1582_Py_store_3_18
XFE_PHC1581_Py_store_1_13 BUF3 $PINS O=FE_PHN1581_Py_store_1_13
+ I=FE_PHN886_Py_store_1_13
XFE_PHC1579_Py_store_3_14 BUF1CK $PINS O=FE_PHN858_Py_store_3_14
+ I=FE_PHN1579_Py_store_3_14
XFE_PHC1575_Px_store_3_13 BUF1CK $PINS O=FE_PHN1575_Px_store_3_13
+ I=FE_PHN987_Px_store_3_13
XFE_PHC1573_Px_store_1_26 BUF3 $PINS O=FE_PHN1573_Px_store_1_26
+ I=FE_PHN690_Px_store_1_26
XFE_PHC1571_Px_out_from_look_4 BUF1CK $PINS O=FE_PHN1571_Px_out_from_look_4
+ I=Px_out[4]
XFE_PHC1570_Py_store_1_0 BUF1CK $PINS O=FE_PHN1570_Py_store_1_0
+ I=FE_PHN876_Py_store_1_0
XFE_PHC1569_FE_PSRN_113 BUF1CK $PINS O=FE_PHN1569_FE_PSRN_113 I=FE_PSRN_113
XFE_PHC1568_Px_out_from_look_26 BUF1CK $PINS O=FE_PHN1568_Px_out_from_look_26
+ I=Px_out[26]
XFE_PHC1567_Py_store_1_22 BUF3 $PINS O=FE_PHN1567_Py_store_1_22
+ I=Py_store_1[22]
XFE_PHC1566_Px_store_3_22 BUF2CK $PINS O=FE_PHN1566_Px_store_3_22
+ I=Px_store_3[22]
XFE_PHC1562_Py_out_from_look_8 BUF1CK $PINS O=FE_PHN812_Py_out_from_look_8
+ I=FE_PHN1562_Py_out_from_look_8
XFE_PHC1561_Py_store_3_19 BUF3 $PINS O=FE_PHN892_Py_store_3_19
+ I=FE_PHN1561_Py_store_3_19
XFE_PHC1560_Py_store_3_8 BUF1CK $PINS O=FE_PHN1560_Py_store_3_8 I=Py_store_3[8]
XFE_PHC1559_Px_store_3_31 BUF1CK $PINS O=FE_PHN849_Px_store_3_31
+ I=FE_PHN1559_Px_store_3_31
XFE_PHC1555_Py_out_from_look_28 BUF1CK $PINS O=FE_PHN815_Py_out_from_look_28
+ I=FE_PHN1555_Py_out_from_look_28
XFE_PHC1554_Py_store_3_0 BUF1CK $PINS O=FE_PHN1554_Py_store_3_0 I=Py_store_3[0]
XFE_PHC1553_Px_store_2_6 BUF1CK $PINS O=FE_PHN1553_Px_store_2_6
+ I=FE_PHN881_Px_store_2_6
XFE_PHC1552_Py_store_1_23 BUF1CK $PINS O=FE_PHN808_Py_store_1_23
+ I=FE_PHN1552_Py_store_1_23
XFE_PHC1551_Px_store_3_18 BUF1CK $PINS O=FE_PHN844_Px_store_3_18
+ I=FE_PHN1551_Px_store_3_18
XFE_PHC1550_Px_store_1_12 BUF1CK $PINS O=FE_PHN1550_Px_store_1_12
+ I=Px_store_1[12]
XFE_PHC1549_Py_store_3_21 BUF2CK $PINS O=FE_PHN1549_Py_store_3_21
+ I=Py_store_3[21]
XFE_PHC1548_Px_store_1_31 BUF1CK $PINS O=Px_store_1[31]
+ I=FE_PHN1548_Px_store_1_31
XFE_PHC1546_FE_PSRN_94 BUF1CK $PINS O=FE_PHN1546_FE_PSRN_94 I=FE_PSRN_94
XFE_PHC1545_Px_store_3_3 BUF1CK $PINS O=FE_PHN827_Px_store_3_3
+ I=FE_PHN1545_Px_store_3_3
XFE_PHC1544_Py_store_2_22 BUF1CK $PINS O=FE_PHN1544_Py_store_2_22
+ I=Py_store_2[22]
XFE_PHC1543_Px_store_1_2 BUF1CK $PINS O=FE_PHN1543_Px_store_1_2 I=Px_store_1[2]
XFE_PHC1542_Py_store_1_18 BUF1CK $PINS O=FE_PHN875_Py_store_1_18
+ I=FE_PHN1542_Py_store_1_18
XFE_PHC1541_Px_store_1_1 BUF1CK $PINS O=FE_PHN839_Px_store_1_1
+ I=FE_PHN1541_Px_store_1_1
XFE_PHC1540_Px_store_3_4 BUF1CK $PINS O=FE_PHN816_Px_store_3_4
+ I=FE_PHN1540_Px_store_3_4
XFE_PHC1539_Py_store_1_15 BUF1CK $PINS O=FE_PHN1539_Py_store_1_15
+ I=Py_store_1[15]
XFE_PHC1538_Py_store_2_1 BUF2CK $PINS O=FE_PHN1538_Py_store_2_1 I=Py_store_2[1]
XFE_PHC1536_Px_store_2_12 BUF2CK $PINS O=FE_PHN1536_Px_store_2_12
+ I=FE_PHN821_Px_store_2_12
XFE_PHC1533_Py_store_3_6 BUF1CK $PINS O=FE_PHN1533_Py_store_3_6 I=Py_store_3[6]
XFE_PHC1532_Px_store_2_25 BUF1CK $PINS O=FE_PHN917_Px_store_2_25
+ I=FE_PHN1532_Px_store_2_25
XFE_PHC1531_Py_store_1_6 BUF1CK $PINS O=FE_PHN1531_Py_store_1_6 I=Py_store_1[6]
XFE_PHC1530_Px_store_3_15 BUF1CK $PINS O=FE_PHN942_Px_store_3_15
+ I=FE_PHN1530_Px_store_3_15
XFE_PHC1529_Px_store_1_7 BUF1CK $PINS O=Px_store_1[7] I=FE_PHN1529_Px_store_1_7
XFE_PHC1528_Py_store_3_24 BUF1CK $PINS O=FE_PHN908_Py_store_3_24
+ I=FE_PHN1528_Py_store_3_24
XFE_PHC1527_Px_store_3_16 BUF1CK $PINS O=FE_PHN898_Px_store_3_16
+ I=FE_PHN1527_Px_store_3_16
XFE_PHC1526_Px_store_1_27 BUF1CK $PINS O=FE_PHN872_Px_store_1_27
+ I=FE_PHN1526_Px_store_1_27
XFE_PHC1525_Px_store_3_17 BUF1CK $PINS O=Px_store_3[17]
+ I=FE_PHN1525_Px_store_3_17
XFE_PHC1524_Py_store_1_8 BUF1CK $PINS O=FE_PHN842_Py_store_1_8
+ I=FE_PHN1524_Py_store_1_8
XFE_PHC1523_Py_out_from_look_10 BUF1CK $PINS O=FE_PHN809_Py_out_from_look_10
+ I=FE_PHN1523_Py_out_from_look_10
XFE_PHC1522_Py_store_1_3 BUF1CK $PINS O=FE_PHN824_Py_store_1_3
+ I=FE_PHN1522_Py_store_1_3
XFE_PHC1521_Py_store_1_28 BUF1CK $PINS O=FE_PHN877_Py_store_1_28
+ I=FE_PHN1521_Py_store_1_28
XFE_PHC1520_Py_store_3_28 BUF2CK $PINS O=FE_PHN1520_Py_store_3_28
+ I=Py_store_3[28]
XFE_PHC1518_Px_store_2_9 BUF1CK $PINS O=FE_PHN1518_Px_store_2_9
+ I=FE_PHN959_Px_store_2_9
XFE_PHC1516_Py_store_1_21 BUF1CK $PINS O=FE_PHN1516_Py_store_1_21
+ I=Py_store_1[21]
XFE_PHC1515_Py_store_1_1 BUF3CK $PINS O=FE_PHN1515_Py_store_1_1
+ I=FE_PHN951_Py_store_1_1
XFE_PHC1514_Py_store_3_26 BUF1CK $PINS O=FE_PHN871_Py_store_3_26
+ I=FE_PHN1514_Py_store_3_26
XFE_PHC1512_Py_store_3_23 BUF1CK $PINS O=FE_PHN1512_Py_store_3_23
+ I=Py_store_3[23]
XFE_PHC1511_Px_store_2_11 BUF1CK $PINS O=FE_PHN852_Px_store_2_11
+ I=FE_PHN1511_Px_store_2_11
XFE_PHC1510_Py_store_1_30 BUF1CK $PINS O=FE_PHN851_Py_store_1_30
+ I=FE_PHN1510_Py_store_1_30
XFE_PHC1508_Py_store_1_27 BUF1CK $PINS O=FE_PHN841_Py_store_1_27
+ I=FE_PHN1508_Py_store_1_27
XFE_PHC1506_Px_store_3_30 BUF1CK $PINS O=FE_PHN912_Px_store_3_30
+ I=FE_PHN1506_Px_store_3_30
XFE_PHC1504_Py_store_3_12 BUF1CK $PINS O=FE_PHN1504_Py_store_3_12
+ I=Py_store_3[12]
XFE_PHC1502_Py_store_1_31 BUF1CK $PINS O=Py_store_1[31]
+ I=FE_PHN1502_Py_store_1_31
XFE_PHC1500_Py_store_3_20 BUF1CK $PINS O=FE_PHN1500_Py_store_3_20
+ I=Py_store_3[20]
XFE_PHC1499_Px_store_3_19 BUF1CK $PINS O=Px_store_3[19]
+ I=FE_PHN1499_Px_store_3_19
XFE_PHC1498_Px_store_2_16 BUF1CK $PINS O=FE_PHN1498_Px_store_2_16
+ I=Px_store_2[16]
XFE_PHC1497_Px_store_2_17 BUF1CK $PINS O=FE_PHN1497_Px_store_2_17
+ I=Px_store_2[17]
XFE_PHC1496_Px_store_1_23 BUF1CK $PINS O=Px_store_1[23]
+ I=FE_PHN1496_Px_store_1_23
XFE_PHC1494_Py_store_2_10 BUF1CK $PINS O=FE_PHN843_Py_store_2_10
+ I=FE_PHN1494_Py_store_2_10
XFE_PHC1493_Px_store_1_20 BUF1CK $PINS O=FE_PHN1493_Px_store_1_20
+ I=Px_store_1[20]
XFE_PHC1492_Px_store_2_24 BUF1CK $PINS O=FE_PHN1492_Px_store_2_24
+ I=Px_store_2[24]
XFE_PHC1491_Py_store_3_30 BUF1CK $PINS O=FE_PHN1491_Py_store_3_30
+ I=Py_store_3[30]
XFE_PHC1488_Py_store_2_26 BUF1CK $PINS O=FE_PHN1488_Py_store_2_26
+ I=FE_PHN921_Py_store_2_26
XFE_PHC1486_Px_store_3_7 BUF1CK $PINS O=FE_PHN1486_Px_store_3_7 I=Px_store_3[7]
XFE_PHC1485_Px_store_2_3 BUF1CK $PINS O=FE_PHN1485_Px_store_2_3 I=Px_store_2[3]
XFE_PHC1482_Px_store_2_31 BUF1CK $PINS O=FE_PHN1482_Px_store_2_31
+ I=Px_store_2[31]
XFE_PHC1481_Py_store_2_24 BUF1CK $PINS O=FE_PHN1481_Py_store_2_24
+ I=Py_store_2[24]
XFE_PHC1480_Py_store_2_3 BUF1CK $PINS O=FE_PHN847_Py_store_2_3
+ I=FE_PHN1480_Py_store_2_3
XFE_PHC1478_Px_store_2_0 BUF1CK $PINS O=FE_PHN1478_Px_store_2_0 I=Px_store_2[0]
XFE_PHC1477_Py_store_1_5 BUF1CK $PINS O=FE_PHN910_Py_store_1_5
+ I=FE_PHN1477_Py_store_1_5
XFE_PHC1476_Px_store_2_8 BUF1CK $PINS O=Px_store_2[8] I=FE_PHN1476_Px_store_2_8
XFE_PHC1474_Py_store_1_2 BUF1CK $PINS O=FE_PHN811_Py_store_1_2
+ I=FE_PHN1474_Py_store_1_2
XFE_PHC1473_Py_store_2_16 BUF1CK $PINS O=FE_PHN1473_Py_store_2_16
+ I=Py_store_2[16]
XFE_PHC1472_Px_store_2_1 BUF1CK $PINS O=Px_store_2[1] I=FE_PHN1472_Px_store_2_1
XFE_PHC1471_Px_store_2_19 BUF1CK $PINS O=FE_PHN888_Px_store_2_19
+ I=FE_PHN1471_Px_store_2_19
XFE_PHC1470_Py_store_1_29 BUF1CK $PINS O=FE_PHN1470_Py_store_1_29
+ I=Py_store_1[29]
XFE_PHC1469_Py_store_2_15 BUF1CK $PINS O=Py_store_2[15]
+ I=FE_PHN1469_Py_store_2_15
XFE_PHC1468_Px_store_2_2 BUF1CK $PINS O=Px_store_2[2] I=FE_PHN1468_Px_store_2_2
XFE_PHC1467_Px_store_2_30 BUF1CK $PINS O=FE_PHN1467_Px_store_2_30
+ I=Px_store_2[30]
XFE_PHC1466_Py_store_2_28 BUF1CK $PINS O=FE_PHN914_Py_store_2_28
+ I=FE_PHN1466_Py_store_2_28
XFE_PHC1465_Py_store_2_25 BUF1CK $PINS O=FE_PHN927_Py_store_2_25
+ I=FE_PHN1465_Py_store_2_25
XFE_PHC1464_Py_store_2_8 BUF1CK $PINS O=FE_PHN1464_Py_store_2_8 I=Py_store_2[8]
XFE_PHC1462_Px_store_2_7 BUF1CK $PINS O=Px_store_2[7] I=FE_PHN1462_Px_store_2_7
XFE_PHC1461_Px_store_2_18 BUF1CK $PINS O=Px_store_2[18]
+ I=FE_PHN1461_Px_store_2_18
XFE_PHC1460_Py_store_2_6 BUF1CK $PINS O=Py_store_2[6] I=FE_PHN1460_Py_store_2_6
XFE_PHC1459_Py_store_2_4 BUF1CK $PINS O=FE_PHN1459_Py_store_2_4 I=Py_store_2[4]
XFE_PHC1458_Py_store_2_14 BUF1CK $PINS O=FE_PHN1458_Py_store_2_14
+ I=Py_store_2[14]
XFE_PHC1457_Py_store_2_2 BUF1CK $PINS O=FE_PHN903_Py_store_2_2
+ I=FE_PHN1457_Py_store_2_2
XFE_PHC1456_Py_store_2_27 BUF1CK $PINS O=FE_PHN894_Py_store_2_27
+ I=FE_PHN1456_Py_store_2_27
XFE_PHC1455_Py_store_2_29 BUF1CK $PINS O=FE_PHN936_Py_store_2_29
+ I=FE_PHN1455_Py_store_2_29
XFE_PHC1454_Py_store_2_5 BUF1CK $PINS O=FE_PHN1454_Py_store_2_5 I=Py_store_2[5]
XFE_PHC987_Px_store_3_13 BUF1S $PINS O=FE_PHN987_Px_store_3_13 I=Px_store_3[13]
XFE_PHC960_Py_store_1_29 BUF1S $PINS O=FE_PHN960_Py_store_1_29
+ I=FE_PHN1470_Py_store_1_29
XFE_PHC959_Px_store_2_9 BUF1S $PINS O=FE_PHN959_Px_store_2_9 I=Px_store_2[9]
XFE_PHC958_Py_out_from_look_29 BUF1S $PINS O=Py_out[29]
+ I=FE_PHN958_Py_out_from_look_29
XFE_PHC957_Px_store_3_7 BUF1S $PINS O=FE_PHN957_Px_store_3_7
+ I=FE_PHN1486_Px_store_3_7
XFE_PHC956_Py_store_2_8 BUF1S $PINS O=FE_PHN956_Py_store_2_8
+ I=FE_PHN1464_Py_store_2_8
XFE_PHC955_Py_store_3_6 BUF1S $PINS O=FE_PHN955_Py_store_3_6
+ I=FE_PHN1533_Py_store_3_6
XFE_PHC954_Px_store_2_18 BUF1S $PINS O=FE_PHN954_Px_store_2_18 I=Px_store_2[18]
XFE_PHC953_Py_store_2_16 BUF1S $PINS O=FE_PHN953_Py_store_2_16
+ I=FE_PHN1473_Py_store_2_16
XFE_PHC952_Py_store_2_6 BUF1S $PINS O=FE_PHN952_Py_store_2_6 I=Py_store_2[6]
XFE_PHC951_Py_store_1_1 BUF1S $PINS O=FE_PHN951_Py_store_1_1 I=Py_store_1[1]
XFE_PHC950_Py_store_3_30 BUF1S $PINS O=FE_PHN950_Py_store_3_30
+ I=FE_PHN1491_Py_store_3_30
XFE_PHC948_Px_store_3_19 BUF1S $PINS O=FE_PHN948_Px_store_3_19 I=Px_store_3[19]
XFE_PHC947_Py_store_2_14 BUF1S $PINS O=FE_PHN947_Py_store_2_14
+ I=FE_PHN1458_Py_store_2_14
XFE_PHC946_Py_store_3_20 BUF1S $PINS O=FE_PHN946_Py_store_3_20
+ I=FE_PHN1500_Py_store_3_20
XFE_PHC944_Py_store_3_23 BUF1S $PINS O=FE_PHN944_Py_store_3_23
+ I=FE_PHN1512_Py_store_3_23
XFE_PHC943_Py_store_3_28 BUF1S $PINS O=FE_PHN943_Py_store_3_28
+ I=FE_PHN1520_Py_store_3_28
XFE_PHC942_Px_store_3_15 BUF1S $PINS O=Px_store_3[15] I=FE_PHN942_Px_store_3_15
XFE_PHC941_Px_store_1_14 BUF1S $PINS O=FE_PHN941_Px_store_1_14 I=Px_store_1[14]
XFE_PHC939_Py_store_3_10 DELA $PINS O=FE_PHN939_Py_store_3_10 I=Py_store_3[10]
XFE_PHC938_Px_store_1_23 BUF1S $PINS O=FE_PHN938_Px_store_1_23 I=Px_store_1[23]
XFE_PHC937_Px_store_2_24 BUF1S $PINS O=FE_PHN937_Px_store_2_24
+ I=FE_PHN1492_Px_store_2_24
XFE_PHC936_Py_store_2_29 BUF1S $PINS O=Py_store_2[29] I=FE_PHN936_Py_store_2_29
XFE_PHC935_Py_store_2_4 BUF1S $PINS O=FE_PHN935_Py_store_2_4
+ I=FE_PHN1459_Py_store_2_4
XFE_PHC934_Py_store_3_12 BUF1S $PINS O=FE_PHN934_Py_store_3_12
+ I=FE_PHN1504_Py_store_3_12
XFE_PHC933_Py_store_1_20 BUF1S $PINS O=FE_PHN933_Py_store_1_20 I=Py_store_1[20]
XFE_PHC932_Py_store_3_16 BUF1S $PINS O=Py_store_3[16] I=FE_PHN932_Py_store_3_16
XFE_PHC931_Px_out_from_look_0 BUF1S $PINS O=Px_out[0] I=FE_PSRN_180
XFE_PHC930_Py_store_3_1 BUF1S $PINS O=FE_PHN930_Py_store_3_1 I=Py_store_3[1]
XFE_PHC929_Px_store_3_17 BUF1S $PINS O=FE_PHN929_Px_store_3_17 I=Px_store_3[17]
XFE_PHC927_Py_store_2_25 BUF1S $PINS O=Py_store_2[25] I=FE_PHN927_Py_store_2_25
XFE_PHC926_Px_store_3_1 BUF1S $PINS O=Px_store_3[1] I=FE_PHN926_Px_store_3_1
XFE_PHC925_Py_store_2_5 BUF1S $PINS O=FE_PHN925_Py_store_2_5
+ I=FE_PHN1454_Py_store_2_5
XFE_PHC924_Px_store_1_28 BUF1S $PINS O=Px_store_1[28] I=FE_PHN924_Px_store_1_28
XFE_PHC922_Py_store_3_22 BUF1S $PINS O=Py_store_3[22] I=FE_PHN922_Py_store_3_22
XFE_PHC921_Py_store_2_26 BUF1S $PINS O=FE_PHN921_Py_store_2_26 I=Py_store_2[26]
XFE_PHC920_Py_store_3_0 BUF1S $PINS O=FE_PHN920_Py_store_3_0
+ I=FE_PHN1554_Py_store_3_0
XFE_PHC919_Px_store_3_0 BUF1S $PINS O=Px_store_3[0] I=FE_PHN919_Px_store_3_0
XFE_PHC918_Px_store_1_13 BUF1S $PINS O=FE_PHN918_Px_store_1_13 I=Px_store_1[13]
XFE_PHC917_Px_store_2_25 BUF1S $PINS O=Px_store_2[25] I=FE_PHN917_Px_store_2_25
XFE_PHC916_Px_store_2_7 BUF1S $PINS O=FE_PHN916_Px_store_2_7 I=Px_store_2[7]
XFE_PHC914_Py_store_2_28 BUF1S $PINS O=Py_store_2[28] I=FE_PHN914_Py_store_2_28
XFE_PHC913_Px_store_1_3 BUF1S $PINS O=Px_store_1[3] I=FE_PHN913_Px_store_1_3
XFE_PHC912_Px_store_3_30 BUF1S $PINS O=Px_store_3[30] I=FE_PHN912_Px_store_3_30
XFE_PHC911_Py_store_1_21 BUF1S $PINS O=FE_PHN911_Py_store_1_21
+ I=FE_PHN1516_Py_store_1_21
XFE_PHC910_Py_store_1_5 BUF1S $PINS O=Py_store_1[5] I=FE_PHN910_Py_store_1_5
XFE_PHC909_Px_out_from_look_4 BUF1S $PINS O=Px_out[4]
+ I=FE_PHN909_Px_out_from_look_4
XFE_PHC908_Py_store_3_24 BUF1S $PINS O=Py_store_3[24] I=FE_PHN908_Py_store_3_24
XFE_PHC907_Py_store_1_31 BUF1S $PINS O=FE_PHN907_Py_store_1_31 I=Py_store_1[31]
XFE_PHC906_Py_store_3_3 BUF1S $PINS O=Py_store_3[3] I=FE_PHN906_Py_store_3_3
XFE_PHC905_Px_store_1_20 BUF1S $PINS O=FE_PHN905_Px_store_1_20
+ I=FE_PHN1493_Px_store_1_20
XFE_PHC904_Py_store_3_13 DELA $PINS O=FE_PHN904_Py_store_3_13 I=Py_store_3[13]
XFE_PHC903_Py_store_2_2 BUF1S $PINS O=Py_store_2[2] I=FE_PHN903_Py_store_2_2
XFE_PHC902_Py_store_2_18 BUF1S $PINS O=Py_store_2[18] I=FE_PHN902_Py_store_2_18
XFE_PHC900_Py_store_3_18 BUF1S $PINS O=Py_store_3[18] I=FE_PHN900_Py_store_3_18
XFE_PHC899_Py_store_1_15 BUF1S $PINS O=FE_PHN899_Py_store_1_15
+ I=FE_PHN1539_Py_store_1_15
XFE_PHC898_Px_store_3_16 BUF1S $PINS O=Px_store_3[16] I=FE_PHN898_Px_store_3_16
XFE_PHC897_Px_store_2_8 BUF1S $PINS O=FE_PHN897_Px_store_2_8 I=Px_store_2[8]
XFE_PHC896_Px_store_3_28 DELA $PINS O=FE_PHN896_Px_store_3_28 I=Px_store_3[28]
XFE_PHC895_Px_store_2_17 BUF1S $PINS O=Px_store_2[17] I=FE_PHN895_Px_store_2_17
XFE_PHC894_Py_store_2_27 BUF1S $PINS O=Py_store_2[27] I=FE_PHN894_Py_store_2_27
XFE_PHC893_Px_store_1_31 BUF1S $PINS O=FE_PHN893_Px_store_1_31 I=Px_store_1[31]
XFE_PHC892_Py_store_3_19 BUF1S $PINS O=Py_store_3[19] I=FE_PHN892_Py_store_3_19
XFE_PHC891_Px_store_3_9 BUF1S $PINS O=Px_store_3[9] I=FE_PHN891_Px_store_3_9
XFE_PHC890_Px_store_3_5 BUF1S $PINS O=Px_store_3[5] I=FE_PHN890_Px_store_3_5
XFE_PHC889_Py_store_1_7 DELA $PINS O=Py_store_1[7] I=FE_PHN889_Py_store_1_7
XFE_PHC888_Px_store_2_19 BUF1S $PINS O=Px_store_2[19] I=FE_PHN888_Px_store_2_19
XFE_PHC887_Px_store_1_7 BUF1S $PINS O=FE_PHN887_Px_store_1_7 I=Px_store_1[7]
XFE_PHC886_Py_store_1_13 BUF1S $PINS O=FE_PHN886_Py_store_1_13 I=Py_store_1[13]
XFE_PHC885_Py_store_1_19 DELA $PINS O=FE_PHN885_Py_store_1_19 I=Py_store_1[19]
XFE_PHC884_Py_store_1_16 DELA $PINS O=Py_store_1[16] I=FE_PHN884_Py_store_1_16
XFE_PHC883_Px_store_1_21 BUF1S $PINS O=Px_store_1[21] I=FE_PHN883_Px_store_1_21
XFE_PHC881_Px_store_2_6 BUF1S $PINS O=FE_PHN881_Px_store_2_6 I=Px_store_2[6]
XFE_PHC880_Px_store_2_3 BUF1S $PINS O=Px_store_2[3] I=FE_PHN880_Px_store_2_3
XFE_PHC879_Py_store_2_15 BUF1S $PINS O=FE_PHN879_Py_store_2_15 I=Py_store_2[15]
XFE_PHC878_Px_store_2_31 BUF1S $PINS O=Px_store_2[31] I=FE_PHN878_Px_store_2_31
XFE_PHC877_Py_store_1_28 BUF1S $PINS O=Py_store_1[28] I=FE_PHN877_Py_store_1_28
XFE_PHC876_Py_store_1_0 BUF1S $PINS O=FE_PHN876_Py_store_1_0 I=Py_store_1[0]
XFE_PHC875_Py_store_1_18 BUF1S $PINS O=Py_store_1[18] I=FE_PHN875_Py_store_1_18
XFE_PHC874_Py_store_3_29 DELA $PINS O=Py_store_3[29] I=FE_PHN874_Py_store_3_29
XFE_PHC872_Px_store_1_27 BUF1S $PINS O=Px_store_1[27] I=FE_PHN872_Px_store_1_27
XFE_PHC871_Py_store_3_26 BUF1S $PINS O=Py_store_3[26] I=FE_PHN871_Py_store_3_26
XFE_PHC870_Py_store_2_24 BUF1S $PINS O=FE_PHN870_Py_store_2_24
+ I=FE_PHN1481_Py_store_2_24
XFE_PHC869_Px_store_2_30 BUF1S $PINS O=FE_PHN869_Px_store_2_30
+ I=FE_PHN1467_Px_store_2_30
XFE_PHC868_Py_store_2_22 BUF1S $PINS O=Py_store_2[22] I=FE_PHN868_Py_store_2_22
XFE_PHC867_Px_store_2_1 BUF1S $PINS O=FE_PHN867_Px_store_2_1 I=Px_store_2[1]
XFE_PHC865_Px_store_1_2 BUF1S $PINS O=FE_PHN865_Px_store_1_2
+ I=FE_PHN1543_Px_store_1_2
XFE_PHC864_Px_store_2_2 BUF1S $PINS O=FE_PHN864_Px_store_2_2 I=Px_store_2[2]
XFE_PHC863_Py_store_3_15 DELA $PINS O=Py_store_3[15] I=FE_PHN863_Py_store_3_15
XFE_PHC861_Py_store_3_21 BUF1S $PINS O=FE_PHN861_Py_store_3_21
+ I=FE_PHN1549_Py_store_3_21
XFE_PHC859_Px_store_2_15 DELA $PINS O=FE_PHN859_Px_store_2_15 I=Px_store_2[15]
XFE_PHC858_Py_store_3_14 BUF1S $PINS O=Py_store_3[14] I=FE_PHN858_Py_store_3_14
XFE_PHC857_Px_out_from_look_24 BUF1S $PINS O=Px_out[24]
+ I=FE_PHN857_Px_out_from_look_24
XFE_PHC855_Py_store_3_5 DELA $PINS O=Py_store_3[5] I=FE_PHN855_Py_store_3_5
XFE_PHC854_Px_store_3_2 BUF1S $PINS O=FE_PHN854_Px_store_3_2 I=Px_store_3[2]
XFE_PHC853_Py_store_3_17 DELA $PINS O=Py_store_3[17] I=FE_PHN853_Py_store_3_17
XFE_PHC852_Px_store_2_11 BUF1S $PINS O=Px_store_2[11] I=FE_PHN852_Px_store_2_11
XFE_PHC851_Py_store_1_30 BUF1S $PINS O=Py_store_1[30] I=FE_PHN851_Py_store_1_30
XFE_PHC850_Px_out_from_look_15 BUF1S $PINS O=Px_out[15]
+ I=FE_PHN850_Px_out_from_look_15
XFE_PHC849_Px_store_3_31 BUF1S $PINS O=Px_store_3[31] I=FE_PHN849_Px_store_3_31
XFE_PHC848_Py_store_1_9 DELA $PINS O=Py_store_1[9] I=FE_PHN848_Py_store_1_9
XFE_PHC847_Py_store_2_3 BUF1S $PINS O=Py_store_2[3] I=FE_PHN847_Py_store_2_3
XFE_PHC846_Px_store_2_0 BUF1S $PINS O=FE_PHN846_Px_store_2_0
+ I=FE_PHN1478_Px_store_2_0
XFE_PHC845_Px_out_from_look_14 BUF1S $PINS O=Px_out[14]
+ I=FE_PHN845_Px_out_from_look_14
XFE_PHC844_Px_store_3_18 BUF1S $PINS O=Px_store_3[18] I=FE_PHN844_Px_store_3_18
XFE_PHC843_Py_store_2_10 BUF1S $PINS O=Py_store_2[10] I=FE_PHN843_Py_store_2_10
XFE_PHC842_Py_store_1_8 BUF1S $PINS O=Py_store_1[8] I=FE_PHN842_Py_store_1_8
XFE_PHC841_Py_store_1_27 BUF1S $PINS O=Py_store_1[27] I=FE_PHN841_Py_store_1_27
XFE_PHC839_Px_store_1_1 BUF1S $PINS O=Px_store_1[1] I=FE_PHN839_Px_store_1_1
XFE_PHC838_Py_store_2_9 DELA $PINS O=Py_store_2[9] I=FE_PHN838_Py_store_2_9
XFE_PHC837_Py_store_1_12 DELA $PINS O=FE_PHN837_Py_store_1_12 I=Py_store_1[12]
XFE_PHC835_Px_store_1_22 DELA $PINS O=Px_store_1[22] I=FE_PHN835_Px_store_1_22
XFE_PHC834_Py_store_3_31 DELA $PINS O=FE_PHN834_Py_store_3_31 I=Py_store_3[31]
XFE_PHC833_Px_out_from_look_18 BUF1S $PINS O=Px_out[18]
+ I=FE_PHN833_Px_out_from_look_18
XFE_PHC832_Px_store_2_28 DELA $PINS O=Px_store_2[28] I=FE_PHN832_Px_store_2_28
XFE_PHC831_Px_store_1_4 DELA $PINS O=FE_PHN831_Px_store_1_4 I=Px_store_1[4]
XFE_PHC830_Py_store_1_6 BUF1S $PINS O=FE_PHN830_Py_store_1_6
+ I=FE_PHN1531_Py_store_1_6
XFE_PHC828_Py_store_3_27 DELA $PINS O=Py_store_3[27] I=FE_PHN828_Py_store_3_27
XFE_PHC827_Px_store_3_3 BUF1S $PINS O=Px_store_3[3] I=FE_PHN827_Px_store_3_3
XFE_PHC826_Px_store_1_12 BUF1S $PINS O=Px_store_1[12] I=FE_PHN826_Px_store_1_12
XFE_PHC825_Py_store_1_22 BUF1S $PINS O=Py_store_1[22] I=FE_PHN825_Py_store_1_22
XFE_PHC824_Py_store_1_3 BUF1S $PINS O=Py_store_1[3] I=FE_PHN824_Py_store_1_3
XFE_PHC823_Py_out_from_look_30 DELA $PINS O=Py_out[30]
+ I=FE_PHN823_Py_out_from_look_30
XFE_PHC822_Px_out_from_look_26 BUF1S $PINS O=Px_out[26]
+ I=FE_PHN822_Px_out_from_look_26
XFE_PHC821_Px_store_2_12 BUF1S $PINS O=FE_PHN821_Px_store_2_12 I=Px_store_2[12]
XFE_PHC819_Py_store_3_8 BUF1S $PINS O=FE_PHN819_Py_store_3_8
+ I=FE_PHN1560_Py_store_3_8
XFE_PHC818_Px_out_from_look_19 BUF1S $PINS O=Px_out[19]
+ I=FE_PHN818_Px_out_from_look_19
XFE_PHC817_Py_out_from_look_13 BUF1S $PINS O=Py_out[13]
+ I=FE_PHN817_Py_out_from_look_13
XFE_PHC816_Px_store_3_4 BUF1S $PINS O=Px_store_3[4] I=FE_PHN816_Px_store_3_4
XFE_PHC815_Py_out_from_look_28 BUF1S $PINS O=Py_out[28]
+ I=FE_PHN815_Py_out_from_look_28
XFE_PHC813_Py_out_from_look_16 BUF1S $PINS O=Py_out[16]
+ I=FE_PHN1569_FE_PSRN_113
XFE_PHC812_Py_out_from_look_8 BUF1S $PINS O=Py_out[8]
+ I=FE_PHN812_Py_out_from_look_8
XFE_PHC811_Py_store_1_2 BUF1S $PINS O=Py_store_1[2] I=FE_PHN811_Py_store_1_2
XFE_PHC810_Px_out_from_look_8 BUF1S $PINS O=Px_out[8]
+ I=FE_PHN810_Px_out_from_look_8
XFE_PHC809_Py_out_from_look_10 BUF1S $PINS O=Py_out[10]
+ I=FE_PHN809_Py_out_from_look_10
XFE_PHC808_Py_store_1_23 BUF1S $PINS O=Py_store_1[23] I=FE_PHN808_Py_store_1_23
XFE_PHC807_Py_store_2_1 BUF1S $PINS O=Py_store_2[1] I=FE_PHN807_Py_store_2_1
XFE_PHC806_Px_out_from_look_6 BUF1S $PINS O=Px_out[6]
+ I=FE_PHN806_Px_out_from_look_6
XFE_PHC804_Px_out_from_look_7 BUF1S $PINS O=Px_out[7]
+ I=FE_PHN804_Px_out_from_look_7
XFE_PHC802_Py_store_2_7 DELA $PINS O=FE_PHN802_Py_store_2_7 I=Py_store_2[7]
XFE_PHC801_Px_store_2_26 DELA $PINS O=Px_store_2[26] I=FE_PHN801_Px_store_2_26
XFE_PHC799_Py_store_1_17 DELA $PINS O=Py_store_1[17] I=FE_PHN799_Py_store_1_17
XFE_PHC798_Px_out_from_look_27 BUF1S $PINS O=Px_out[27]
+ I=FE_PHN798_Px_out_from_look_27
XFE_PHC797_Px_store_2_10 DELA $PINS O=Px_store_2[10] I=FE_PHN797_Px_store_2_10
XFE_PHC796_Px_store_2_16 BUF1S $PINS O=Px_store_2[16] I=FE_PHN796_Px_store_2_16
XFE_PHC795_Px_store_2_27 BUF1S $PINS O=FE_PHN795_Px_store_2_27 I=Px_store_2[27]
XFE_PHC794_Py_out_from_look_24 BUF1S $PINS O=Py_out[24]
+ I=FE_PHN794_Py_out_from_look_24
XFE_PHC793_Py_store_2_12 DELA $PINS O=Py_store_2[12] I=FE_PHN793_Py_store_2_12
XFE_PHC792_Py_store_1_24 BUF1S $PINS O=FE_PHN792_Py_store_1_24 I=Py_store_1[24]
XFE_PHC791_Py_out_from_look_6 BUF1S $PINS O=Py_out[6]
+ I=FE_PHN791_Py_out_from_look_6
XFE_PHC790_Px_store_1_18 DELA $PINS O=FE_PHN790_Px_store_1_18 I=Px_store_1[18]
XFE_PHC789_Py_store_2_19 DELA $PINS O=FE_PHN789_Py_store_2_19 I=Py_store_2[19]
XFE_PHC788_Py_store_2_23 DELA $PINS O=FE_PHN788_Py_store_2_23 I=Py_store_2[23]
XFE_PHC787_Py_store_2_11 DELA $PINS O=Py_store_2[11] I=FE_PHN787_Py_store_2_11
XFE_PHC786_Py_out_from_look_20 BUF1S $PINS O=Py_out[20] I=FE_PHN1546_FE_PSRN_94
XFE_PHC785_Px_store_2_29 DELA $PINS O=FE_PHN785_Px_store_2_29 I=Px_store_2[29]
XFE_PHC784_Px_store_2_14 DELA $PINS O=FE_PHN784_Px_store_2_14 I=Px_store_2[14]
XFE_PHC783_Py_store_2_13 DELA $PINS O=Py_store_2[13] I=FE_PHN783_Py_store_2_13
XFE_PHC782_Px_out_from_look_25 BUF1S $PINS O=Px_out[25]
+ I=FE_PHN782_Px_out_from_look_25
XFE_PHC780_Px_store_2_5 DELA $PINS O=Px_store_2[5] I=FE_PHN780_Px_store_2_5
XFE_PHC778_Px_store_2_4 DELA $PINS O=FE_PHN778_Px_store_2_4 I=Px_store_2[4]
XFE_PHC777_Px_store_2_23 DELA $PINS O=Px_store_2[23] I=FE_PHN777_Px_store_2_23
XFE_PHC776_Px_store_2_21 DELA $PINS O=FE_PHN776_Px_store_2_21 I=Px_store_2[21]
XFE_PHC775_Py_store_3_2 DELA $PINS O=Py_store_3[2] I=FE_PHN775_Py_store_3_2
XFE_PHC774_Py_store_2_0 DELA $PINS O=FE_PHN774_Py_store_2_0 I=Py_store_2[0]
XFE_PHC773_Py_store_2_20 DELA $PINS O=Py_store_2[20] I=FE_PHN773_Py_store_2_20
XFE_PHC771_Py_store_2_17 DELA $PINS O=Py_store_2[17] I=FE_PHN771_Py_store_2_17
XFE_PHC770_Px_store_2_20 DELA $PINS O=FE_PHN770_Px_store_2_20 I=Px_store_2[20]
XFE_PHC768_Px_store_2_22 DELA $PINS O=FE_PHN768_Px_store_2_22 I=Px_store_2[22]
XFE_PHC765_Py_out_from_look_0 DELA $PINS O=Py_out[0] I=FE_PSRN_85
XFE_PHC764_Px_out_from_look_13 BUF1S $PINS O=Px_out[13] I=FE_PSRN_84
XFE_PHC763_Py_out_from_look_15 BUF1S $PINS O=Py_out[15]
+ I=FE_PHN763_Py_out_from_look_15
XFE_PHC762_Py_store_2_30 DELA $PINS O=FE_PHN762_Py_store_2_30 I=Py_store_2[30]
XFE_PHC761_Py_store_2_31 DELA $PINS O=FE_PHN761_Py_store_2_31 I=Py_store_2[31]
XFE_PHC759_Py_store_2_21 DELA $PINS O=FE_PHN759_Py_store_2_21 I=Py_store_2[21]
XFE_PHC758_Py_out_from_look_26 DELA $PINS O=Py_out[26] I=FE_PSRN_82
XFE_PHC743_Py_out_from_look_4 BUF1S $PINS O=Py_out[4]
+ I=FE_PHN743_Py_out_from_look_4
XFE_PHC741_Py_out_from_look_23 BUF1S $PINS O=Py_out[23]
+ I=FE_PHN741_Py_out_from_look_23
XFE_PHC740_Px_store_1_15 BUF1S $PINS O=Px_store_1[15] I=FE_PHN740_Px_store_1_15
XFE_PHC739_Px_out_from_look_3 BUF1S $PINS O=Px_out[3] I=FE_PSRN_77
XFE_PHC738_Py_out_from_look_25 BUF1S $PINS O=Py_out[25] I=FE_PSRN_75
XFE_PHC737_Px_out_from_look_21 BUF1S $PINS O=Px_out[21] I=FE_PSRN_73
XFE_PHC736_Py_out_from_look_27 BUF1S $PINS O=Py_out[27]
+ I=FE_PHN736_Py_out_from_look_27
XFE_PHC735_Px_store_3_25 BUF1S $PINS O=FE_PHN735_Px_store_3_25 I=Px_store_3[25]
XFE_PHC734_Px_out_from_look_2 BUF1S $PINS O=Px_out[2] I=FE_PSRN_70
XFE_PHC733_Py_out_from_look_21 BUF1S $PINS O=Py_out[21]
+ I=FE_PHN733_Py_out_from_look_21
XFE_PHC732_Py_out_from_look_1 BUF1S $PINS O=Py_out[1]
+ I=FE_PHN732_Py_out_from_look_1
XFE_PHC731_Py_out_from_look_31 BUF1S $PINS O=Py_out[31]
+ I=FE_PHN731_Py_out_from_look_31
XFE_PHC730_Py_out_from_look_2 BUF1S $PINS O=Py_out[2]
+ I=FE_PHN730_Py_out_from_look_2
XFE_PHC729_Px_out_from_look_5 BUF1S $PINS O=Px_out[5] I=FE_PSRN_65
XFE_PHC728_Py_store_3_11 BUF1S $PINS O=FE_PHN728_Py_store_3_11 I=Py_store_3[11]
XFE_PHC727_Px_store_3_10 BUF1S $PINS O=Px_store_3[10] I=FE_PHN727_Px_store_3_10
XFE_PHC726_Px_store_1_19 BUF1S $PINS O=Px_store_1[19] I=FE_PHN726_Px_store_1_19
XFE_PHC725_Py_out_from_look_11 BUF1S $PINS O=Py_out[11]
+ I=FE_PHN725_Py_out_from_look_11
XFE_PHC724_Px_store_2_13 BUF1S $PINS O=FE_PHN724_Px_store_2_13 I=Px_store_2[13]
XFE_PHC723_Px_store_3_24 BUF1S $PINS O=Px_store_3[24] I=FE_PHN723_Px_store_3_24
XFE_PHC722_Py_store_1_14 BUF1S $PINS O=Py_store_1[14] I=FE_PHN722_Py_store_1_14
XFE_PHC721_Py_out_from_look_17 BUF1S $PINS O=Py_out[17] I=FE_PSRN_58
XFE_PHC720_Px_store_1_25 BUF1S $PINS O=Px_store_1[25] I=FE_PHN720_Px_store_1_25
XFE_PHC719_Px_store_3_14 BUF1S $PINS O=FE_PHN719_Px_store_3_14 I=Px_store_3[14]
XFE_PHC718_Px_store_3_11 BUF1S $PINS O=Px_store_3[11] I=FE_PHN718_Px_store_3_11
XFE_PHC717_Px_store_1_10 BUF1S $PINS O=Px_store_1[10] I=FE_PHN717_Px_store_1_10
XFE_PHC716_Py_out_from_look_9 BUF1S $PINS O=Py_out[9] I=FE_PSRN_53
XFE_PHC715_Px_out_from_look_1 BUF1S $PINS O=Px_out[1]
+ I=FE_PHN715_Px_out_from_look_1
XFE_PHC714_Py_store_3_7 BUF1S $PINS O=Py_store_3[7] I=FE_PHN714_Py_store_3_7
XFE_PHC713_Py_out_from_look_7 BUF1S $PINS O=Py_out[7] I=FE_PSRN_49
XFE_PHC712_Px_store_3_6 BUF1S $PINS O=FE_PHN712_Px_store_3_6 I=Px_store_3[6]
XFE_PHC711_Px_out_from_look_29 BUF1S $PINS O=Px_out[29]
+ I=FE_PHN711_Px_out_from_look_29
XFE_PHC710_Py_out_from_look_5 BUF1S $PINS O=Py_out[5]
+ I=FE_PHN710_Py_out_from_look_5
XFE_PHC709_Px_store_3_23 BUF1S $PINS O=FE_PHN709_Px_store_3_23 I=Px_store_3[23]
XFE_PHC708_Py_store_1_26 BUF1S $PINS O=Py_store_1[26] I=FE_PHN708_Py_store_1_26
XFE_PHC707_Px_store_3_12 BUF1S $PINS O=Px_store_3[12] I=FE_PHN707_Px_store_3_12
XFE_PHC706_Px_store_3_20 BUF1S $PINS O=Px_store_3[20] I=FE_PHN706_Px_store_3_20
XFE_PHC705_Px_out_from_look_16 BUF1S $PINS O=Px_out[16]
+ I=FE_PHN705_Px_out_from_look_16
XFE_PHC704_Px_out_from_look_17 BUF1S $PINS O=Px_out[17] I=FE_PSRN_41
XFE_PHC703_Px_out_from_look_28 BUF1S $PINS O=Px_out[28]
+ I=FE_PHN703_Px_out_from_look_28
XFE_PHC702_Py_store_3_4 BUF1S $PINS O=Py_store_3[4] I=FE_PHN702_Py_store_3_4
XFE_PHC701_Py_out_from_look_18 BUF1S $PINS O=Py_out[18] I=FE_PSRN_37
XFE_PHC700_Px_store_1_24 BUF1S $PINS O=Px_store_1[24] I=FE_PHN700_Px_store_1_24
XFE_PHC699_Px_store_3_21 BUF1S $PINS O=Px_store_3[21] I=FE_PHN699_Px_store_3_21
XFE_PHC698_Px_store_3_27 BUF1S $PINS O=Px_store_3[27] I=FE_PHN698_Px_store_3_27
XFE_PHC697_Px_out_from_look_11 BUF1S $PINS O=Px_out[11]
+ I=FE_PHN697_Px_out_from_look_11
XFE_PHC696_Py_out_from_look_14 BUF1S $PINS O=Py_out[14]
+ I=FE_PHN696_Py_out_from_look_14
XFE_PHC695_Px_store_3_26 BUF1S $PINS O=Px_store_3[26] I=FE_PHN695_Px_store_3_26
XFE_PHC694_Px_store_1_29 BUF1S $PINS O=Px_store_1[29] I=FE_PHN694_Px_store_1_29
XFE_PHC693_Py_out_from_look_3 BUF1S $PINS O=Py_out[3] I=FE_PSRN_28
XFE_PHC692_Py_store_3_9 BUF1S $PINS O=Py_store_3[9] I=FE_PHN692_Py_store_3_9
XFE_PHC691_Px_store_1_11 BUF1S $PINS O=FE_PHN691_Px_store_1_11 I=Px_store_1[11]
XFE_PHC690_Px_store_1_26 BUF1S $PINS O=FE_PHN690_Px_store_1_26 I=Px_store_1[26]
XFE_PHC689_Px_store_1_5 BUF1S $PINS O=FE_PHN689_Px_store_1_5 I=Px_store_1[5]
XFE_PHC688_Py_store_3_25 BUF1S $PINS O=FE_PHN688_Py_store_3_25 I=Py_store_3[25]
XFE_PHC687_Px_out_from_look_20 BUF1S $PINS O=Px_out[20]
+ I=FE_PHN687_Px_out_from_look_20
XFE_PHC686_Py_out_from_look_12 BUF1S $PINS O=Py_out[12] I=FE_PSRN_24
XFE_PHC685_Py_store_1_10 BUF1S $PINS O=FE_PHN685_Py_store_1_10 I=Py_store_1[10]
XFE_PHC684_Py_store_1_25 BUF1S $PINS O=FE_PHN684_Py_store_1_25 I=Py_store_1[25]
XFE_PHC683_Px_store_3_22 BUF1S $PINS O=Px_store_3[22] I=FE_PHN683_Px_store_3_22
XFE_PHC682_Px_store_1_6 BUF1S $PINS O=Px_store_1[6] I=FE_PHN682_Px_store_1_6
XFE_PHC681_Px_store_1_30 BUF1S $PINS O=Px_store_1[30] I=FE_PHN681_Px_store_1_30
XFE_PHC680_Px_store_1_9 BUF1S $PINS O=FE_PHN680_Px_store_1_9 I=Px_store_1[9]
XFE_PHC679_Px_store_1_0 BUF1S $PINS O=Px_store_1[0] I=FE_PHN679_Px_store_1_0
XFE_PHC678_Px_store_3_8 BUF1S $PINS O=FE_PHN678_Px_store_3_8 I=Px_store_3[8]
XFE_PHC677_Px_store_1_8 BUF1S $PINS O=Px_store_1[8] I=FE_PHN677_Px_store_1_8
XFE_PHC676_Px_store_1_17 BUF1S $PINS O=Px_store_1[17] I=FE_PHN676_Px_store_1_17
XFE_PHC675_Px_out_from_look_23 BUF1S $PINS O=Px_out[23]
+ I=FE_PHN675_Px_out_from_look_23
XFE_PHC674_Py_store_1_4 BUF1S $PINS O=Py_store_1[4] I=FE_PHN674_Py_store_1_4
XFE_PHC673_Py_store_1_11 BUF1S $PINS O=FE_PHN673_Py_store_1_11 I=Py_store_1[11]
XFE_PHC672_Py_out_from_look_22 BUF1S $PINS O=Py_out[22]
+ I=FE_PHN672_Py_out_from_look_22
XFE_PHC671_Px_store_3_29 BUF1S $PINS O=Px_store_3[29] I=FE_PHN671_Px_store_3_29
XFE_PHC670_Px_out_from_look_30 BUF1S $PINS O=Px_out[30]
+ I=FE_PHN670_Px_out_from_look_30
XFE_PHC669_Px_out_from_look_12 BUF1S $PINS O=Px_out[12]
+ I=FE_PHN669_Px_out_from_look_12
XFE_PHC668_Px_out_from_look_10 BUF1S $PINS O=Px_out[10] I=FE_PSRN_10
XFE_PHC667_Py_out_from_look_19 BUF1S $PINS O=Py_out[19] I=FE_PSRN_8
XFE_PHC666_Px_store_1_16 BUF1S $PINS O=Px_store_1[16] I=FE_PHN666_Px_store_1_16
XFE_PHC665_Px_out_from_look_22 BUF1S $PINS O=Px_out[22] I=FE_PSRN_5
XFE_PHC664_Px_out_from_look_9 BUF1S $PINS O=Px_out[9] I=FE_PSRN_3
XFE_PHC663_Px_out_from_look_31 BUF1S $PINS O=Px_out[31]
+ I=FE_PHN663_Px_out_from_look_31
XFE_OFC546_n137 BUF1 $PINS O=FE_OFN579_n I=FE_OFN577_n
XFE_OFC545_n137 INV1S $PINS O=FE_OFN578_n I=FE_OFN575_n
XFE_OFC544_n137 INV1S $PINS O=FE_OFN577_n I=FE_OFN575_n
XFE_OFC543_n137 BUF1 $PINS O=FE_OFN576_n I=FE_OFN69_n137
XFE_OFC542_n137 INV1S $PINS O=FE_OFN575_n I=FE_OFN69_n137
XFE_OFC541_n170 BUF1 $PINS O=FE_OFN574_n I=FE_OFN71_n170
XFE_OFC540_n170 BUF1 $PINS O=FE_OFN573_n I=FE_OFN72_n170
XFE_OFC539_n170 BUF1 $PINS O=FE_OFN572_n I=FE_OFN72_n170
XFE_OFC538_n171 BUF1 $PINS O=FE_OFN571_n I=FE_OFN74_n171
XFE_OFC537_n171 BUF1 $PINS O=FE_OFN570_n I=FE_OFN75_n171
XFE_OFC536_n171 BUF1 $PINS O=FE_OFN569_n I=FE_OFN75_n171
XFE_OFC520_n171 BUF1 $PINS O=FE_OFN553_n171 I=FE_OFN552_n171
XFE_OFC519_n171 BUF1 $PINS O=FE_OFN552_n171 I=n171
XFE_OFC518_n170 BUF1 $PINS O=FE_OFN551_n170 I=FE_OFN550_n170
XFE_OFC517_n170 BUF1 $PINS O=FE_OFN550_n170 I=n170
XFE_OFC516_n137 BUF1 $PINS O=FE_OFN549_n137 I=FE_OFN548_n137
XFE_OFC515_n137 BUF1 $PINS O=FE_OFN548_n137 I=n137
XFE_OFC514_n6 BUF1 $PINS O=FE_OFN547_n6 I=FE_OFN545_n6
XFE_OFC513_n6 BUF1 $PINS O=FE_OFN546_n6 I=FE_OFN545_n6
XFE_OFC512_n6 BUF1 $PINS O=FE_OFN545_n6 I=n6
XFE_OFC417_FE_OFN14_FE_DBTN1_i_i_rst BUF1 $PINS
+ O=FE_OFN450_FE_OFN14_FE_DBTN1_i_i_rst I=FE_OFN276_FE_OFN14_FE_DBTN1_i_i_rst
XFE_OFC343_FE_OFN66_n3 INV1S $PINS O=FE_OFN376_FE_OFN66_n3
+ I=FE_OFN374_FE_OFN66_n3
XFE_OFC342_FE_OFN66_n3 INV2 $PINS O=FE_OFN375_FE_OFN66_n3
+ I=FE_OFN374_FE_OFN66_n3
XFE_OFC341_FE_OFN66_n3 INV1S $PINS O=FE_OFN374_FE_OFN66_n3 I=n3
XFE_OFC340_FE_OFN66_n3 BUF1 $PINS O=FE_OFN373_FE_OFN66_n3 I=n3
XFE_OFC339_FE_OFN67_n4 BUF1 $PINS O=FE_OFN372_FE_OFN67_n4
+ I=FE_OFN371_FE_OFN67_n4
XFE_OFC338_FE_OFN67_n4 BUF1 $PINS O=FE_OFN371_FE_OFN67_n4 I=n4
XFE_OFC337_FE_OFN67_n4 BUF1 $PINS O=FE_OFN370_FE_OFN67_n4 I=n4
XFE_OFC336_FE_OFN68_n5 BUF1 $PINS O=FE_OFN369_FE_OFN68_n5
+ I=FE_OFN367_FE_OFN68_n5
XFE_OFC335_FE_OFN68_n5 BUF1 $PINS O=FE_OFN368_FE_OFN68_n5
+ I=FE_OFN367_FE_OFN68_n5
XFE_OFC334_FE_OFN68_n5 BUF1 $PINS O=FE_OFN367_FE_OFN68_n5 I=FE_OFN68_n5
XFE_OFC73_n171 INV1S $PINS O=FE_OFN75_n171 I=FE_OFN73_n171
XFE_OFC72_n171 INV1S $PINS O=FE_OFN74_n171 I=FE_OFN73_n171
XFE_OFC71_n171 INV1S $PINS O=FE_OFN73_n171 I=n171
XFE_OFC70_n170 INV1S $PINS O=FE_OFN72_n170 I=FE_OFN70_n170
XFE_OFC69_n170 INV1S $PINS O=FE_OFN71_n170 I=FE_OFN70_n170
XFE_OFC68_n170 INV1S $PINS O=FE_OFN70_n170 I=n170
XFE_OFC67_n137 BUF1CK $PINS O=FE_OFN69_n137 I=n137
XFE_OFC66_n5 BUF1 $PINS O=FE_OFN68_n5 I=n5
XU2 ND2 $PINS O=n204 I1=n1 I2=n2
XU5 ND2 $PINS O=n205 I1=n7 I2=n8
XU8 ND2 $PINS O=n206 I1=n9 I2=n10
XU11 ND2 $PINS O=FE_PHN1616_n207 I1=n11 I2=n12
XU14 ND2 $PINS O=n208 I1=n13 I2=n14
XU17 ND2 $PINS O=n209 I1=n15 I2=n16
XU20 ND2 $PINS O=n210 I1=n17 I2=n18
XU23 ND2 $PINS O=n211 I1=n19 I2=n20
XU26 ND2 $PINS O=n212 I1=n21 I2=n22
XU29 ND2 $PINS O=n213 I1=n23 I2=n24
XU32 ND2 $PINS O=n214 I1=n25 I2=n26
XU35 ND2 $PINS O=n215 I1=n27 I2=n28
XU38 ND2 $PINS O=n216 I1=n29 I2=n30
XU41 ND2 $PINS O=n217 I1=n31 I2=n32
XU44 ND2 $PINS O=n218 I1=n33 I2=n34
XU47 ND2 $PINS O=n219 I1=n35 I2=n36
XU50 ND2 $PINS O=n220 I1=n37 I2=n38
XU53 ND2 $PINS O=n221 I1=n39 I2=n40
XU56 ND2 $PINS O=n222 I1=n41 I2=n42
XU59 ND2 $PINS O=n223 I1=n43 I2=n44
XU62 ND2 $PINS O=n224 I1=n45 I2=n46
XU65 ND2 $PINS O=n225 I1=n47 I2=n48
XU68 ND2 $PINS O=n226 I1=n49 I2=n50
XU71 ND2 $PINS O=n227 I1=n51 I2=n52
XU74 ND2 $PINS O=n228 I1=n53 I2=n54
XU77 ND2 $PINS O=n229 I1=n55 I2=n56
XU80 ND2 $PINS O=n230 I1=n57 I2=n58
XU83 ND2 $PINS O=n231 I1=n59 I2=n60
XU86 ND2 $PINS O=n232 I1=n61 I2=n62
XU89 ND2 $PINS O=n233 I1=n63 I2=n64
XU92 ND2 $PINS O=n234 I1=n65 I2=n66
XU95 ND2 $PINS O=n235 I1=n67 I2=n68
XU98 ND2 $PINS O=n236 I1=n69 I2=n70
XU101 ND2 $PINS O=n237 I1=n71 I2=n72
XU104 ND2 $PINS O=n238 I1=n73 I2=n74
XU107 ND2 $PINS O=n239 I1=n75 I2=n76
XU110 ND2 $PINS O=n240 I1=n77 I2=n78
XU113 ND2 $PINS O=n241 I1=n79 I2=n80
XU116 ND2 $PINS O=n242 I1=n81 I2=FE_PHN1628_n82
XU119 ND2 $PINS O=n243 I1=n83 I2=n84
XU122 ND2 $PINS O=n244 I1=n85 I2=FE_PHN1614_n86
XU125 ND2 $PINS O=n245 I1=n87 I2=n88
XU128 ND2 $PINS O=n246 I1=n89 I2=n90
XU131 ND2 $PINS O=n247 I1=n91 I2=n92
XU134 ND2 $PINS O=n248 I1=n93 I2=n94
XU137 ND2 $PINS O=n249 I1=n95 I2=n96
XU140 ND2 $PINS O=n250 I1=FE_PHN1632_n97 I2=n98
XU143 ND2 $PINS O=n251 I1=n99 I2=n100
XU146 ND2 $PINS O=n252 I1=n101 I2=n102
XU149 ND2 $PINS O=n253 I1=n103 I2=n104
XU152 ND2 $PINS O=n254 I1=n105 I2=n106
XU155 ND2 $PINS O=n255 I1=n107 I2=n108
XU158 ND2 $PINS O=n256 I1=n109 I2=n110
XU161 ND2 $PINS O=n257 I1=n111 I2=n112
XU164 ND2 $PINS O=n258 I1=n113 I2=n114
XU167 ND2 $PINS O=n259 I1=n115 I2=n116
XU170 ND2 $PINS O=n260 I1=n117 I2=n118
XU173 ND2 $PINS O=n261 I1=n119 I2=n120
XU176 ND2 $PINS O=n262 I1=n121 I2=n122
XU179 ND2 $PINS O=n263 I1=n123 I2=n124
XU182 ND2 $PINS O=n264 I1=n125 I2=n126
XU185 ND2 $PINS O=n265 I1=n127 I2=n128
XU188 ND2 $PINS O=n266 I1=n129 I2=n130
XU191 ND2 $PINS O=n267 I1=n131 I2=n132
XU395 OR3B2 $PINS O=n133 I1=P_sel[0] B1=P_sel[1]
+ B2=lookup_table_done_from_control
XU461 OR3B2 $PINS O=n136 I1=P_sel[1] B1=P_sel[0]
+ B2=lookup_table_done_from_control
XPx_store_2_reg[31] QDFFRBN $PINS Q=FE_PHN878_Px_store_2_31 D=n397
+ CK=i_clk_clone4 RB=FE_OFN328_n
XPx_store_2_reg[30] QDFFRBN $PINS Q=Px_store_2[30] D=n398 CK=i_clk_clone4
+ RB=FE_OFN328_n
XPx_store_2_reg[29] QDFFRBN $PINS Q=Px_store_2[29] D=n399 CK=i_clk_clone1
+ RB=FE_OFN284_FE_OFN10_FE_DBTN1_i_i_rst
XPx_store_2_reg[28] QDFFRBN $PINS Q=FE_PHN832_Px_store_2_28 D=n400
+ CK=i_clk_clone4 RB=FE_OFN329_n
XPx_store_2_reg[27] QDFFRBN $PINS Q=Px_store_2[27] D=n401 CK=i_clk_clone2
+ RB=FE_OFN283_FE_OFN10_FE_DBTN1_i_i_rst
XPx_store_2_reg[26] QDFFRBN $PINS Q=FE_PHN801_Px_store_2_26 D=n402
+ CK=i_clk_clone4 RB=FE_OFN327_n
XPx_store_2_reg[25] QDFFRBN $PINS Q=FE_PHN1532_Px_store_2_25 D=n403
+ CK=i_clk_clone1 RB=FE_OFN285_FE_OFN10_FE_DBTN1_i_i_rst
XPx_store_2_reg[24] QDFFRBN $PINS Q=Px_store_2[24] D=n404 CK=i_clk_clone4
+ RB=FE_OFN329_n
XPx_store_2_reg[23] QDFFRBN $PINS Q=FE_PHN777_Px_store_2_23 D=n405
+ CK=i_clk_clone1 RB=FE_OFN284_FE_OFN10_FE_DBTN1_i_i_rst
XPx_store_2_reg[22] QDFFRBN $PINS Q=Px_store_2[22] D=n406 CK=i_clk_clone4
+ RB=FE_OFN329_n
XPx_store_2_reg[21] QDFFRBN $PINS Q=Px_store_2[21] D=n407 CK=i_clk
+ RB=FE_OFN22_FE_DBTN1_i_i_rst
XPx_store_2_reg[20] QDFFRBN $PINS Q=Px_store_2[20] D=n408 CK=i_clk_clone1
+ RB=FE_OFN44_FE_DBTN1_i_i_rst
XPx_store_2_reg[19] QDFFRBN $PINS Q=FE_PHN1471_Px_store_2_19 D=n409 CK=i_clk
+ RB=FE_OFN286_FE_OFN9_FE_DBTN1_i_i_rst
XPx_store_2_reg[18] QDFFRBN $PINS Q=FE_PHN1461_Px_store_2_18 D=n410
+ CK=i_clk_clone3 RB=FE_OFN328_n
XPx_store_2_reg[17] QDFFRBN $PINS Q=FE_PHN895_Px_store_2_17 D=n411 CK=i_clk
+ RB=FE_OFN22_FE_DBTN1_i_i_rst
XPx_store_2_reg[16] QDFFRBN $PINS Q=FE_PHN796_Px_store_2_16 D=n412
+ CK=i_clk_clone3 RB=FE_OFN328_n
XPx_store_2_reg[15] QDFFRBN $PINS Q=Px_store_2[15] D=n413 CK=i_clk_clone1
+ RB=FE_OFN286_FE_OFN9_FE_DBTN1_i_i_rst
XPx_store_2_reg[14] QDFFRBN $PINS Q=Px_store_2[14] D=n414 CK=i_clk_clone3
+ RB=FE_OFN42_FE_DBTN1_i_i_rst
XPx_store_2_reg[13] QDFFRBN $PINS Q=Px_store_2[13] D=n415 CK=i_clk_clone10
+ RB=FE_OFN287_FE_OFN9_FE_DBTN1_i_i_rst
XPx_store_2_reg[12] QDFFRBN $PINS Q=Px_store_2[12] D=n416 CK=i_clk_clone1
+ RB=FE_OFN44_FE_DBTN1_i_i_rst
XPx_store_2_reg[11] QDFFRBN $PINS Q=FE_PHN1511_Px_store_2_11 D=n417
+ CK=i_clk_clone6 RB=FE_OFN331_n
XPx_store_2_reg[10] QDFFRBN $PINS Q=FE_PHN797_Px_store_2_10 D=n418
+ CK=i_clk_clone1 RB=FE_OFN330_n
XPx_store_2_reg[9] QDFFRBN $PINS Q=Px_store_2[9] D=n419 CK=i_clk_clone6
+ RB=FE_OFN331_n
XPx_store_2_reg[8] QDFFRBN $PINS Q=FE_PHN1476_Px_store_2_8 D=n420
+ CK=i_clk_clone1 RB=FE_OFN284_FE_OFN10_FE_DBTN1_i_i_rst
XPx_store_2_reg[7] QDFFRBN $PINS Q=FE_PHN1462_Px_store_2_7 D=n421 CK=i_clk
+ RB=FE_OFN287_FE_OFN9_FE_DBTN1_i_i_rst
XPx_store_2_reg[6] QDFFRBN $PINS Q=Px_store_2[6] D=n422 CK=i_clk_clone6
+ RB=FE_OFN331_n
XPx_store_2_reg[5] QDFFRBN $PINS Q=FE_PHN780_Px_store_2_5 D=n423
+ CK=i_clk_clone10 RB=FE_OFN289_FE_OFN8_FE_DBTN1_i_i_rst
XPx_store_2_reg[4] QDFFRBN $PINS Q=Px_store_2[4] D=n424 CK=i_clk_clone6
+ RB=FE_OFN288_FE_OFN8_FE_DBTN1_i_i_rst
XPx_store_2_reg[3] QDFFRBN $PINS Q=FE_PHN880_Px_store_2_3 D=n425
+ CK=i_clk_clone10 RB=FE_OFN289_FE_OFN8_FE_DBTN1_i_i_rst
XPx_store_2_reg[2] QDFFRBN $PINS Q=FE_PHN1468_Px_store_2_2 D=n426
+ CK=i_clk_clone10 RB=i_rst
XPx_store_2_reg[1] QDFFRBN $PINS Q=FE_PHN1472_Px_store_2_1 D=n427
+ CK=i_clk_clone10 RB=FE_OFN289_FE_OFN8_FE_DBTN1_i_i_rst
XPx_store_2_reg[0] QDFFRBN $PINS Q=Px_store_2[0] D=n428 CK=i_clk_clone10
+ RB=i_rst
XPy_store_2_reg[31] QDFFRBN $PINS Q=Py_store_2[31] D=n301 CK=i_clk_clone8
+ RB=FE_OFN275_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_2_reg[30] QDFFRBN $PINS Q=Py_store_2[30] D=n302 CK=i_clk_clone5
+ RB=FE_OFN32_FE_DBTN1_i_i_rst
XPy_store_2_reg[29] QDFFRBN $PINS Q=FE_PHN1455_Py_store_2_29 D=n303
+ CK=i_clk_clone7 RB=FE_OFN29_FE_DBTN1_i_i_rst
XPy_store_2_reg[28] QDFFRBN $PINS Q=FE_PHN1466_Py_store_2_28 D=n304
+ CK=i_clk_clone6 RB=FE_OFN32_FE_DBTN1_i_i_rst
XPy_store_2_reg[27] QDFFRBN $PINS Q=FE_PHN1456_Py_store_2_27 D=n305
+ CK=i_clk_clone8 RB=FE_OFN276_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_2_reg[26] QDFFRBN $PINS Q=Py_store_2[26] D=n306 CK=i_clk_clone5
+ RB=FE_OFN32_FE_DBTN1_i_i_rst
XPy_store_2_reg[25] QDFFRBN $PINS Q=FE_PHN1465_Py_store_2_25 D=n307
+ CK=i_clk_clone8 RB=FE_OFN276_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_2_reg[24] QDFFRBN $PINS Q=Py_store_2[24] D=n308 CK=i_clk_clone5
+ RB=FE_OFN32_FE_DBTN1_i_i_rst
XPy_store_2_reg[23] QDFFRBN $PINS Q=Py_store_2[23] D=n309 CK=i_clk_clone8
+ RB=FE_OFN450_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_2_reg[22] QDFFRBN $PINS Q=FE_PHN868_Py_store_2_22 D=n310
+ CK=i_clk_clone6 RB=FE_OFN280_FE_OFN11_FE_DBTN1_i_i_rst
XPy_store_2_reg[21] QDFFRBN $PINS Q=Py_store_2[21] D=n311 CK=i_clk_clone9
+ RB=FE_OFN27_FE_DBTN1_i_i_rst
XPy_store_2_reg[20] QDFFRBN $PINS Q=FE_PHN773_Py_store_2_20 D=n312
+ CK=i_clk_clone8 RB=FE_OFN29_FE_DBTN1_i_i_rst
XPy_store_2_reg[19] QDFFRBN $PINS Q=Py_store_2[19] D=n313 CK=i_clk_clone7
+ RB=FE_OFN450_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_2_reg[18] QDFFRBN $PINS Q=FE_PHN902_Py_store_2_18 D=n314
+ CK=i_clk_clone8 RB=FE_OFN275_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_2_reg[17] QDFFRBN $PINS Q=FE_PHN771_Py_store_2_17 D=n315
+ CK=i_clk_clone7 RB=FE_OFN277_FE_OFN13_FE_DBTN1_i_i_rst
XPy_store_2_reg[16] QDFFRBN $PINS Q=Py_store_2[16] D=n316 CK=i_clk_clone8
+ RB=FE_OFN275_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_2_reg[15] QDFFRBN $PINS Q=FE_PHN1469_Py_store_2_15 D=n317
+ CK=i_clk_clone9 RB=FE_OFN27_FE_DBTN1_i_i_rst
XPy_store_2_reg[14] QDFFRBN $PINS Q=Py_store_2[14] D=n318 CK=i_clk_clone8
+ RB=FE_OFN275_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_2_reg[13] QDFFRBN $PINS Q=FE_PHN783_Py_store_2_13 D=n319
+ CK=i_clk_clone7 RB=FE_OFN450_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_2_reg[12] QDFFRBN $PINS Q=FE_PHN793_Py_store_2_12 D=n320
+ CK=i_clk_clone8 RB=FE_OFN275_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_2_reg[11] QDFFRBN $PINS Q=FE_PHN787_Py_store_2_11 D=n321
+ CK=i_clk_clone7 RB=FE_OFN450_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_2_reg[10] QDFFRBN $PINS Q=FE_PHN1494_Py_store_2_10 D=n322
+ CK=i_clk_clone5 RB=FE_OFN280_FE_OFN11_FE_DBTN1_i_i_rst
XPy_store_2_reg[9] QDFFRBN $PINS Q=FE_PHN838_Py_store_2_9 D=n323
+ CK=i_clk_clone7 RB=FE_OFN450_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_2_reg[8] QDFFRBN $PINS Q=Py_store_2[8] D=n324 CK=i_clk_clone5
+ RB=FE_OFN281_FE_OFN11_FE_DBTN1_i_i_rst
XPy_store_2_reg[7] QDFFRBN $PINS Q=Py_store_2[7] D=n325 CK=i_clk_clone7
+ RB=FE_OFN277_FE_OFN13_FE_DBTN1_i_i_rst
XPy_store_2_reg[6] QDFFRBN $PINS Q=FE_PHN1460_Py_store_2_6 D=n326
+ CK=i_clk_clone5 RB=FE_OFN29_FE_DBTN1_i_i_rst
XPy_store_2_reg[5] QDFFRBN $PINS Q=Py_store_2[5] D=n327 CK=i_clk_clone9
+ RB=FE_OFN278_FE_OFN13_FE_DBTN1_i_i_rst
XPy_store_2_reg[4] QDFFRBN $PINS Q=Py_store_2[4] D=n328 CK=i_clk_clone7
+ RB=FE_OFN277_FE_OFN13_FE_DBTN1_i_i_rst
XPy_store_2_reg[3] QDFFRBN $PINS Q=FE_PHN1480_Py_store_2_3 D=n329
+ CK=i_clk_clone10 RB=FE_OFN27_FE_DBTN1_i_i_rst
XPy_store_2_reg[2] QDFFRBN $PINS Q=FE_PHN1457_Py_store_2_2 D=n330
+ CK=i_clk_clone7 RB=FE_OFN27_FE_DBTN1_i_i_rst
XPy_store_2_reg[1] QDFFRBN $PINS Q=FE_PHN807_Py_store_2_1 D=n331
+ CK=i_clk_clone10 RB=FE_OFN288_FE_OFN8_FE_DBTN1_i_i_rst
XPy_store_2_reg[0] QDFFRBN $PINS Q=Py_store_2[0] D=n332 CK=i_clk_clone6
+ RB=FE_OFN282_FE_OFN11_FE_DBTN1_i_i_rst
XPx_store_1_reg[31] QDFFRBN $PINS Q=FE_PHN1548_Px_store_1_31 D=n460
+ CK=i_clk_clone3 RB=FE_OFN328_n
XPx_store_1_reg[30] QDFFRBN $PINS Q=FE_PHN681_Px_store_1_30 D=n459
+ CK=i_clk_clone2 RB=FE_OFN328_n
XPx_store_1_reg[29] QDFFRBN $PINS Q=FE_PHN694_Px_store_1_29 D=n458
+ CK=i_clk_clone1 RB=FE_OFN284_FE_OFN10_FE_DBTN1_i_i_rst
XPx_store_1_reg[28] QDFFRBN $PINS Q=FE_PHN924_Px_store_1_28 D=n457
+ CK=i_clk_clone4 RB=FE_OFN327_n
XPx_store_1_reg[27] QDFFRBN $PINS Q=FE_PHN1526_Px_store_1_27 D=n456
+ CK=i_clk_clone2 RB=FE_OFN283_FE_OFN10_FE_DBTN1_i_i_rst
XPx_store_1_reg[26] QDFFRBN $PINS Q=Px_store_1[26] D=n455 CK=i_clk_clone2
+ RB=FE_OFN327_n
XPx_store_1_reg[25] QDFFRBN $PINS Q=FE_PHN720_Px_store_1_25 D=n454
+ CK=i_clk_clone1 RB=FE_OFN285_FE_OFN10_FE_DBTN1_i_i_rst
XPx_store_1_reg[24] QDFFRBN $PINS Q=FE_PHN700_Px_store_1_24 D=n453
+ CK=i_clk_clone2 RB=FE_OFN327_n
XPx_store_1_reg[23] QDFFRBN $PINS Q=FE_PHN1496_Px_store_1_23 D=n452
+ CK=i_clk_clone1 RB=FE_OFN284_FE_OFN10_FE_DBTN1_i_i_rst
XPx_store_1_reg[22] QDFFRBN $PINS Q=FE_PHN835_Px_store_1_22 D=n451
+ CK=i_clk_clone4 RB=FE_OFN46_FE_DBTN1_i_i_rst
XPx_store_1_reg[21] QDFFRBN $PINS Q=FE_PHN883_Px_store_1_21 D=n450 CK=i_clk
+ RB=FE_OFN22_FE_DBTN1_i_i_rst
XPx_store_1_reg[20] QDFFRBN $PINS Q=Px_store_1[20] D=n449 CK=i_clk_clone1
+ RB=FE_OFN24_FE_DBTN1_i_i_rst
XPx_store_1_reg[19] QDFFRBN $PINS Q=FE_PHN726_Px_store_1_19 D=n448 CK=i_clk
+ RB=FE_OFN22_FE_DBTN1_i_i_rst
XPx_store_1_reg[18] QDFFRBN $PINS Q=Px_store_1[18] D=n447 CK=i_clk_clone2
+ RB=FE_OFN46_FE_DBTN1_i_i_rst
XPx_store_1_reg[17] QDFFRBN $PINS Q=FE_PHN676_Px_store_1_17 D=n446 CK=i_clk
+ RB=FE_OFN22_FE_DBTN1_i_i_rst
XPx_store_1_reg[16] QDFFRBN $PINS Q=FE_PHN666_Px_store_1_16 D=n445
+ CK=i_clk_clone3 RB=FE_OFN46_FE_DBTN1_i_i_rst
XPx_store_1_reg[15] QDFFRBN $PINS Q=FE_PHN740_Px_store_1_15 D=n444
+ CK=i_clk_clone1 RB=FE_OFN286_FE_OFN9_FE_DBTN1_i_i_rst
XPx_store_1_reg[14] QDFFRBN $PINS Q=Px_store_1[14] D=n443 CK=i_clk_clone1
+ RB=FE_OFN42_FE_DBTN1_i_i_rst
XPx_store_1_reg[13] QDFFRBN $PINS Q=Px_store_1[13] D=n442 CK=i_clk_clone1
+ RB=FE_OFN287_FE_OFN9_FE_DBTN1_i_i_rst
XPx_store_1_reg[12] QDFFRBN $PINS Q=FE_PHN826_Px_store_1_12 D=n441
+ CK=i_clk_clone1 RB=FE_OFN44_FE_DBTN1_i_i_rst
XPx_store_1_reg[11] QDFFRBN $PINS Q=Px_store_1[11] D=n440 CK=i_clk_clone6
+ RB=FE_OFN331_n
XPx_store_1_reg[10] QDFFRBN $PINS Q=FE_PHN717_Px_store_1_10 D=n439
+ CK=i_clk_clone1 RB=FE_OFN330_n
XPx_store_1_reg[9] QDFFRBN $PINS Q=Px_store_1[9] D=n438 CK=i_clk_clone6
+ RB=FE_OFN330_n
XPx_store_1_reg[8] QDFFRBN $PINS Q=FE_PHN677_Px_store_1_8 D=n437
+ CK=i_clk_clone1 RB=FE_OFN284_FE_OFN10_FE_DBTN1_i_i_rst
XPx_store_1_reg[7] QDFFRBN $PINS Q=FE_PHN1529_Px_store_1_7 D=n436 CK=i_clk
+ RB=FE_OFN287_FE_OFN9_FE_DBTN1_i_i_rst
XPx_store_1_reg[6] QDFFRBN $PINS Q=FE_PHN682_Px_store_1_6 D=n435
+ CK=i_clk_clone1 RB=FE_OFN330_n
XPx_store_1_reg[5] QDFFRBN $PINS Q=Px_store_1[5] D=n434 CK=i_clk_clone10
+ RB=FE_OFN289_FE_OFN8_FE_DBTN1_i_i_rst
XPx_store_1_reg[4] QDFFRBN $PINS Q=Px_store_1[4] D=n433 CK=i_clk_clone10
+ RB=FE_OFN287_FE_OFN9_FE_DBTN1_i_i_rst
XPx_store_1_reg[3] QDFFRBN $PINS Q=FE_PHN913_Px_store_1_3 D=n432
+ CK=i_clk_clone10 RB=FE_OFN290_FE_OFN8_FE_DBTN1_i_i_rst
XPx_store_1_reg[2] QDFFRBN $PINS Q=Px_store_1[2] D=n431 CK=i_clk_clone10
+ RB=FE_OFN287_FE_OFN9_FE_DBTN1_i_i_rst
XPx_store_1_reg[1] QDFFRBN $PINS Q=FE_PHN1541_Px_store_1_1 D=n430
+ CK=i_clk_clone10 RB=FE_OFN290_FE_OFN8_FE_DBTN1_i_i_rst
XPx_store_1_reg[0] QDFFRBN $PINS Q=FE_PHN679_Px_store_1_0 D=n429
+ CK=i_clk_clone6 RB=i_rst
XPx_store_3_reg[31] QDFFRBN $PINS Q=FE_PHN1559_Px_store_3_31 D=n365
+ CK=i_clk_clone4 RB=FE_OFN328_n
XPx_store_3_reg[30] QDFFRBN $PINS Q=FE_PHN1506_Px_store_3_30 D=n366
+ CK=i_clk_clone4 RB=FE_OFN328_n
XPx_store_3_reg[29] QDFFRBN $PINS Q=FE_PHN1599_Px_store_3_29 D=n367
+ CK=i_clk_clone1 RB=FE_OFN284_FE_OFN10_FE_DBTN1_i_i_rst
XPx_store_3_reg[28] QDFFRBN $PINS Q=Px_store_3[28] D=n368 CK=i_clk_clone4
+ RB=FE_OFN327_n
XPx_store_3_reg[27] QDFFRBN $PINS Q=FE_PHN698_Px_store_3_27 D=n369
+ CK=i_clk_clone2 RB=FE_OFN24_FE_DBTN1_i_i_rst
XPx_store_3_reg[26] QDFFRBN $PINS Q=FE_PHN695_Px_store_3_26 D=n370
+ CK=i_clk_clone4 RB=FE_OFN327_n
XPx_store_3_reg[25] QDFFRBN $PINS Q=Px_store_3[25] D=n371 CK=i_clk_clone2
+ RB=FE_OFN285_FE_OFN10_FE_DBTN1_i_i_rst
XPx_store_3_reg[24] QDFFRBN $PINS Q=FE_PHN723_Px_store_3_24 D=n372
+ CK=i_clk_clone4 RB=FE_OFN329_n
XPx_store_3_reg[23] QDFFRBN $PINS Q=Px_store_3[23] D=n373 CK=i_clk_clone1
+ RB=FE_OFN285_FE_OFN10_FE_DBTN1_i_i_rst
XPx_store_3_reg[22] QDFFRBN $PINS Q=FE_PHN683_Px_store_3_22 D=n374
+ CK=i_clk_clone4 RB=FE_OFN328_n
XPx_store_3_reg[21] QDFFRBN $PINS Q=FE_PHN699_Px_store_3_21 D=n375 CK=i_clk
+ RB=FE_OFN286_FE_OFN9_FE_DBTN1_i_i_rst
XPx_store_3_reg[20] QDFFRBN $PINS Q=FE_PHN706_Px_store_3_20 D=n376
+ CK=i_clk_clone1 RB=FE_OFN44_FE_DBTN1_i_i_rst
XPx_store_3_reg[19] QDFFRBN $PINS Q=FE_PHN1499_Px_store_3_19 D=n377 CK=i_clk
+ RB=FE_OFN286_FE_OFN9_FE_DBTN1_i_i_rst
XPx_store_3_reg[18] QDFFRBN $PINS Q=FE_PHN1551_Px_store_3_18 D=n378
+ CK=i_clk_clone4 RB=FE_OFN328_n
XPx_store_3_reg[17] QDFFRBN $PINS Q=FE_PHN1525_Px_store_3_17 D=n379 CK=i_clk
+ RB=FE_OFN22_FE_DBTN1_i_i_rst
XPx_store_3_reg[16] QDFFRBN $PINS Q=FE_PHN1527_Px_store_3_16 D=n380
+ CK=i_clk_clone3 RB=FE_OFN328_n
XPx_store_3_reg[15] QDFFRBN $PINS Q=FE_PHN1530_Px_store_3_15 D=n381 CK=i_clk
+ RB=FE_OFN286_FE_OFN9_FE_DBTN1_i_i_rst
XPx_store_3_reg[14] QDFFRBN $PINS Q=Px_store_3[14] D=n382 CK=i_clk_clone1
+ RB=FE_OFN42_FE_DBTN1_i_i_rst
XPx_store_3_reg[13] QDFFRBN $PINS Q=Px_store_3[13] D=n383 CK=i_clk_clone10
+ RB=FE_OFN287_FE_OFN9_FE_DBTN1_i_i_rst
XPx_store_3_reg[12] QDFFRBN $PINS Q=FE_PHN707_Px_store_3_12 D=n384
+ CK=i_clk_clone1 RB=FE_OFN44_FE_DBTN1_i_i_rst
XPx_store_3_reg[11] QDFFRBN $PINS Q=FE_PHN718_Px_store_3_11 D=n385
+ CK=i_clk_clone6 RB=FE_OFN331_n
XPx_store_3_reg[10] QDFFRBN $PINS Q=FE_PHN727_Px_store_3_10 D=n386
+ CK=i_clk_clone1 RB=FE_OFN330_n
XPx_store_3_reg[9] QDFFRBN $PINS Q=FE_PHN891_Px_store_3_9 D=n387
+ CK=i_clk_clone6 RB=FE_OFN331_n
XPx_store_3_reg[8] QDFFRBN $PINS Q=Px_store_3[8] D=n388 CK=i_clk_clone1
+ RB=FE_OFN284_FE_OFN10_FE_DBTN1_i_i_rst
XPx_store_3_reg[7] QDFFRBN $PINS Q=Px_store_3[7] D=n389 CK=i_clk
+ RB=FE_OFN287_FE_OFN9_FE_DBTN1_i_i_rst
XPx_store_3_reg[6] QDFFRBN $PINS Q=Px_store_3[6] D=n390 CK=i_clk_clone1
+ RB=FE_OFN331_n
XPx_store_3_reg[5] QDFFRBN $PINS Q=FE_PHN890_Px_store_3_5 D=n391
+ CK=i_clk_clone10 RB=FE_OFN289_FE_OFN8_FE_DBTN1_i_i_rst
XPx_store_3_reg[4] QDFFRBN $PINS Q=FE_PHN1540_Px_store_3_4 D=n392
+ CK=i_clk_clone6 RB=FE_OFN288_FE_OFN8_FE_DBTN1_i_i_rst
XPx_store_3_reg[3] QDFFRBN $PINS Q=FE_PHN1545_Px_store_3_3 D=n393
+ CK=i_clk_clone10 RB=FE_OFN289_FE_OFN8_FE_DBTN1_i_i_rst
XPx_store_3_reg[2] QDFFRBN $PINS Q=Px_store_3[2] D=n394 CK=i_clk_clone10
+ RB=i_rst
XPx_store_3_reg[1] QDFFRBN $PINS Q=FE_PHN926_Px_store_3_1 D=n395
+ CK=i_clk_clone10 RB=FE_OFN290_FE_OFN8_FE_DBTN1_i_i_rst
XPx_store_3_reg[0] QDFFRBN $PINS Q=FE_PHN919_Px_store_3_0 D=n396
+ CK=i_clk_clone10 RB=i_rst
XPy_store_1_reg[31] QDFFRBN $PINS Q=FE_PHN1502_Py_store_1_31 D=n364
+ CK=i_clk_clone8 RB=FE_OFN275_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_1_reg[30] QDFFRBN $PINS Q=FE_PHN1510_Py_store_1_30 D=n363
+ CK=i_clk_clone5 RB=FE_OFN281_FE_OFN11_FE_DBTN1_i_i_rst
XPy_store_1_reg[29] QDFFRBN $PINS Q=Py_store_1[29] D=n362 CK=i_clk_clone5
+ RB=FE_OFN29_FE_DBTN1_i_i_rst
XPy_store_1_reg[28] QDFFRBN $PINS Q=FE_PHN1521_Py_store_1_28 D=n361
+ CK=i_clk_clone6 RB=FE_OFN32_FE_DBTN1_i_i_rst
XPy_store_1_reg[27] QDFFRBN $PINS Q=FE_PHN1508_Py_store_1_27 D=n360
+ CK=i_clk_clone7 RB=FE_OFN450_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_1_reg[26] QDFFRBN $PINS Q=FE_PHN708_Py_store_1_26 D=n359
+ CK=i_clk_clone5 RB=FE_OFN32_FE_DBTN1_i_i_rst
XPy_store_1_reg[25] QDFFRBN $PINS Q=Py_store_1[25] D=n358 CK=i_clk_clone7
+ RB=FE_OFN276_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_1_reg[24] QDFFRBN $PINS Q=Py_store_1[24] D=n357 CK=i_clk_clone5
+ RB=FE_OFN281_FE_OFN11_FE_DBTN1_i_i_rst
XPy_store_1_reg[23] QDFFRBN $PINS Q=FE_PHN1552_Py_store_1_23 D=n356
+ CK=i_clk_clone8 RB=FE_OFN450_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_1_reg[22] QDFFRBN $PINS Q=FE_PHN825_Py_store_1_22 D=n355
+ CK=i_clk_clone5 RB=FE_OFN280_FE_OFN11_FE_DBTN1_i_i_rst
XPy_store_1_reg[21] QDFFRBN $PINS Q=Py_store_1[21] D=n354 CK=i_clk_clone7
+ RB=FE_OFN277_FE_OFN13_FE_DBTN1_i_i_rst
XPy_store_1_reg[20] QDFFRBN $PINS Q=Py_store_1[20] D=n353 CK=i_clk_clone8
+ RB=FE_OFN29_FE_DBTN1_i_i_rst
XPy_store_1_reg[19] QDFFRBN $PINS Q=Py_store_1[19] D=n352 CK=i_clk_clone7
+ RB=FE_OFN450_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_1_reg[18] QDFFRBN $PINS Q=FE_PHN1542_Py_store_1_18 D=n351
+ CK=i_clk_clone8 RB=FE_OFN276_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_1_reg[17] QDFFRBN $PINS Q=FE_PHN799_Py_store_1_17 D=n350
+ CK=i_clk_clone7 RB=FE_OFN277_FE_OFN13_FE_DBTN1_i_i_rst
XPy_store_1_reg[16] QDFFRBN $PINS Q=FE_PHN884_Py_store_1_16 D=n349
+ CK=i_clk_clone8 RB=FE_OFN275_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_1_reg[15] QDFFRBN $PINS Q=Py_store_1[15] D=n348 CK=i_clk_clone9
+ RB=FE_OFN27_FE_DBTN1_i_i_rst
XPy_store_1_reg[14] QDFFRBN $PINS Q=FE_PHN722_Py_store_1_14 D=n347
+ CK=i_clk_clone8 RB=FE_OFN275_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_1_reg[13] QDFFRBN $PINS Q=Py_store_1[13] D=n346 CK=i_clk_clone7
+ RB=FE_OFN276_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_1_reg[12] QDFFRBN $PINS Q=Py_store_1[12] D=n345 CK=i_clk_clone8
+ RB=FE_OFN450_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_1_reg[11] QDFFRBN $PINS Q=Py_store_1[11] D=n344 CK=i_clk_clone8
+ RB=FE_OFN450_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_1_reg[10] QDFFRBN $PINS Q=Py_store_1[10] D=n343 CK=i_clk_clone5
+ RB=FE_OFN280_FE_OFN11_FE_DBTN1_i_i_rst
XPy_store_1_reg[9] QDFFRBN $PINS Q=FE_PHN848_Py_store_1_9 D=n342
+ CK=i_clk_clone7 RB=FE_OFN450_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_1_reg[8] QDFFRBN $PINS Q=FE_PHN1524_Py_store_1_8 D=n341
+ CK=i_clk_clone5 RB=FE_OFN281_FE_OFN11_FE_DBTN1_i_i_rst
XPy_store_1_reg[7] QDFFRBN $PINS Q=FE_PHN889_Py_store_1_7 D=n340
+ CK=i_clk_clone7 RB=FE_OFN277_FE_OFN13_FE_DBTN1_i_i_rst
XPy_store_1_reg[6] QDFFRBN $PINS Q=Py_store_1[6] D=n339 CK=i_clk_clone5
+ RB=FE_OFN282_FE_OFN11_FE_DBTN1_i_i_rst
XPy_store_1_reg[5] QDFFRBN $PINS Q=FE_PHN1477_Py_store_1_5 D=n338
+ CK=i_clk_clone9 RB=FE_OFN278_FE_OFN13_FE_DBTN1_i_i_rst
XPy_store_1_reg[4] QDFFRBN $PINS Q=FE_PHN674_Py_store_1_4 D=n337
+ CK=i_clk_clone7 RB=FE_OFN277_FE_OFN13_FE_DBTN1_i_i_rst
XPy_store_1_reg[3] QDFFRBN $PINS Q=FE_PHN1522_Py_store_1_3 D=n336
+ CK=i_clk_clone10 RB=FE_OFN27_FE_DBTN1_i_i_rst
XPy_store_1_reg[2] QDFFRBN $PINS Q=FE_PHN1474_Py_store_1_2 D=n335
+ CK=i_clk_clone9 RB=FE_OFN27_FE_DBTN1_i_i_rst
XPy_store_1_reg[1] QDFFRBN $PINS Q=Py_store_1[1] D=n334 CK=i_clk_clone10
+ RB=FE_OFN289_FE_OFN8_FE_DBTN1_i_i_rst
XPy_store_1_reg[0] QDFFRBN $PINS Q=Py_store_1[0] D=n333 CK=i_clk_clone6
+ RB=FE_OFN288_FE_OFN8_FE_DBTN1_i_i_rst
XPy_store_3_reg[31] QDFFRBN $PINS Q=Py_store_3[31] D=n269 CK=i_clk_clone8
+ RB=FE_OFN29_FE_DBTN1_i_i_rst
XPy_store_3_reg[30] QDFFRBN $PINS Q=Py_store_3[30] D=n270 CK=i_clk_clone5
+ RB=FE_OFN32_FE_DBTN1_i_i_rst
XPy_store_3_reg[29] QDFFRBN $PINS Q=FE_PHN874_Py_store_3_29 D=n271
+ CK=i_clk_clone7 RB=FE_OFN29_FE_DBTN1_i_i_rst
XPy_store_3_reg[28] QDFFRBN $PINS Q=Py_store_3[28] D=n272 CK=i_clk_clone6
+ RB=FE_OFN32_FE_DBTN1_i_i_rst
XPy_store_3_reg[27] QDFFRBN $PINS Q=FE_PHN828_Py_store_3_27 D=n273
+ CK=i_clk_clone8 RB=FE_OFN450_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_3_reg[26] QDFFRBN $PINS Q=FE_PHN1514_Py_store_3_26 D=n274
+ CK=i_clk_clone5 RB=FE_OFN32_FE_DBTN1_i_i_rst
XPy_store_3_reg[25] QDFFRBN $PINS Q=Py_store_3[25] D=n275 CK=i_clk_clone7
+ RB=FE_OFN276_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_3_reg[24] QDFFRBN $PINS Q=FE_PHN1528_Py_store_3_24 D=n276
+ CK=i_clk_clone5 RB=FE_OFN32_FE_DBTN1_i_i_rst
XPy_store_3_reg[23] QDFFRBN $PINS Q=Py_store_3[23] D=n277 CK=i_clk_clone8
+ RB=FE_OFN450_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_3_reg[22] QDFFRBN $PINS Q=FE_PHN922_Py_store_3_22 D=n278
+ CK=i_clk_clone6 RB=FE_OFN280_FE_OFN11_FE_DBTN1_i_i_rst
XPy_store_3_reg[21] QDFFRBN $PINS Q=Py_store_3[21] D=n279 CK=i_clk_clone7
+ RB=FE_OFN27_FE_DBTN1_i_i_rst
XPy_store_3_reg[20] QDFFRBN $PINS Q=Py_store_3[20] D=n280 CK=i_clk_clone5
+ RB=FE_OFN32_FE_DBTN1_i_i_rst
XPy_store_3_reg[19] QDFFRBN $PINS Q=FE_PHN1561_Py_store_3_19 D=n281
+ CK=i_clk_clone7 RB=FE_OFN450_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_3_reg[18] QDFFRBN $PINS Q=FE_PHN1582_Py_store_3_18 D=n282
+ CK=i_clk_clone8 RB=FE_OFN275_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_3_reg[17] QDFFRBN $PINS Q=FE_PHN853_Py_store_3_17 D=n283
+ CK=i_clk_clone7 RB=FE_OFN277_FE_OFN13_FE_DBTN1_i_i_rst
XPy_store_3_reg[16] QDFFRBN $PINS Q=FE_PHN1593_Py_store_3_16 D=n284
+ CK=i_clk_clone8 RB=FE_OFN275_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_3_reg[15] QDFFRBN $PINS Q=FE_PHN863_Py_store_3_15 D=n285
+ CK=i_clk_clone9 RB=FE_OFN27_FE_DBTN1_i_i_rst
XPy_store_3_reg[14] QDFFRBN $PINS Q=FE_PHN1579_Py_store_3_14 D=n286
+ CK=i_clk_clone8 RB=FE_OFN275_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_3_reg[13] QDFFRBN $PINS Q=Py_store_3[13] D=n287 CK=i_clk_clone7
+ RB=FE_OFN450_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_3_reg[12] QDFFRBN $PINS Q=Py_store_3[12] D=n288 CK=i_clk_clone8
+ RB=FE_OFN276_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_3_reg[11] QDFFRBN $PINS Q=Py_store_3[11] D=n289 CK=i_clk_clone7
+ RB=FE_OFN450_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_3_reg[10] QDFFRBN $PINS Q=Py_store_3[10] D=n290 CK=i_clk_clone5
+ RB=FE_OFN26_FE_DBTN1_i_i_rst
XPy_store_3_reg[9] QDFFRBN $PINS Q=FE_PHN692_Py_store_3_9 D=n291
+ CK=i_clk_clone7 RB=FE_OFN450_FE_OFN14_FE_DBTN1_i_i_rst
XPy_store_3_reg[8] QDFFRBN $PINS Q=Py_store_3[8] D=n292 CK=i_clk_clone7
+ RB=FE_OFN281_FE_OFN11_FE_DBTN1_i_i_rst
XPy_store_3_reg[7] QDFFRBN $PINS Q=FE_PHN714_Py_store_3_7 D=n293
+ CK=i_clk_clone7 RB=FE_OFN277_FE_OFN13_FE_DBTN1_i_i_rst
XPy_store_3_reg[6] QDFFRBN $PINS Q=Py_store_3[6] D=n294 CK=i_clk_clone7
+ RB=FE_OFN281_FE_OFN11_FE_DBTN1_i_i_rst
XPy_store_3_reg[5] QDFFRBN $PINS Q=FE_PHN855_Py_store_3_5 D=n295
+ CK=i_clk_clone7 RB=FE_OFN27_FE_DBTN1_i_i_rst
XPy_store_3_reg[4] QDFFRBN $PINS Q=FE_PHN702_Py_store_3_4 D=n296
+ CK=i_clk_clone7 RB=FE_OFN277_FE_OFN13_FE_DBTN1_i_i_rst
XPy_store_3_reg[3] QDFFRBN $PINS Q=FE_PHN906_Py_store_3_3 D=n297
+ CK=i_clk_clone10 RB=FE_OFN289_FE_OFN8_FE_DBTN1_i_i_rst
XPy_store_3_reg[2] QDFFRBN $PINS Q=FE_PHN775_Py_store_3_2 D=n298
+ CK=i_clk_clone9 RB=FE_OFN278_FE_OFN13_FE_DBTN1_i_i_rst
XPy_store_3_reg[1] QDFFRBN $PINS Q=Py_store_3[1] D=n299 CK=i_clk_clone10
+ RB=FE_OFN289_FE_OFN8_FE_DBTN1_i_i_rst
XPy_store_3_reg[0] QDFFRBN $PINS Q=Py_store_3[0] D=n300 CK=i_clk_clone6
+ RB=FE_OFN282_FE_OFN11_FE_DBTN1_i_i_rst
XPx_out_reg[31] QDFFRBN $PINS Q=FE_PHN663_Px_out_from_look_31 D=n267
+ CK=i_clk_clone4 RB=FE_OFN328_n
XPx_out_reg[30] QDFFRBN $PINS Q=FE_PHN670_Px_out_from_look_30 D=FE_PHN1610_n266
+ CK=i_clk_clone4 RB=FE_OFN328_n
XPx_out_reg[29] QDFFRBN $PINS Q=FE_PHN711_Px_out_from_look_29 D=n265
+ CK=i_clk_clone1 RB=FE_OFN284_FE_OFN10_FE_DBTN1_i_i_rst
XPx_out_reg[28] QDFFRBN $PINS Q=FE_PHN703_Px_out_from_look_28 D=n264
+ CK=i_clk_clone4 RB=FE_OFN327_n
XPx_out_reg[27] QDFFRBN $PINS Q=FE_PHN798_Px_out_from_look_27 D=FE_PHN1617_n263
+ CK=i_clk_clone2 RB=FE_OFN283_FE_OFN10_FE_DBTN1_i_i_rst
XPx_out_reg[26] QDFFRBN $PINS Q=FE_PHN822_Px_out_from_look_26 D=n262
+ CK=i_clk_clone4 RB=FE_OFN24_FE_DBTN1_i_i_rst
XPx_out_reg[25] QDFFRBN $PINS Q=FE_PHN782_Px_out_from_look_25 D=n261 CK=i_clk
+ RB=FE_OFN285_FE_OFN10_FE_DBTN1_i_i_rst
XPx_out_reg[24] QDFFRBN $PINS Q=FE_PHN857_Px_out_from_look_24 D=FE_PHN1621_n260
+ CK=i_clk_clone4 RB=FE_OFN327_n
XPx_out_reg[23] QDFFRBN $PINS Q=FE_PHN675_Px_out_from_look_23 D=n259
+ CK=i_clk_clone1 RB=FE_OFN284_FE_OFN10_FE_DBTN1_i_i_rst
XPx_out_reg[22] QDFFRBN $PINS Q=FE_PSRN_5 D=n258 CK=i_clk_clone4 RB=FE_OFN327_n
XPx_out_reg[21] QDFFRBN $PINS Q=FE_PSRN_73 D=FE_PHN1631_n257 CK=i_clk
+ RB=FE_OFN22_FE_DBTN1_i_i_rst
XPx_out_reg[20] QDFFRBN $PINS Q=FE_PHN687_Px_out_from_look_20 D=FE_PHN1622_n256
+ CK=i_clk_clone1 RB=FE_OFN46_FE_DBTN1_i_i_rst
XPx_out_reg[19] QDFFRBN $PINS Q=FE_PHN818_Px_out_from_look_19 D=n255 CK=i_clk
+ RB=FE_OFN286_FE_OFN9_FE_DBTN1_i_i_rst
XPx_out_reg[18] QDFFRBN $PINS Q=FE_PHN833_Px_out_from_look_18 D=FE_PHN1607_n254
+ CK=i_clk_clone3 RB=FE_OFN46_FE_DBTN1_i_i_rst
XPx_out_reg[17] QDFFRBN $PINS Q=FE_PSRN_41 D=FE_PHN1619_n253 CK=i_clk
+ RB=FE_OFN22_FE_DBTN1_i_i_rst
XPx_out_reg[16] QDFFRBN $PINS Q=FE_PHN705_Px_out_from_look_16 D=FE_PHN1620_n252
+ CK=i_clk_clone3 RB=FE_OFN46_FE_DBTN1_i_i_rst
XPx_out_reg[15] QDFFRBN $PINS Q=FE_PHN850_Px_out_from_look_15 D=n251 CK=i_clk
+ RB=FE_OFN286_FE_OFN9_FE_DBTN1_i_i_rst
XPx_out_reg[14] QDFFRBN $PINS Q=FE_PHN845_Px_out_from_look_14 D=n250
+ CK=i_clk_clone3 RB=FE_OFN46_FE_DBTN1_i_i_rst
XPx_out_reg[13] QDFFRBN $PINS Q=FE_PSRN_84 D=n249 CK=i_clk
+ RB=FE_OFN22_FE_DBTN1_i_i_rst
XPx_out_reg[12] QDFFRBN $PINS Q=FE_PHN669_Px_out_from_look_12 D=n248
+ CK=i_clk_clone3 RB=FE_OFN46_FE_DBTN1_i_i_rst
XPx_out_reg[11] QDFFRBN $PINS Q=FE_PHN697_Px_out_from_look_11 D=FE_PHN1627_n247
+ CK=i_clk_clone1 RB=FE_OFN330_n
XPx_out_reg[10] QDFFRBN $PINS Q=FE_PSRN_10 D=n246 CK=i_clk_clone1
+ RB=FE_OFN283_FE_OFN10_FE_DBTN1_i_i_rst
XPx_out_reg[9] QDFFRBN $PINS Q=FE_PSRN_3 D=n245 CK=i_clk_clone1 RB=FE_OFN331_n
XPx_out_reg[8] QDFFRBN $PINS Q=FE_PHN810_Px_out_from_look_8 D=n244
+ CK=i_clk_clone1 RB=FE_OFN283_FE_OFN10_FE_DBTN1_i_i_rst
XPx_out_reg[7] QDFFRBN $PINS Q=FE_PHN804_Px_out_from_look_7 D=FE_PHN1608_n243
+ CK=i_clk RB=FE_OFN287_FE_OFN9_FE_DBTN1_i_i_rst
XPx_out_reg[6] QDFFRBN $PINS Q=FE_PHN806_Px_out_from_look_6 D=n242
+ CK=i_clk_clone1 RB=FE_OFN330_n
XPx_out_reg[5] QDFFRBN $PINS Q=FE_PSRN_65 D=n241 CK=i_clk_clone10
+ RB=FE_OFN289_FE_OFN8_FE_DBTN1_i_i_rst
XPx_out_reg[4] QDFFRBN $PINS Q=FE_PHN909_Px_out_from_look_4 D=n240
+ CK=i_clk_clone6 RB=FE_OFN331_n
XPx_out_reg[3] QDFFRBN $PINS Q=FE_PSRN_77 D=n239 CK=i_clk_clone10
+ RB=FE_OFN290_FE_OFN8_FE_DBTN1_i_i_rst
XPx_out_reg[2] QDFFRBN $PINS Q=FE_PSRN_70 D=FE_PHN1611_n238 CK=i_clk_clone10
+ RB=i_rst
XPx_out_reg[1] QDFFRBN $PINS Q=FE_PHN715_Px_out_from_look_1 D=FE_PHN1612_n237
+ CK=i_clk_clone10 RB=FE_OFN290_FE_OFN8_FE_DBTN1_i_i_rst
XPx_out_reg[0] QDFFRBN $PINS Q=FE_PSRN_180 D=FE_PHN1615_n236 CK=i_clk_clone10
+ RB=i_rst
XPy_out_reg[31] QDFFRBN $PINS Q=FE_PHN731_Py_out_from_look_31 D=n235
+ CK=i_clk_clone8 RB=FE_OFN29_FE_DBTN1_i_i_rst
XPy_out_reg[30] QDFFRBN $PINS Q=FE_PHN823_Py_out_from_look_30 D=n234
+ CK=i_clk_clone5 RB=FE_OFN281_FE_OFN11_FE_DBTN1_i_i_rst
XPy_out_reg[29] QDFFRBN $PINS Q=FE_PHN958_Py_out_from_look_29 D=n233
+ CK=i_clk_clone7 RB=FE_OFN281_FE_OFN11_FE_DBTN1_i_i_rst
XPy_out_reg[28] QDFFRBN $PINS Q=FE_PHN1555_Py_out_from_look_28 D=n232
+ CK=i_clk_clone6 RB=FE_OFN26_FE_DBTN1_i_i_rst
XPy_out_reg[27] QDFFRBN $PINS Q=FE_PHN736_Py_out_from_look_27 D=n231
+ CK=i_clk_clone7 RB=FE_OFN276_FE_OFN14_FE_DBTN1_i_i_rst
XPy_out_reg[26] QDFFRBN $PINS Q=FE_PSRN_82 D=FE_PHN1613_n230 CK=i_clk_clone5
+ RB=FE_OFN26_FE_DBTN1_i_i_rst
XPy_out_reg[25] QDFFRBN $PINS Q=FE_PSRN_75 D=FE_PHN1609_n229 CK=i_clk_clone7
+ RB=FE_OFN29_FE_DBTN1_i_i_rst
XPy_out_reg[24] QDFFRBN $PINS Q=FE_PHN1584_Py_out_from_look_24
+ D=FE_PHN1618_n228 CK=i_clk_clone5 RB=FE_OFN281_FE_OFN11_FE_DBTN1_i_i_rst
XPy_out_reg[23] QDFFRBN $PINS Q=FE_PHN741_Py_out_from_look_23 D=n227
+ CK=i_clk_clone8 RB=FE_OFN450_FE_OFN14_FE_DBTN1_i_i_rst
XPy_out_reg[22] QDFFRBN $PINS Q=FE_PHN672_Py_out_from_look_22 D=n226
+ CK=i_clk_clone5 RB=FE_OFN280_FE_OFN11_FE_DBTN1_i_i_rst
XPy_out_reg[21] QDFFRBN $PINS Q=FE_PHN733_Py_out_from_look_21 D=n225
+ CK=i_clk_clone7 RB=FE_OFN277_FE_OFN13_FE_DBTN1_i_i_rst
XPy_out_reg[20] QDFFRBN $PINS Q=FE_PSRN_94 D=FE_PHN1624_n224 CK=i_clk_clone8
+ RB=FE_OFN281_FE_OFN11_FE_DBTN1_i_i_rst
XPy_out_reg[19] QDFFRBN $PINS Q=FE_PSRN_8 D=n223 CK=i_clk_clone7
+ RB=FE_OFN277_FE_OFN13_FE_DBTN1_i_i_rst
XPy_out_reg[18] QDFFRBN $PINS Q=FE_PSRN_37 D=FE_PHN1623_n222 CK=i_clk_clone8
+ RB=FE_OFN276_FE_OFN14_FE_DBTN1_i_i_rst
XPy_out_reg[17] QDFFRBN $PINS Q=FE_PSRN_58 D=n221 CK=i_clk_clone7
+ RB=FE_OFN277_FE_OFN13_FE_DBTN1_i_i_rst
XPy_out_reg[16] QDFFRBN $PINS Q=FE_PSRN_113 D=n220 CK=i_clk_clone8
+ RB=FE_OFN275_FE_OFN14_FE_DBTN1_i_i_rst
XPy_out_reg[15] QDFFRBN $PINS Q=FE_PHN763_Py_out_from_look_15 D=n219
+ CK=i_clk_clone9 RB=FE_OFN27_FE_DBTN1_i_i_rst
XPy_out_reg[14] QDFFRBN $PINS Q=FE_PHN696_Py_out_from_look_14 D=n218
+ CK=i_clk_clone8 RB=FE_OFN275_FE_OFN14_FE_DBTN1_i_i_rst
XPy_out_reg[13] QDFFRBN $PINS Q=FE_PHN1600_Py_out_from_look_13 D=n217
+ CK=i_clk_clone7 RB=FE_OFN450_FE_OFN14_FE_DBTN1_i_i_rst
XPy_out_reg[12] QDFFRBN $PINS Q=FE_PSRN_24 D=FE_PHN1626_n216 CK=i_clk_clone8
+ RB=FE_OFN276_FE_OFN14_FE_DBTN1_i_i_rst
XPy_out_reg[11] QDFFRBN $PINS Q=FE_PHN725_Py_out_from_look_11 D=n215
+ CK=i_clk_clone8 RB=FE_OFN450_FE_OFN14_FE_DBTN1_i_i_rst
XPy_out_reg[10] QDFFRBN $PINS Q=FE_PHN1523_Py_out_from_look_10 D=n214
+ CK=i_clk_clone5 RB=FE_OFN26_FE_DBTN1_i_i_rst
XPy_out_reg[9] QDFFRBN $PINS Q=FE_PSRN_53 D=n213 CK=i_clk_clone7
+ RB=FE_OFN276_FE_OFN14_FE_DBTN1_i_i_rst
XPy_out_reg[8] QDFFRBN $PINS Q=FE_PHN1562_Py_out_from_look_8 D=n212
+ CK=i_clk_clone7 RB=FE_OFN281_FE_OFN11_FE_DBTN1_i_i_rst
XPy_out_reg[7] QDFFRBN $PINS Q=FE_PSRN_49 D=n211 CK=i_clk_clone7
+ RB=FE_OFN277_FE_OFN13_FE_DBTN1_i_i_rst
XPy_out_reg[6] QDFFRBN $PINS Q=FE_PHN791_Py_out_from_look_6 D=n210
+ CK=i_clk_clone5 RB=FE_OFN282_FE_OFN11_FE_DBTN1_i_i_rst
XPy_out_reg[5] QDFFRBN $PINS Q=FE_PHN710_Py_out_from_look_5 D=n209
+ CK=i_clk_clone7 RB=FE_OFN27_FE_DBTN1_i_i_rst
XPy_out_reg[4] QDFFRBN $PINS Q=FE_PHN743_Py_out_from_look_4 D=FE_PHN1606_n208
+ CK=i_clk_clone7 RB=FE_OFN277_FE_OFN13_FE_DBTN1_i_i_rst
XPy_out_reg[3] QDFFRBN $PINS Q=FE_PSRN_28 D=n207 CK=i_clk_clone10
+ RB=FE_OFN289_FE_OFN8_FE_DBTN1_i_i_rst
XPy_out_reg[2] QDFFRBN $PINS Q=FE_PHN730_Py_out_from_look_2 D=n206
+ CK=i_clk_clone10 RB=FE_OFN27_FE_DBTN1_i_i_rst
XPy_out_reg[1] QDFFRBN $PINS Q=FE_PHN732_Py_out_from_look_1 D=n205
+ CK=i_clk_clone10 RB=FE_OFN289_FE_OFN8_FE_DBTN1_i_i_rst
XPy_out_reg[0] QDFFRBN $PINS Q=FE_PSRN_85 D=n204 CK=i_clk_clone6
+ RB=FE_OFN288_FE_OFN8_FE_DBTN1_i_i_rst
XU10 AO13 $PINS O=n6 A1=p1 B1=n133 B2=n136 B3=n135
XU22 NR2 $PINS O=n5 I1=n136 I2=p1
XU24 NR2 $PINS O=n4 I1=n133 I2=p1
XU25 NR2 $PINS O=n3 I1=p1 I2=n135
XU49 ND3 $PINS O=n135 I1=P_sel[1] I2=P_sel[0] I3=lookup_table_done_from_control
XU52 OR2 $PINS O=n137 I1=n135 I2=mode
XU55 OR2 $PINS O=n170 I1=n133 I2=mode
XU58 OR2 $PINS O=n171 I1=n136 I2=mode
XU81 AOI22S $PINS O=n2 A1=FE_PHN920_Py_store_3_0 A2=FE_OFN375_FE_OFN66_n3
+ B1=FE_PHN774_Py_store_2_0 B2=FE_OFN371_FE_OFN67_n4
XU82 AOI22S $PINS O=n1 A1=FE_PHN1570_Py_store_1_0 A2=FE_OFN367_FE_OFN68_n5
+ B1=Py_out[0] B2=FE_OFN545_n6
XU84 AOI22S $PINS O=n8 A1=FE_PHN930_Py_store_3_1 A2=FE_OFN376_FE_OFN66_n3
+ B1=FE_PHN1538_Py_store_2_1 B2=FE_OFN371_FE_OFN67_n4
XU85 AOI22S $PINS O=n7 A1=FE_PHN1515_Py_store_1_1 A2=FE_OFN368_FE_OFN68_n5
+ B1=Py_out[1] B2=FE_OFN546_n6
XU87 AOI22S $PINS O=n10 A1=Py_store_3[2] A2=FE_OFN376_FE_OFN66_n3
+ B1=Py_store_2[2] B2=FE_OFN371_FE_OFN67_n4
XU88 AOI22S $PINS O=n9 A1=Py_store_1[2] A2=FE_OFN368_FE_OFN68_n5 B1=Py_out[2]
+ B2=FE_OFN546_n6
XU90 AOI22S $PINS O=n12 A1=Py_store_3[3] A2=FE_OFN376_FE_OFN66_n3
+ B1=Py_store_2[3] B2=FE_OFN371_FE_OFN67_n4
XU91 AOI22S $PINS O=n11 A1=Py_store_1[3] A2=FE_OFN368_FE_OFN68_n5 B1=Py_out[3]
+ B2=FE_OFN546_n6
XU93 AOI22S $PINS O=n14 A1=Py_store_3[4] A2=FE_OFN376_FE_OFN66_n3
+ B1=FE_PHN935_Py_store_2_4 B2=FE_OFN371_FE_OFN67_n4
XU94 AOI22S $PINS O=n13 A1=Py_store_1[4] A2=FE_OFN368_FE_OFN68_n5 B1=Py_out[4]
+ B2=FE_OFN546_n6
XU96 AOI22S $PINS O=n16 A1=Py_store_3[5] A2=FE_OFN376_FE_OFN66_n3
+ B1=FE_PHN925_Py_store_2_5 B2=FE_OFN371_FE_OFN67_n4
XU97 AOI22S $PINS O=n15 A1=Py_store_1[5] A2=FE_OFN368_FE_OFN68_n5 B1=Py_out[5]
+ B2=FE_OFN546_n6
XU99 AOI22S $PINS O=n18 A1=FE_PHN955_Py_store_3_6 A2=FE_OFN375_FE_OFN66_n3
+ B1=FE_PHN952_Py_store_2_6 B2=FE_OFN372_FE_OFN67_n4
XU100 AOI22S $PINS O=n17 A1=FE_PHN830_Py_store_1_6 A2=FE_OFN369_FE_OFN68_n5
+ B1=Py_out[6] B2=FE_OFN547_n6
XU102 AOI22S $PINS O=n20 A1=Py_store_3[7] A2=FE_OFN376_FE_OFN66_n3
+ B1=FE_PHN802_Py_store_2_7 B2=FE_OFN371_FE_OFN67_n4
XU103 AOI22S $PINS O=n19 A1=Py_store_1[7] A2=FE_OFN368_FE_OFN68_n5 B1=Py_out[7]
+ B2=FE_OFN546_n6
XU105 AOI22S $PINS O=n22 A1=FE_PHN819_Py_store_3_8 A2=FE_OFN375_FE_OFN66_n3
+ B1=FE_PHN956_Py_store_2_8 B2=FE_OFN372_FE_OFN67_n4
XU106 AOI22S $PINS O=n21 A1=Py_store_1[8] A2=FE_OFN369_FE_OFN68_n5 B1=Py_out[8]
+ B2=FE_OFN547_n6
XU108 AOI22S $PINS O=n24 A1=Py_store_3[9] A2=FE_OFN376_FE_OFN66_n3
+ B1=Py_store_2[9] B2=FE_OFN372_FE_OFN67_n4
XU109 AOI22S $PINS O=n23 A1=Py_store_1[9] A2=FE_OFN369_FE_OFN68_n5 B1=Py_out[9]
+ B2=FE_OFN547_n6
XU111 AOI22S $PINS O=n26 A1=FE_PHN939_Py_store_3_10 A2=FE_OFN375_FE_OFN66_n3
+ B1=Py_store_2[10] B2=FE_OFN372_FE_OFN67_n4
XU112 AOI22S $PINS O=n25 A1=FE_PHN685_Py_store_1_10 A2=FE_OFN369_FE_OFN68_n5
+ B1=Py_out[10] B2=FE_OFN547_n6
XU114 AOI22S $PINS O=n28 A1=FE_PHN728_Py_store_3_11 A2=FE_OFN376_FE_OFN66_n3
+ B1=Py_store_2[11] B2=FE_OFN372_FE_OFN67_n4
XU115 AOI22S $PINS O=n27 A1=FE_PHN1589_Py_store_1_11 A2=FE_OFN369_FE_OFN68_n5
+ B1=Py_out[11] B2=FE_OFN547_n6
XU117 AOI22S $PINS O=n30 A1=FE_PHN934_Py_store_3_12 A2=FE_OFN375_FE_OFN66_n3
+ B1=Py_store_2[12] B2=FE_OFN372_FE_OFN67_n4
XU118 AOI22S $PINS O=n29 A1=FE_PHN837_Py_store_1_12 A2=FE_OFN369_FE_OFN68_n5
+ B1=Py_out[12] B2=FE_OFN547_n6
XU120 AOI22S $PINS O=n32 A1=FE_PHN904_Py_store_3_13 A2=FE_OFN376_FE_OFN66_n3
+ B1=Py_store_2[13] B2=FE_OFN372_FE_OFN67_n4
XU121 AOI22S $PINS O=n31 A1=FE_PHN1581_Py_store_1_13 A2=FE_OFN369_FE_OFN68_n5
+ B1=Py_out[13] B2=FE_OFN547_n6
XU123 AOI22S $PINS O=n34 A1=Py_store_3[14] A2=FE_OFN375_FE_OFN66_n3
+ B1=FE_PHN947_Py_store_2_14 B2=FE_OFN372_FE_OFN67_n4
XU124 AOI22S $PINS O=n33 A1=Py_store_1[14] A2=FE_OFN367_FE_OFN68_n5
+ B1=Py_out[14] B2=FE_OFN545_n6
XU126 AOI22S $PINS O=n36 A1=Py_store_3[15] A2=FE_OFN376_FE_OFN66_n3
+ B1=FE_PHN879_Py_store_2_15 B2=FE_OFN371_FE_OFN67_n4
XU127 AOI22S $PINS O=n35 A1=FE_PHN899_Py_store_1_15 A2=FE_OFN368_FE_OFN68_n5
+ B1=Py_out[15] B2=FE_OFN546_n6
XU129 AOI22S $PINS O=n38 A1=Py_store_3[16] A2=FE_OFN375_FE_OFN66_n3
+ B1=FE_PHN953_Py_store_2_16 B2=FE_OFN372_FE_OFN67_n4
XU130 AOI22S $PINS O=n37 A1=Py_store_1[16] A2=FE_OFN369_FE_OFN68_n5
+ B1=Py_out[16] B2=FE_OFN547_n6
XU132 AOI22S $PINS O=n40 A1=Py_store_3[17] A2=FE_OFN376_FE_OFN66_n3
+ B1=Py_store_2[17] B2=FE_OFN371_FE_OFN67_n4
XU133 AOI22S $PINS O=n39 A1=Py_store_1[17] A2=FE_OFN368_FE_OFN68_n5
+ B1=Py_out[17] B2=FE_OFN546_n6
XU135 AOI22S $PINS O=n42 A1=Py_store_3[18] A2=FE_OFN375_FE_OFN66_n3
+ B1=Py_store_2[18] B2=FE_OFN372_FE_OFN67_n4
XU136 AOI22S $PINS O=n41 A1=Py_store_1[18] A2=FE_OFN369_FE_OFN68_n5
+ B1=Py_out[18] B2=FE_OFN547_n6
XU138 AOI22S $PINS O=n44 A1=Py_store_3[19] A2=FE_OFN376_FE_OFN66_n3
+ B1=FE_PHN789_Py_store_2_19 B2=FE_OFN371_FE_OFN67_n4
XU139 AOI22S $PINS O=n43 A1=FE_PHN885_Py_store_1_19 A2=FE_OFN368_FE_OFN68_n5
+ B1=Py_out[19] B2=FE_OFN547_n6
XU141 AOI22S $PINS O=n46 A1=FE_PHN946_Py_store_3_20 A2=FE_OFN375_FE_OFN66_n3
+ B1=Py_store_2[20] B2=FE_OFN372_FE_OFN67_n4
XU142 AOI22S $PINS O=n45 A1=FE_PHN933_Py_store_1_20 A2=FE_OFN367_FE_OFN68_n5
+ B1=Py_out[20] B2=FE_OFN545_n6
XU144 AOI22S $PINS O=n48 A1=FE_PHN861_Py_store_3_21 A2=FE_OFN376_FE_OFN66_n3
+ B1=FE_PHN759_Py_store_2_21 B2=FE_OFN371_FE_OFN67_n4
XU145 AOI22S $PINS O=n47 A1=FE_PHN911_Py_store_1_21 A2=FE_OFN368_FE_OFN68_n5
+ B1=Py_out[21] B2=FE_OFN546_n6
XU147 AOI22S $PINS O=n50 A1=Py_store_3[22] A2=FE_OFN375_FE_OFN66_n3
+ B1=FE_PHN1544_Py_store_2_22 B2=FE_OFN371_FE_OFN67_n4
XU148 AOI22S $PINS O=n49 A1=FE_PHN1567_Py_store_1_22 A2=FE_OFN367_FE_OFN68_n5
+ B1=Py_out[22] B2=FE_OFN545_n6
XU150 AOI22S $PINS O=n52 A1=FE_PHN944_Py_store_3_23 A2=FE_OFN375_FE_OFN66_n3
+ B1=FE_PHN788_Py_store_2_23 B2=FE_OFN372_FE_OFN67_n4
XU151 AOI22S $PINS O=n51 A1=Py_store_1[23] A2=FE_OFN369_FE_OFN68_n5
+ B1=Py_out[23] B2=FE_OFN547_n6
XU153 AOI22S $PINS O=n54 A1=Py_store_3[24] A2=FE_OFN375_FE_OFN66_n3
+ B1=FE_PHN870_Py_store_2_24 B2=FE_OFN372_FE_OFN67_n4
XU154 AOI22S $PINS O=n53 A1=FE_PHN792_Py_store_1_24 A2=FE_OFN367_FE_OFN68_n5
+ B1=Py_out[24] B2=FE_OFN545_n6
XU156 AOI22S $PINS O=n56 A1=FE_PHN688_Py_store_3_25 A2=FE_OFN375_FE_OFN66_n3
+ B1=Py_store_2[25] B2=FE_OFN372_FE_OFN67_n4
XU157 AOI22S $PINS O=n55 A1=FE_PHN684_Py_store_1_25 A2=FE_OFN369_FE_OFN68_n5
+ B1=Py_out[25] B2=FE_OFN547_n6
XU159 AOI22S $PINS O=n58 A1=Py_store_3[26] A2=FE_OFN375_FE_OFN66_n3
+ B1=FE_PHN1488_Py_store_2_26 B2=FE_OFN372_FE_OFN67_n4
XU160 AOI22S $PINS O=n57 A1=Py_store_1[26] A2=FE_OFN367_FE_OFN68_n5
+ B1=Py_out[26] B2=FE_OFN545_n6
XU162 AOI22S $PINS O=n60 A1=Py_store_3[27] A2=FE_OFN375_FE_OFN66_n3
+ B1=Py_store_2[27] B2=FE_OFN372_FE_OFN67_n4
XU163 AOI22S $PINS O=n59 A1=Py_store_1[27] A2=FE_OFN369_FE_OFN68_n5
+ B1=Py_out[27] B2=FE_OFN547_n6
XU165 AOI22S $PINS O=n62 A1=FE_PHN943_Py_store_3_28 A2=FE_OFN375_FE_OFN66_n3
+ B1=Py_store_2[28] B2=FE_OFN372_FE_OFN67_n4
XU166 AOI22S $PINS O=n61 A1=Py_store_1[28] A2=FE_OFN367_FE_OFN68_n5
+ B1=Py_out[28] B2=FE_OFN545_n6
XU168 AOI22S $PINS O=n64 A1=Py_store_3[29] A2=FE_OFN375_FE_OFN66_n3
+ B1=Py_store_2[29] B2=FE_OFN372_FE_OFN67_n4
XU169 AOI22S $PINS O=n63 A1=FE_PHN960_Py_store_1_29 A2=FE_OFN369_FE_OFN68_n5
+ B1=Py_out[29] B2=FE_OFN547_n6
XU171 AOI22S $PINS O=n66 A1=FE_PHN950_Py_store_3_30 A2=FE_OFN375_FE_OFN66_n3
+ B1=FE_PHN762_Py_store_2_30 B2=FE_OFN372_FE_OFN67_n4
XU172 AOI22S $PINS O=n65 A1=Py_store_1[30] A2=FE_OFN367_FE_OFN68_n5
+ B1=Py_out[30] B2=FE_OFN545_n6
XU174 AOI22S $PINS O=n68 A1=FE_PHN834_Py_store_3_31 A2=FE_OFN375_FE_OFN66_n3
+ B1=FE_PHN761_Py_store_2_31 B2=FE_OFN372_FE_OFN67_n4
XU175 AOI22S $PINS O=n67 A1=FE_PHN907_Py_store_1_31 A2=FE_OFN367_FE_OFN68_n5
+ B1=Py_out[31] B2=FE_OFN545_n6
XU177 AOI22S $PINS O=n70 A1=Px_store_3[0] A2=n3 B1=FE_PHN846_Px_store_2_0
+ B2=FE_OFN371_FE_OFN67_n4
XU178 AOI22S $PINS O=n69 A1=Px_store_1[0] A2=FE_OFN368_FE_OFN68_n5 B1=Px_out[0]
+ B2=FE_OFN546_n6
XU180 AOI22S $PINS O=n72 A1=Px_store_3[1] A2=FE_OFN376_FE_OFN66_n3
+ B1=FE_PHN867_Px_store_2_1 B2=FE_OFN371_FE_OFN67_n4
XU181 AOI22S $PINS O=n71 A1=Px_store_1[1] A2=FE_OFN368_FE_OFN68_n5 B1=Px_out[1]
+ B2=FE_OFN546_n6
XU183 AOI22S $PINS O=n74 A1=FE_PHN854_Px_store_3_2 A2=FE_OFN376_FE_OFN66_n3
+ B1=FE_PHN864_Px_store_2_2 B2=FE_OFN371_FE_OFN67_n4
XU184 AOI22S $PINS O=n73 A1=FE_PHN865_Px_store_1_2 A2=FE_OFN368_FE_OFN68_n5
+ B1=Px_out[2] B2=FE_OFN546_n6
XU186 AOI22S $PINS O=n76 A1=Px_store_3[3] A2=FE_OFN376_FE_OFN66_n3
+ B1=FE_PHN1485_Px_store_2_3 B2=FE_OFN371_FE_OFN67_n4
XU187 AOI22S $PINS O=n75 A1=Px_store_1[3] A2=FE_OFN368_FE_OFN68_n5 B1=Px_out[3]
+ B2=FE_OFN546_n6
XU189 AOI22S $PINS O=n78 A1=Px_store_3[4] A2=FE_OFN375_FE_OFN66_n3
+ B1=FE_PHN778_Px_store_2_4 B2=FE_OFN371_FE_OFN67_n4
XU190 AOI22S $PINS O=n77 A1=FE_PHN831_Px_store_1_4 A2=FE_OFN367_FE_OFN68_n5
+ B1=FE_PHN1571_Px_out_from_look_4 B2=FE_OFN545_n6
XU192 AOI22S $PINS O=n80 A1=Px_store_3[5] A2=FE_OFN376_FE_OFN66_n3
+ B1=Px_store_2[5] B2=FE_OFN371_FE_OFN67_n4
XU193 AOI22S $PINS O=n79 A1=FE_PHN1597_Px_store_1_5 A2=FE_OFN368_FE_OFN68_n5
+ B1=Px_out[5] B2=FE_OFN546_n6
XU194 AOI22S $PINS O=n82 A1=FE_PHN712_Px_store_3_6 A2=n3
+ B1=FE_PHN1553_Px_store_2_6 B2=n4
XU195 AOI22S $PINS O=n81 A1=Px_store_1[6] A2=FE_OFN367_FE_OFN68_n5 B1=Px_out[6]
+ B2=FE_OFN545_n6
XU196 AOI22S $PINS O=n84 A1=FE_PHN957_Px_store_3_7 A2=n3
+ B1=FE_PHN916_Px_store_2_7 B2=n4
XU197 AOI22S $PINS O=n83 A1=FE_PHN887_Px_store_1_7 A2=FE_OFN367_FE_OFN68_n5
+ B1=Px_out[7] B2=FE_OFN545_n6
XU198 AOI22S $PINS O=n86 A1=FE_PHN678_Px_store_3_8 A2=FE_OFN373_FE_OFN66_n3
+ B1=FE_PHN897_Px_store_2_8 B2=FE_OFN370_FE_OFN67_n4
XU199 AOI22S $PINS O=n85 A1=Px_store_1[8] A2=FE_OFN68_n5 B1=Px_out[8] B2=n6
XU200 AOI22S $PINS O=FE_PHN1625_n88 A1=Px_store_3[9] A2=n3
+ B1=FE_PHN1518_Px_store_2_9 B2=n4
XU201 AOI22S $PINS O=n87 A1=FE_PHN680_Px_store_1_9 A2=FE_OFN367_FE_OFN68_n5
+ B1=Px_out[9] B2=FE_OFN545_n6
XU202 AOI22S $PINS O=n90 A1=Px_store_3[10] A2=FE_OFN373_FE_OFN66_n3
+ B1=Px_store_2[10] B2=FE_OFN370_FE_OFN67_n4
XU203 AOI22S $PINS O=FE_PHN1630_n89 A1=Px_store_1[10] A2=FE_OFN68_n5
+ B1=FE_PHN1588_Px_out_from_look_10 B2=n6
XU204 AOI22S $PINS O=n92 A1=Px_store_3[11] A2=n3 B1=Px_store_2[11] B2=n4
XU205 AOI22S $PINS O=n91 A1=FE_PHN691_Px_store_1_11 A2=FE_OFN367_FE_OFN68_n5
+ B1=Px_out[11] B2=FE_OFN545_n6
XU206 AOI22S $PINS O=n94 A1=Px_store_3[12] A2=FE_OFN373_FE_OFN66_n3
+ B1=FE_PHN1536_Px_store_2_12 B2=FE_OFN370_FE_OFN67_n4
XU207 AOI22S $PINS O=n93 A1=FE_PHN1550_Px_store_1_12 A2=FE_OFN68_n5
+ B1=Px_out[12] B2=n6
XU208 AOI22S $PINS O=n96 A1=FE_PHN987_Px_store_3_13 A2=n3
+ B1=FE_PHN724_Px_store_2_13 B2=n4
XU209 AOI22S $PINS O=n95 A1=FE_PHN918_Px_store_1_13 A2=FE_OFN367_FE_OFN68_n5
+ B1=FE_PHN1598_Px_out_from_look_13 B2=FE_OFN545_n6
XU210 AOI22S $PINS O=n98 A1=FE_PHN719_Px_store_3_14 A2=FE_OFN373_FE_OFN66_n3
+ B1=FE_PHN784_Px_store_2_14 B2=FE_OFN370_FE_OFN67_n4
XU211 AOI22S $PINS O=n97 A1=FE_PHN1595_Px_store_1_14 A2=FE_OFN68_n5
+ B1=Px_out[14] B2=n6
XU212 AOI22S $PINS O=n100 A1=Px_store_3[15] A2=n3 B1=FE_PHN859_Px_store_2_15
+ B2=n4
XU213 AOI22S $PINS O=n99 A1=Px_store_1[15] A2=FE_OFN68_n5 B1=Px_out[15] B2=n6
XU214 AOI22S $PINS O=n102 A1=Px_store_3[16] A2=FE_OFN373_FE_OFN66_n3
+ B1=FE_PHN1498_Px_store_2_16 B2=FE_OFN370_FE_OFN67_n4
XU215 AOI22S $PINS O=n101 A1=Px_store_1[16] A2=FE_OFN68_n5 B1=Px_out[16] B2=n6
XU216 AOI22S $PINS O=n104 A1=FE_PHN929_Px_store_3_17 A2=n3
+ B1=FE_PHN1497_Px_store_2_17 B2=n4
XU217 AOI22S $PINS O=n103 A1=Px_store_1[17] A2=FE_OFN367_FE_OFN68_n5
+ B1=Px_out[17] B2=FE_OFN545_n6
XU218 AOI22S $PINS O=n106 A1=Px_store_3[18] A2=FE_OFN373_FE_OFN66_n3
+ B1=FE_PHN954_Px_store_2_18 B2=FE_OFN370_FE_OFN67_n4
XU219 AOI22S $PINS O=n105 A1=FE_PHN790_Px_store_1_18 A2=FE_OFN68_n5
+ B1=Px_out[18] B2=n6
XU220 AOI22S $PINS O=n108 A1=FE_PHN948_Px_store_3_19 A2=n3 B1=Px_store_2[19]
+ B2=n4
XU221 AOI22S $PINS O=n107 A1=Px_store_1[19] A2=FE_OFN367_FE_OFN68_n5
+ B1=Px_out[19] B2=FE_OFN545_n6
XU222 AOI22S $PINS O=n110 A1=Px_store_3[20] A2=FE_OFN373_FE_OFN66_n3
+ B1=FE_PHN770_Px_store_2_20 B2=FE_OFN370_FE_OFN67_n4
XU223 AOI22S $PINS O=n109 A1=FE_PHN905_Px_store_1_20 A2=FE_OFN68_n5
+ B1=Px_out[20] B2=n6
XU224 AOI22S $PINS O=n112 A1=FE_PHN1594_Px_store_3_21 A2=n3
+ B1=FE_PHN776_Px_store_2_21 B2=n4
XU225 AOI22S $PINS O=n111 A1=Px_store_1[21] A2=FE_OFN367_FE_OFN68_n5
+ B1=Px_out[21] B2=FE_OFN545_n6
XU226 AOI22S $PINS O=n114 A1=FE_PHN1566_Px_store_3_22 A2=FE_OFN373_FE_OFN66_n3
+ B1=FE_PHN768_Px_store_2_22 B2=FE_OFN370_FE_OFN67_n4
XU227 AOI22S $PINS O=n113 A1=Px_store_1[22] A2=FE_OFN68_n5 B1=Px_out[22] B2=n6
XU228 AOI22S $PINS O=n116 A1=FE_PHN709_Px_store_3_23 A2=FE_OFN373_FE_OFN66_n3
+ B1=Px_store_2[23] B2=FE_OFN370_FE_OFN67_n4
XU229 AOI22S $PINS O=n115 A1=FE_PHN938_Px_store_1_23 A2=FE_OFN68_n5
+ B1=Px_out[23] B2=n6
XU230 AOI22S $PINS O=n118 A1=Px_store_3[24] A2=FE_OFN373_FE_OFN66_n3
+ B1=FE_PHN937_Px_store_2_24 B2=FE_OFN370_FE_OFN67_n4
XU231 AOI22S $PINS O=n117 A1=Px_store_1[24] A2=FE_OFN68_n5 B1=Px_out[24] B2=n6
XU232 AOI22S $PINS O=n120 A1=FE_PHN735_Px_store_3_25 A2=FE_OFN373_FE_OFN66_n3
+ B1=Px_store_2[25] B2=FE_OFN370_FE_OFN67_n4
XU233 AOI22S $PINS O=n119 A1=Px_store_1[25] A2=FE_OFN68_n5 B1=Px_out[25] B2=n6
XU234 AOI22S $PINS O=n122 A1=Px_store_3[26] A2=FE_OFN373_FE_OFN66_n3
+ B1=Px_store_2[26] B2=FE_OFN370_FE_OFN67_n4
XU235 AOI22S $PINS O=n121 A1=FE_PHN1573_Px_store_1_26 A2=FE_OFN68_n5
+ B1=FE_PHN1568_Px_out_from_look_26 B2=n6
XU236 AOI22S $PINS O=n124 A1=Px_store_3[27] A2=FE_OFN373_FE_OFN66_n3
+ B1=FE_PHN795_Px_store_2_27 B2=FE_OFN370_FE_OFN67_n4
XU237 AOI22S $PINS O=n123 A1=Px_store_1[27] A2=FE_OFN68_n5 B1=Px_out[27] B2=n6
XU238 AOI22S $PINS O=n126 A1=FE_PHN896_Px_store_3_28 A2=FE_OFN373_FE_OFN66_n3
+ B1=Px_store_2[28] B2=FE_OFN370_FE_OFN67_n4
XU239 AOI22S $PINS O=n125 A1=Px_store_1[28] A2=FE_OFN68_n5 B1=Px_out[28] B2=n6
XU240 AOI22S $PINS O=n128 A1=Px_store_3[29] A2=FE_OFN373_FE_OFN66_n3
+ B1=FE_PHN785_Px_store_2_29 B2=FE_OFN370_FE_OFN67_n4
XU241 AOI22S $PINS O=n127 A1=Px_store_1[29] A2=FE_OFN68_n5 B1=Px_out[29] B2=n6
XU242 AOI22S $PINS O=n130 A1=Px_store_3[30] A2=FE_OFN373_FE_OFN66_n3
+ B1=FE_PHN869_Px_store_2_30 B2=FE_OFN370_FE_OFN67_n4
XU243 AOI22S $PINS O=n129 A1=Px_store_1[30] A2=FE_OFN68_n5 B1=Px_out[30] B2=n6
XU244 AOI22S $PINS O=n132 A1=Px_store_3[31] A2=FE_OFN373_FE_OFN66_n3
+ B1=FE_PHN1482_Px_store_2_31 B2=FE_OFN370_FE_OFN67_n4
XU245 AOI22S $PINS O=n131 A1=FE_PHN893_Px_store_1_31 A2=FE_OFN68_n5
+ B1=Px_out[31] B2=n6
XU246 MOAI1S $PINS O=n332 A1=n183 A2=FE_OFN72_n170 B1=FE_PHN774_Py_store_2_0
+ B2=FE_OFN72_n170
XU247 MOAI1S $PINS O=n330 A1=n493 A2=FE_OFN574_n B1=Py_store_2[2]
+ B2=FE_OFN574_n
XU248 MOAI1S $PINS O=n326 A1=n499 A2=FE_OFN72_n170 B1=FE_PHN952_Py_store_2_6
+ B2=FE_OFN72_n170
XU249 MOAI1S $PINS O=n333 A1=n183 A2=FE_OFN75_n171 B1=FE_PHN876_Py_store_1_0
+ B2=FE_OFN75_n171
XU250 MOAI1S $PINS O=n335 A1=n493 A2=FE_OFN571_n B1=Py_store_1[2]
+ B2=FE_OFN571_n
XU251 MOAI1S $PINS O=n339 A1=n499 A2=FE_OFN75_n171 B1=FE_PHN830_Py_store_1_6
+ B2=FE_OFN75_n171
XU252 MOAI1S $PINS O=n318 A1=n476 A2=FE_OFN572_n B1=FE_PHN947_Py_store_2_14
+ B2=FE_OFN572_n
XU253 MOAI1S $PINS O=n302 A1=n494 A2=FE_OFN572_n B1=FE_PHN762_Py_store_2_30
+ B2=FE_OFN572_n
XU254 MOAI1S $PINS O=n347 A1=n476 A2=FE_OFN569_n B1=Py_store_1[14]
+ B2=FE_OFN569_n
XU255 MOAI1S $PINS O=n363 A1=n494 A2=FE_OFN569_n B1=Py_store_1[30]
+ B2=FE_OFN569_n
XU256 MOAI1S $PINS O=n328 A1=n497 A2=FE_OFN574_n B1=FE_PHN935_Py_store_2_4
+ B2=FE_OFN574_n
XU257 MOAI1S $PINS O=n320 A1=n474 A2=FE_OFN573_n B1=Py_store_2[12]
+ B2=FE_OFN573_n
XU258 MOAI1S $PINS O=n316 A1=n478 A2=FE_OFN572_n B1=FE_PHN953_Py_store_2_16
+ B2=FE_OFN572_n
XU259 MOAI1S $PINS O=n304 A1=n491 A2=FE_OFN572_n B1=Py_store_2[28]
+ B2=FE_OFN572_n
XU260 MOAI1S $PINS O=n337 A1=n497 A2=FE_OFN571_n B1=Py_store_1[4]
+ B2=FE_OFN571_n
XU261 MOAI1S $PINS O=n345 A1=n474 A2=FE_OFN570_n B1=FE_PHN837_Py_store_1_12
+ B2=FE_OFN570_n
XU262 MOAI1S $PINS O=n349 A1=n478 A2=FE_OFN570_n B1=Py_store_1[16]
+ B2=FE_OFN570_n
XU263 MOAI1S $PINS O=n361 A1=n491 A2=FE_OFN569_n B1=Py_store_1[28]
+ B2=FE_OFN569_n
XU264 MOAI1S $PINS O=n324 A1=n501 A2=FE_OFN72_n170 B1=FE_PHN956_Py_store_2_8
+ B2=FE_OFN72_n170
XU265 MOAI1S $PINS O=n322 A1=n472 A2=FE_OFN572_n B1=Py_store_2[10]
+ B2=FE_OFN572_n
XU266 MOAI1S $PINS O=n314 A1=n480 A2=FE_OFN573_n B1=Py_store_2[18]
+ B2=FE_OFN573_n
XU267 MOAI1S $PINS O=n312 A1=n483 A2=FE_OFN572_n B1=Py_store_2[20]
+ B2=FE_OFN572_n
XU268 MOAI1S $PINS O=n310 A1=n485 A2=FE_OFN72_n170 B1=Py_store_2[22]
+ B2=FE_OFN72_n170
XU269 MOAI1S $PINS O=n308 A1=n487 A2=FE_OFN572_n B1=FE_PHN870_Py_store_2_24
+ B2=FE_OFN572_n
XU270 MOAI1S $PINS O=n306 A1=n489 A2=FE_OFN572_n B1=FE_PHN921_Py_store_2_26
+ B2=FE_OFN572_n
XU271 MOAI1S $PINS O=n341 A1=n501 A2=FE_OFN75_n171 B1=Py_store_1[8]
+ B2=FE_OFN75_n171
XU272 MOAI1S $PINS O=n343 A1=n472 A2=FE_OFN75_n171 B1=FE_PHN685_Py_store_1_10
+ B2=FE_OFN75_n171
XU273 MOAI1S $PINS O=n351 A1=n480 A2=FE_OFN570_n B1=Py_store_1[18]
+ B2=FE_OFN570_n
XU274 MOAI1S $PINS O=n353 A1=n483 A2=FE_OFN569_n B1=FE_PHN933_Py_store_1_20
+ B2=FE_OFN569_n
XU275 MOAI1S $PINS O=n355 A1=n485 A2=FE_OFN75_n171 B1=Py_store_1[22]
+ B2=FE_OFN75_n171
XU276 MOAI1S $PINS O=n357 A1=n487 A2=FE_OFN569_n B1=FE_PHN792_Py_store_1_24
+ B2=FE_OFN569_n
XU277 MOAI1S $PINS O=n359 A1=n489 A2=FE_OFN569_n B1=Py_store_1[26]
+ B2=FE_OFN569_n
XU278 MOAI1S $PINS O=n331 A1=n482 A2=FE_OFN574_n B1=Py_store_2[1]
+ B2=FE_OFN574_n
XU279 MOAI1S $PINS O=n329 A1=n496 A2=FE_OFN574_n B1=Py_store_2[3]
+ B2=FE_OFN574_n
XU280 MOAI1S $PINS O=n327 A1=n498 A2=FE_OFN574_n B1=FE_PHN925_Py_store_2_5
+ B2=FE_OFN574_n
XU281 MOAI1S $PINS O=n325 A1=n500 A2=FE_OFN574_n B1=FE_PHN802_Py_store_2_7
+ B2=FE_OFN574_n
XU282 MOAI1S $PINS O=n323 A1=n502 A2=FE_OFN573_n B1=Py_store_2[9]
+ B2=FE_OFN573_n
XU283 MOAI1S $PINS O=n321 A1=n473 A2=FE_OFN573_n B1=Py_store_2[11]
+ B2=FE_OFN573_n
XU284 MOAI1S $PINS O=n319 A1=n475 A2=FE_OFN573_n B1=Py_store_2[13]
+ B2=FE_OFN573_n
XU285 MOAI1S $PINS O=n317 A1=n477 A2=FE_OFN574_n B1=FE_PHN879_Py_store_2_15
+ B2=FE_OFN574_n
XU286 MOAI1S $PINS O=n315 A1=n479 A2=FE_OFN574_n B1=Py_store_2[17]
+ B2=FE_OFN574_n
XU287 MOAI1S $PINS O=n313 A1=n481 A2=FE_OFN573_n B1=FE_PHN789_Py_store_2_19
+ B2=FE_OFN573_n
XU288 MOAI1S $PINS O=n311 A1=n484 A2=FE_OFN574_n B1=FE_PHN759_Py_store_2_21
+ B2=FE_OFN574_n
XU289 MOAI1S $PINS O=n309 A1=n486 A2=FE_OFN573_n B1=FE_PHN788_Py_store_2_23
+ B2=FE_OFN573_n
XU290 MOAI1S $PINS O=n307 A1=n488 A2=FE_OFN573_n B1=Py_store_2[25]
+ B2=FE_OFN573_n
XU291 MOAI1S $PINS O=n305 A1=n490 A2=FE_OFN573_n B1=Py_store_2[27]
+ B2=FE_OFN573_n
XU292 MOAI1S $PINS O=n303 A1=n492 A2=FE_OFN72_n170 B1=Py_store_2[29]
+ B2=FE_OFN72_n170
XU293 MOAI1S $PINS O=n334 A1=n482 A2=FE_OFN571_n B1=FE_PHN951_Py_store_1_1
+ B2=FE_OFN571_n
XU294 MOAI1S $PINS O=n336 A1=n496 A2=FE_OFN571_n B1=Py_store_1[3]
+ B2=FE_OFN571_n
XU295 MOAI1S $PINS O=n338 A1=n498 A2=FE_OFN571_n B1=Py_store_1[5]
+ B2=FE_OFN571_n
XU296 MOAI1S $PINS O=n340 A1=n500 A2=FE_OFN571_n B1=Py_store_1[7]
+ B2=FE_OFN571_n
XU297 MOAI1S $PINS O=n342 A1=n502 A2=FE_OFN570_n B1=Py_store_1[9]
+ B2=FE_OFN570_n
XU298 MOAI1S $PINS O=n344 A1=n473 A2=FE_OFN570_n B1=FE_PHN673_Py_store_1_11
+ B2=FE_OFN570_n
XU299 MOAI1S $PINS O=n346 A1=n475 A2=FE_OFN570_n B1=FE_PHN886_Py_store_1_13
+ B2=FE_OFN570_n
XU300 MOAI1S $PINS O=n348 A1=n477 A2=FE_OFN571_n B1=FE_PHN899_Py_store_1_15
+ B2=FE_OFN571_n
XU301 MOAI1S $PINS O=n350 A1=n479 A2=FE_OFN571_n B1=Py_store_1[17]
+ B2=FE_OFN571_n
XU302 MOAI1S $PINS O=n352 A1=n481 A2=FE_OFN570_n B1=FE_PHN885_Py_store_1_19
+ B2=FE_OFN570_n
XU303 MOAI1S $PINS O=n354 A1=n484 A2=FE_OFN571_n B1=FE_PHN911_Py_store_1_21
+ B2=FE_OFN571_n
XU304 MOAI1S $PINS O=n356 A1=n486 A2=FE_OFN570_n B1=Py_store_1[23]
+ B2=FE_OFN570_n
XU305 MOAI1S $PINS O=n358 A1=n488 A2=FE_OFN570_n B1=FE_PHN684_Py_store_1_25
+ B2=FE_OFN570_n
XU306 MOAI1S $PINS O=n360 A1=n490 A2=FE_OFN570_n B1=Py_store_1[27]
+ B2=FE_OFN570_n
XU307 MOAI1S $PINS O=n362 A1=n492 A2=FE_OFN75_n171 B1=FE_PHN960_Py_store_1_29
+ B2=FE_OFN75_n171
XU308 MOAI1S $PINS O=n301 A1=n495 A2=FE_OFN572_n B1=FE_PHN761_Py_store_2_31
+ B2=FE_OFN572_n
XU309 MOAI1S $PINS O=n364 A1=n495 A2=FE_OFN569_n B1=FE_PHN907_Py_store_1_31
+ B2=FE_OFN569_n
XU310 MOAI1S $PINS O=n396 A1=FE_OFN69_n137 A2=n184 B1=Px_store_3[0]
+ B2=FE_OFN69_n137
XU311 MOAI1S $PINS O=n428 A1=FE_OFN71_n170 A2=n184 B1=FE_PHN846_Px_store_2_0
+ B2=FE_OFN71_n170
XU312 MOAI1S $PINS O=n429 A1=FE_OFN74_n171 A2=n184 B1=Px_store_1[0]
+ B2=FE_OFN74_n171
XU313 MOAI1S $PINS O=n394 A1=FE_OFN69_n137 A2=n462 B1=FE_PHN854_Px_store_3_2
+ B2=FE_OFN69_n137
XU314 MOAI1S $PINS O=n390 A1=FE_OFN548_n137 A2=n468 B1=FE_PHN712_Px_store_3_6
+ B2=FE_OFN548_n137
XU315 MOAI1S $PINS O=n426 A1=FE_OFN71_n170 A2=n462 B1=FE_PHN864_Px_store_2_2
+ B2=FE_OFN71_n170
XU316 MOAI1S $PINS O=n422 A1=n170 A2=n468 B1=FE_PHN881_Px_store_2_6 B2=n170
XU317 MOAI1S $PINS O=n431 A1=FE_OFN74_n171 A2=n462 B1=FE_PHN865_Px_store_1_2
+ B2=FE_OFN74_n171
XU318 MOAI1S $PINS O=n435 A1=n171 A2=n468 B1=Px_store_1[6] B2=n171
XU319 MOAI1S $PINS O=n382 A1=FE_OFN549_n137 A2=n189 B1=FE_PHN719_Px_store_3_14
+ B2=FE_OFN549_n137
XU320 MOAI1S $PINS O=n366 A1=FE_OFN549_n137 A2=n463 B1=Px_store_3[30]
+ B2=FE_OFN549_n137
XU321 MOAI1S $PINS O=n414 A1=FE_OFN551_n170 A2=n189 B1=FE_PHN784_Px_store_2_14
+ B2=FE_OFN551_n170
XU322 MOAI1S $PINS O=n398 A1=FE_OFN551_n170 A2=n463 B1=FE_PHN869_Px_store_2_30
+ B2=FE_OFN551_n170
XU323 MOAI1S $PINS O=n443 A1=FE_OFN553_n171 A2=n189 B1=FE_PHN941_Px_store_1_14
+ B2=FE_OFN553_n171
XU324 MOAI1S $PINS O=n459 A1=FE_OFN553_n171 A2=n463 B1=Px_store_1[30]
+ B2=FE_OFN553_n171
XU325 MOAI1S $PINS O=n392 A1=FE_OFN69_n137 A2=n466 B1=Px_store_3[4] B2=n137
XU326 MOAI1S $PINS O=n384 A1=FE_OFN549_n137 A2=n187 B1=Px_store_3[12]
+ B2=FE_OFN549_n137
XU327 MOAI1S $PINS O=n380 A1=FE_OFN549_n137 A2=n191 B1=Px_store_3[16]
+ B2=FE_OFN549_n137
XU328 MOAI1S $PINS O=n368 A1=FE_OFN549_n137 A2=n268 B1=FE_PHN896_Px_store_3_28
+ B2=FE_OFN549_n137
XU329 MOAI1S $PINS O=n424 A1=FE_OFN72_n170 A2=n466 B1=FE_PHN778_Px_store_2_4
+ B2=FE_OFN72_n170
XU330 MOAI1S $PINS O=n416 A1=FE_OFN550_n170 A2=n187 B1=FE_PHN821_Px_store_2_12
+ B2=FE_OFN550_n170
XU331 MOAI1S $PINS O=n412 A1=FE_OFN551_n170 A2=n191 B1=Px_store_2[16]
+ B2=FE_OFN551_n170
XU332 MOAI1S $PINS O=n400 A1=FE_OFN551_n170 A2=n268 B1=Px_store_2[28]
+ B2=FE_OFN551_n170
XU333 MOAI1S $PINS O=n433 A1=FE_OFN74_n171 A2=n466 B1=FE_PHN831_Px_store_1_4
+ B2=FE_OFN74_n171
XU334 MOAI1S $PINS O=n441 A1=FE_OFN553_n171 A2=n187 B1=Px_store_1[12]
+ B2=FE_OFN553_n171
XU335 MOAI1S $PINS O=n445 A1=FE_OFN553_n171 A2=n191 B1=Px_store_1[16]
+ B2=FE_OFN553_n171
XU336 MOAI1S $PINS O=n457 A1=FE_OFN553_n171 A2=n268 B1=Px_store_1[28]
+ B2=FE_OFN553_n171
XU337 MOAI1S $PINS O=n388 A1=FE_OFN548_n137 A2=n470 B1=FE_PHN678_Px_store_3_8
+ B2=FE_OFN548_n137
XU338 MOAI1S $PINS O=n386 A1=FE_OFN548_n137 A2=n185 B1=Px_store_3[10]
+ B2=FE_OFN548_n137
XU339 MOAI1S $PINS O=n378 A1=FE_OFN549_n137 A2=n193 B1=Px_store_3[18]
+ B2=FE_OFN549_n137
XU340 MOAI1S $PINS O=n376 A1=FE_OFN548_n137 A2=n196 B1=Px_store_3[20]
+ B2=FE_OFN548_n137
XU341 MOAI1S $PINS O=n374 A1=FE_OFN549_n137 A2=n198 B1=Px_store_3[22]
+ B2=FE_OFN549_n137
XU342 MOAI1S $PINS O=n372 A1=FE_OFN549_n137 A2=n200 B1=Px_store_3[24]
+ B2=FE_OFN549_n137
XU343 MOAI1S $PINS O=n370 A1=FE_OFN549_n137 A2=n202 B1=Px_store_3[26]
+ B2=FE_OFN549_n137
XU344 MOAI1S $PINS O=n420 A1=FE_OFN550_n170 A2=n470 B1=FE_PHN897_Px_store_2_8
+ B2=FE_OFN550_n170
XU345 MOAI1S $PINS O=n418 A1=FE_OFN550_n170 A2=n185 B1=Px_store_2[10]
+ B2=FE_OFN550_n170
XU346 MOAI1S $PINS O=n410 A1=FE_OFN551_n170 A2=n193 B1=FE_PHN954_Px_store_2_18
+ B2=FE_OFN551_n170
XU347 MOAI1S $PINS O=n408 A1=FE_OFN550_n170 A2=n196 B1=FE_PHN770_Px_store_2_20
+ B2=FE_OFN550_n170
XU348 MOAI1S $PINS O=n406 A1=FE_OFN551_n170 A2=n198 B1=FE_PHN768_Px_store_2_22
+ B2=FE_OFN551_n170
XU349 MOAI1S $PINS O=n404 A1=FE_OFN551_n170 A2=n200 B1=FE_PHN937_Px_store_2_24
+ B2=FE_OFN551_n170
XU350 MOAI1S $PINS O=n402 A1=FE_OFN551_n170 A2=n202 B1=Px_store_2[26]
+ B2=FE_OFN551_n170
XU351 MOAI1S $PINS O=n437 A1=FE_OFN552_n171 A2=n470 B1=Px_store_1[8]
+ B2=FE_OFN552_n171
XU352 MOAI1S $PINS O=n439 A1=FE_OFN552_n171 A2=n185 B1=Px_store_1[10]
+ B2=FE_OFN552_n171
XU353 MOAI1S $PINS O=n447 A1=FE_OFN553_n171 A2=n193 B1=FE_PHN790_Px_store_1_18
+ B2=FE_OFN553_n171
XU354 MOAI1S $PINS O=n449 A1=FE_OFN552_n171 A2=n196 B1=FE_PHN905_Px_store_1_20
+ B2=FE_OFN552_n171
XU355 MOAI1S $PINS O=n451 A1=FE_OFN553_n171 A2=n198 B1=Px_store_1[22]
+ B2=FE_OFN553_n171
XU356 MOAI1S $PINS O=n453 A1=FE_OFN553_n171 A2=n200 B1=Px_store_1[24]
+ B2=FE_OFN553_n171
XU357 MOAI1S $PINS O=n455 A1=FE_OFN553_n171 A2=n202 B1=FE_PHN690_Px_store_1_26
+ B2=FE_OFN553_n171
XU358 MOAI1S $PINS O=n395 A1=FE_OFN69_n137 A2=n195 B1=Px_store_3[1]
+ B2=FE_OFN69_n137
XU359 MOAI1S $PINS O=n393 A1=FE_OFN576_n A2=n465 B1=Px_store_3[3]
+ B2=FE_OFN576_n
XU360 MOAI1S $PINS O=n391 A1=FE_OFN69_n137 A2=n467 B1=Px_store_3[5]
+ B2=FE_OFN69_n137
XU361 MOAI1S $PINS O=n389 A1=n137 A2=n469 B1=FE_PHN957_Px_store_3_7 B2=n137
XU362 MOAI1S $PINS O=n387 A1=FE_OFN548_n137 A2=n471 B1=Px_store_3[9]
+ B2=FE_OFN548_n137
XU363 MOAI1S $PINS O=n385 A1=n137 A2=n186 B1=Px_store_3[11] B2=n137
XU364 MOAI1S $PINS O=n383 A1=n137 A2=n188 B1=FE_PHN1575_Px_store_3_13 B2=n137
XU365 MOAI1S $PINS O=n381 A1=n137 A2=n190 B1=Px_store_3[15] B2=n137
XU366 MOAI1S $PINS O=n379 A1=n137 A2=n192 B1=FE_PHN929_Px_store_3_17 B2=n137
XU367 MOAI1S $PINS O=n377 A1=n137 A2=n194 B1=FE_PHN948_Px_store_3_19 B2=n137
XU368 MOAI1S $PINS O=n375 A1=n137 A2=n197 B1=Px_store_3[21] B2=n137
XU369 MOAI1S $PINS O=n373 A1=FE_OFN548_n137 A2=n199 B1=FE_PHN709_Px_store_3_23
+ B2=FE_OFN548_n137
XU370 MOAI1S $PINS O=n371 A1=FE_OFN548_n137 A2=n201 B1=FE_PHN735_Px_store_3_25
+ B2=FE_OFN548_n137
XU371 MOAI1S $PINS O=n369 A1=FE_OFN548_n137 A2=n203 B1=Px_store_3[27]
+ B2=FE_OFN548_n137
XU372 MOAI1S $PINS O=n367 A1=FE_OFN548_n137 A2=n461 B1=Px_store_3[29]
+ B2=FE_OFN548_n137
XU373 MOAI1S $PINS O=n365 A1=FE_OFN549_n137 A2=n464 B1=Px_store_3[31]
+ B2=FE_OFN549_n137
XU374 MOAI1S $PINS O=n427 A1=FE_OFN71_n170 A2=n195 B1=FE_PHN867_Px_store_2_1
+ B2=FE_OFN71_n170
XU375 MOAI1S $PINS O=n425 A1=FE_OFN71_n170 A2=n465 B1=Px_store_2[3]
+ B2=FE_OFN71_n170
XU376 MOAI1S $PINS O=n423 A1=FE_OFN71_n170 A2=n467 B1=Px_store_2[5]
+ B2=FE_OFN574_n
XU377 MOAI1S $PINS O=n421 A1=n170 A2=n469 B1=FE_PHN916_Px_store_2_7 B2=n170
XU378 MOAI1S $PINS O=n419 A1=n170 A2=n471 B1=FE_PHN959_Px_store_2_9 B2=n170
XU379 MOAI1S $PINS O=n417 A1=n170 A2=n186 B1=Px_store_2[11] B2=n170
XU380 MOAI1S $PINS O=n415 A1=n170 A2=n188 B1=FE_PHN724_Px_store_2_13 B2=n170
XU381 MOAI1S $PINS O=n413 A1=n170 A2=n190 B1=FE_PHN859_Px_store_2_15 B2=n170
XU382 MOAI1S $PINS O=n411 A1=n170 A2=n192 B1=Px_store_2[17] B2=n170
XU383 MOAI1S $PINS O=n409 A1=n170 A2=n194 B1=Px_store_2[19] B2=n170
XU384 MOAI1S $PINS O=n407 A1=n170 A2=n197 B1=FE_PHN776_Px_store_2_21 B2=n170
XU385 MOAI1S $PINS O=n405 A1=FE_OFN550_n170 A2=n199 B1=Px_store_2[23]
+ B2=FE_OFN550_n170
XU386 MOAI1S $PINS O=n403 A1=FE_OFN550_n170 A2=n201 B1=Px_store_2[25]
+ B2=FE_OFN550_n170
XU387 MOAI1S $PINS O=n401 A1=FE_OFN550_n170 A2=n203 B1=FE_PHN795_Px_store_2_27
+ B2=FE_OFN550_n170
XU388 MOAI1S $PINS O=n399 A1=FE_OFN550_n170 A2=n461 B1=FE_PHN785_Px_store_2_29
+ B2=FE_OFN550_n170
XU389 MOAI1S $PINS O=n397 A1=FE_OFN551_n170 A2=n464 B1=Px_store_2[31]
+ B2=FE_OFN551_n170
XU390 MOAI1S $PINS O=n430 A1=FE_OFN571_n A2=n195 B1=Px_store_1[1]
+ B2=FE_OFN571_n
XU391 MOAI1S $PINS O=n432 A1=FE_OFN74_n171 A2=n465 B1=Px_store_1[3]
+ B2=FE_OFN74_n171
XU392 MOAI1S $PINS O=n434 A1=FE_OFN74_n171 A2=n467 B1=FE_PHN689_Px_store_1_5
+ B2=FE_OFN74_n171
XU393 MOAI1S $PINS O=n436 A1=n171 A2=n469 B1=FE_PHN887_Px_store_1_7 B2=n171
XU394 MOAI1S $PINS O=n438 A1=n171 A2=n471 B1=FE_PHN680_Px_store_1_9 B2=n171
XU396 MOAI1S $PINS O=n440 A1=n171 A2=n186 B1=FE_PHN691_Px_store_1_11 B2=n171
XU397 MOAI1S $PINS O=n442 A1=n171 A2=n188 B1=FE_PHN918_Px_store_1_13 B2=n171
XU398 MOAI1S $PINS O=n444 A1=FE_OFN552_n171 A2=n190 B1=Px_store_1[15]
+ B2=FE_OFN552_n171
XU399 MOAI1S $PINS O=n446 A1=n171 A2=n192 B1=Px_store_1[17] B2=n171
XU400 MOAI1S $PINS O=n448 A1=n171 A2=n194 B1=Px_store_1[19] B2=n171
XU401 MOAI1S $PINS O=n450 A1=n171 A2=n197 B1=Px_store_1[21] B2=n171
XU402 MOAI1S $PINS O=n452 A1=FE_OFN552_n171 A2=n199 B1=FE_PHN938_Px_store_1_23
+ B2=FE_OFN552_n171
XU403 MOAI1S $PINS O=n454 A1=FE_OFN552_n171 A2=n201 B1=Px_store_1[25]
+ B2=FE_OFN552_n171
XU404 MOAI1S $PINS O=n456 A1=FE_OFN552_n171 A2=n203 B1=Px_store_1[27]
+ B2=FE_OFN552_n171
XU405 MOAI1S $PINS O=n458 A1=FE_OFN552_n171 A2=n461 B1=Px_store_1[29]
+ B2=FE_OFN552_n171
XU406 MOAI1S $PINS O=n460 A1=FE_OFN553_n171 A2=n464 B1=FE_PHN893_Px_store_1_31
+ B2=FE_OFN553_n171
XU407 MOAI1S $PINS O=n300 A1=FE_OFN69_n137 A2=n183 B1=FE_PHN920_Py_store_3_0
+ B2=FE_OFN69_n137
XU408 MOAI1S $PINS O=n298 A1=FE_OFN576_n A2=n493 B1=Py_store_3[2]
+ B2=FE_OFN576_n
XU409 MOAI1S $PINS O=n294 A1=FE_OFN577_n A2=n499 B1=FE_PHN955_Py_store_3_6
+ B2=FE_OFN577_n
XU410 MOAI1S $PINS O=n286 A1=FE_OFN578_n A2=n476 B1=Py_store_3[14]
+ B2=FE_OFN578_n
XU411 MOAI1S $PINS O=n270 A1=FE_OFN578_n A2=n494 B1=FE_PHN950_Py_store_3_30
+ B2=FE_OFN578_n
XU412 MOAI1S $PINS O=n296 A1=FE_OFN576_n A2=n497 B1=Py_store_3[4]
+ B2=FE_OFN576_n
XU413 MOAI1S $PINS O=n288 A1=FE_OFN579_n A2=n474 B1=FE_PHN934_Py_store_3_12
+ B2=FE_OFN579_n
XU414 MOAI1S $PINS O=n284 A1=FE_OFN578_n A2=n478 B1=Py_store_3[16]
+ B2=FE_OFN578_n
XU415 MOAI1S $PINS O=n272 A1=FE_OFN578_n A2=n491 B1=FE_PHN943_Py_store_3_28
+ B2=FE_OFN578_n
XU416 MOAI1S $PINS O=n292 A1=FE_OFN577_n A2=n501 B1=FE_PHN819_Py_store_3_8
+ B2=FE_OFN577_n
XU417 MOAI1S $PINS O=n290 A1=FE_OFN578_n A2=n472 B1=FE_PHN939_Py_store_3_10
+ B2=FE_OFN578_n
XU418 MOAI1S $PINS O=n282 A1=FE_OFN579_n A2=n480 B1=Py_store_3[18]
+ B2=FE_OFN579_n
XU419 MOAI1S $PINS O=n280 A1=FE_OFN578_n A2=n483 B1=FE_PHN946_Py_store_3_20
+ B2=FE_OFN578_n
XU420 MOAI1S $PINS O=n278 A1=FE_OFN69_n137 A2=n485 B1=Py_store_3[22]
+ B2=FE_OFN69_n137
XU421 MOAI1S $PINS O=n276 A1=FE_OFN578_n A2=n487 B1=Py_store_3[24]
+ B2=FE_OFN578_n
XU422 MOAI1S $PINS O=n274 A1=FE_OFN578_n A2=n489 B1=Py_store_3[26]
+ B2=FE_OFN578_n
XU423 MOAI1S $PINS O=n299 A1=FE_OFN576_n A2=n482 B1=FE_PHN1590_Py_store_3_1
+ B2=FE_OFN576_n
XU424 MOAI1S $PINS O=n297 A1=FE_OFN576_n A2=n496 B1=Py_store_3[3]
+ B2=FE_OFN576_n
XU425 MOAI1S $PINS O=n295 A1=FE_OFN576_n A2=n498 B1=Py_store_3[5]
+ B2=FE_OFN576_n
XU426 MOAI1S $PINS O=n293 A1=FE_OFN576_n A2=n500 B1=Py_store_3[7]
+ B2=FE_OFN576_n
XU427 MOAI1S $PINS O=n291 A1=FE_OFN579_n A2=n502 B1=Py_store_3[9]
+ B2=FE_OFN579_n
XU428 MOAI1S $PINS O=n289 A1=FE_OFN579_n A2=n473 B1=FE_PHN728_Py_store_3_11
+ B2=FE_OFN579_n
XU429 MOAI1S $PINS O=n287 A1=FE_OFN579_n A2=n475 B1=FE_PHN904_Py_store_3_13
+ B2=FE_OFN579_n
XU430 MOAI1S $PINS O=n285 A1=FE_OFN576_n A2=n477 B1=Py_store_3[15]
+ B2=FE_OFN576_n
XU431 MOAI1S $PINS O=n283 A1=FE_OFN576_n A2=n479 B1=Py_store_3[17]
+ B2=FE_OFN576_n
XU432 MOAI1S $PINS O=n281 A1=FE_OFN579_n A2=n481 B1=Py_store_3[19]
+ B2=FE_OFN579_n
XU433 MOAI1S $PINS O=n279 A1=FE_OFN576_n A2=n484 B1=FE_PHN861_Py_store_3_21
+ B2=FE_OFN576_n
XU434 MOAI1S $PINS O=n277 A1=FE_OFN579_n A2=n486 B1=FE_PHN944_Py_store_3_23
+ B2=FE_OFN579_n
XU435 MOAI1S $PINS O=n275 A1=FE_OFN579_n A2=n488 B1=FE_PHN688_Py_store_3_25
+ B2=FE_OFN579_n
XU436 MOAI1S $PINS O=n273 A1=FE_OFN579_n A2=n490 B1=Py_store_3[27]
+ B2=FE_OFN579_n
XU437 MOAI1S $PINS O=n271 A1=FE_OFN579_n A2=n492 B1=Py_store_3[29]
+ B2=FE_OFN577_n
XU438 MOAI1S $PINS O=n269 A1=FE_OFN578_n A2=n495 B1=FE_PHN834_Py_store_3_31
+ B2=FE_OFN578_n
XU439 INV1S $PINS O=n184 I=Px_in[0]
XU440 INV1S $PINS O=n462 I=Px_in[2]
XU441 INV1S $PINS O=n468 I=Px_in[6]
XU442 INV1S $PINS O=n189 I=Px_in[14]
XU443 INV1S $PINS O=n463 I=Px_in[30]
XU444 INV1S $PINS O=n191 I=Px_in[16]
XU445 INV1S $PINS O=n466 I=Px_in[4]
XU446 INV1S $PINS O=n187 I=Px_in[12]
XU447 INV1S $PINS O=n268 I=Px_in[28]
XU448 INV1S $PINS O=n195 I=Px_in[1]
XU449 INV1S $PINS O=n465 I=Px_in[3]
XU450 INV1S $PINS O=n467 I=Px_in[5]
XU451 INV1S $PINS O=n469 I=Px_in[7]
XU452 INV1S $PINS O=n470 I=Px_in[8]
XU453 INV1S $PINS O=n471 I=Px_in[9]
XU454 INV1S $PINS O=n185 I=Px_in[10]
XU455 INV1S $PINS O=n186 I=Px_in[11]
XU456 INV1S $PINS O=n188 I=Px_in[13]
XU457 INV1S $PINS O=n190 I=Px_in[15]
XU458 INV1S $PINS O=n192 I=Px_in[17]
XU459 INV1S $PINS O=n193 I=Px_in[18]
XU460 INV1S $PINS O=n194 I=Px_in[19]
XU462 INV1S $PINS O=n196 I=Px_in[20]
XU463 INV1S $PINS O=n197 I=Px_in[21]
XU464 INV1S $PINS O=n198 I=Px_in[22]
XU465 INV1S $PINS O=n199 I=Px_in[23]
XU466 INV1S $PINS O=n200 I=Px_in[24]
XU467 INV1S $PINS O=n201 I=Px_in[25]
XU468 INV1S $PINS O=n202 I=Px_in[26]
XU469 INV1S $PINS O=n203 I=Px_in[27]
XU470 INV1S $PINS O=n461 I=Px_in[29]
XU471 INV1S $PINS O=n464 I=Px_in[31]
XU472 INV1S $PINS O=n183 I=Py_in[0]
XU473 INV1S $PINS O=n493 I=Py_in[2]
XU474 INV1S $PINS O=n499 I=Py_in[6]
XU475 INV1S $PINS O=n476 I=Py_in[14]
XU476 INV1S $PINS O=n494 I=Py_in[30]
XU477 INV1S $PINS O=n478 I=Py_in[16]
XU478 INV1S $PINS O=n497 I=Py_in[4]
XU479 INV1S $PINS O=n474 I=Py_in[12]
XU480 INV1S $PINS O=n491 I=Py_in[28]
XU481 INV1S $PINS O=n483 I=Py_in[20]
XU482 INV1S $PINS O=n501 I=Py_in[8]
XU483 INV1S $PINS O=n472 I=Py_in[10]
XU484 INV1S $PINS O=n480 I=Py_in[18]
XU485 INV1S $PINS O=n485 I=Py_in[22]
XU486 INV1S $PINS O=n487 I=Py_in[24]
XU487 INV1S $PINS O=n489 I=Py_in[26]
XU488 INV1S $PINS O=n482 I=Py_in[1]
XU489 INV1S $PINS O=n496 I=Py_in[3]
XU490 INV1S $PINS O=n498 I=Py_in[5]
XU491 INV1S $PINS O=n500 I=Py_in[7]
XU492 INV1S $PINS O=n502 I=Py_in[9]
XU493 INV1S $PINS O=n473 I=Py_in[11]
XU494 INV1S $PINS O=n475 I=Py_in[13]
XU495 INV1S $PINS O=n477 I=Py_in[15]
XU496 INV1S $PINS O=n479 I=Py_in[17]
XU497 INV1S $PINS O=n481 I=Py_in[19]
XU498 INV1S $PINS O=n484 I=Py_in[21]
XU499 INV1S $PINS O=n486 I=Py_in[23]
XU500 INV1S $PINS O=n488 I=Py_in[25]
XU501 INV1S $PINS O=n490 I=Py_in[27]
XU502 INV1S $PINS O=n492 I=Py_in[29]
XU503 INV1S $PINS O=n495 I=Py_in[31]
.ENDS

.SUBCKT Control i_rst GFAU_done_to_control keyshift_done_to_control
+ key_from_key_shift[1] key_from_key_shift[0] raw1[31] raw1[30] raw1[29]
+ raw1[28] raw1[27] raw1[26] raw1[25] raw1[24] raw1[23] raw1[22] raw1[21]
+ raw1[20] raw1[19] raw1[18] raw1[17] raw1[16] raw1[15] raw1[14] raw1[13]
+ raw1[12] raw1[11] raw1[10] raw1[9] raw1[8] raw1[7] raw1[6] raw1[5] raw1[4]
+ raw1[3] raw1[2] raw1[1] raw1[0] raw2[31] raw2[30] raw2[29] raw2[28] raw2[27]
+ raw2[26] raw2[25] raw2[24] raw2[23] raw2[22] raw2[21] raw2[20] raw2[19]
+ raw2[18] raw2[17] raw2[16] raw2[15] raw2[14] raw2[13] raw2[12] raw2[11]
+ raw2[10] raw2[9] raw2[8] raw2[7] raw2[6] raw2[5] raw2[4] raw2[3] raw2[2]
+ raw2[1] raw2[0] raw_prime[31] raw_prime[30] raw_prime[29] raw_prime[28]
+ raw_prime[27] raw_prime[26] raw_prime[25] raw_prime[24] raw_prime[23]
+ raw_prime[22] raw_prime[21] raw_prime[20] raw_prime[19] raw_prime[18]
+ raw_prime[17] raw_prime[16] raw_prime[15] raw_prime[14] raw_prime[13]
+ raw_prime[12] raw_prime[11] raw_prime[10] raw_prime[9] raw_prime[8]
+ raw_prime[7] raw_prime[6] raw_prime[5] raw_prime[4] raw_prime[3] raw_prime[2]
+ raw_prime[1] raw_prime[0] raw_a[31] raw_a[30] raw_a[29] raw_a[28] raw_a[27]
+ raw_a[26] raw_a[25] raw_a[24] raw_a[23] raw_a[22] raw_a[21] raw_a[20]
+ raw_a[19] raw_a[18] raw_a[17] raw_a[16] raw_a[15] raw_a[14] raw_a[13]
+ raw_a[12] raw_a[11] raw_a[10] raw_a[9] raw_a[8] raw_a[7] raw_a[6] raw_a[5]
+ raw_a[4] raw_a[3] raw_a[2] raw_a[1] raw_a[0] load_done GFAU_out[31]
+ GFAU_out[30] GFAU_out[29] GFAU_out[28] GFAU_out[27] GFAU_out[26] GFAU_out[25]
+ GFAU_out[24] GFAU_out[23] GFAU_out[22] GFAU_out[21] GFAU_out[20] GFAU_out[19]
+ GFAU_out[18] GFAU_out[17] GFAU_out[16] GFAU_out[15] GFAU_out[14] GFAU_out[13]
+ GFAU_out[12] GFAU_out[11] GFAU_out[10] GFAU_out[9] GFAU_out[8] GFAU_out[7]
+ GFAU_out[6] GFAU_out[5] GFAU_out[4] GFAU_out[3] GFAU_out[2] GFAU_out[1]
+ GFAU_out[0] Px_mont[31] Px_mont[30] Px_mont[29] Px_mont[28] Px_mont[27]
+ Px_mont[26] Px_mont[25] Px_mont[24] Px_mont[23] Px_mont[22] Px_mont[21]
+ Px_mont[20] Px_mont[19] Px_mont[18] Px_mont[17] Px_mont[16] Px_mont[15]
+ Px_mont[14] Px_mont[13] Px_mont[12] Px_mont[11] Px_mont[10] Px_mont[9]
+ Px_mont[8] Px_mont[7] Px_mont[6] Px_mont[5] Px_mont[4] Px_mont[3] Px_mont[2]
+ Px_mont[1] Px_mont[0] Py_mont[31] Py_mont[30] Py_mont[29] Py_mont[28]
+ Py_mont[27] Py_mont[26] Py_mont[25] Py_mont[24] Py_mont[23] Py_mont[22]
+ Py_mont[21] Py_mont[20] Py_mont[19] Py_mont[18] Py_mont[17] Py_mont[16]
+ Py_mont[15] Py_mont[14] Py_mont[13] Py_mont[12] Py_mont[11] Py_mont[10]
+ Py_mont[9] Py_mont[8] Py_mont[7] Py_mont[6] Py_mont[5] Py_mont[4] Py_mont[3]
+ Py_mont[2] Py_mont[1] Py_mont[0] operation_select[1] operation_select[0]
+ key_shift_done_from_control GFAU_done_from_control final_output_1[31]
+ final_output_1[30] final_output_1[29] final_output_1[28] final_output_1[27]
+ final_output_1[26] final_output_1[25] final_output_1[24] final_output_1[23]
+ final_output_1[22] final_output_1[21] final_output_1[20] final_output_1[19]
+ final_output_1[18] final_output_1[17] final_output_1[16] final_output_1[15]
+ final_output_1[14] final_output_1[13] final_output_1[12] final_output_1[11]
+ final_output_1[10] final_output_1[9] final_output_1[8] final_output_1[7]
+ final_output_1[6] final_output_1[5] final_output_1[4] final_output_1[3]
+ final_output_1[2] final_output_1[1] final_output_1[0] final_output_2[31]
+ final_output_2[30] final_output_2[29] final_output_2[28] final_output_2[27]
+ final_output_2[26] final_output_2[25] final_output_2[24] final_output_2[23]
+ final_output_2[22] final_output_2[21] final_output_2[20] final_output_2[19]
+ final_output_2[18] final_output_2[17] final_output_2[16] final_output_2[15]
+ final_output_2[14] final_output_2[13] final_output_2[12] final_output_2[11]
+ final_output_2[10] final_output_2[9] final_output_2[8] final_output_2[7]
+ final_output_2[6] final_output_2[5] final_output_2[4] final_output_2[3]
+ final_output_2[2] final_output_2[1] final_output_2[0] final_done
+ FE_OFN40_FE_DBTN1_i_i_rst FE_OFN35_FE_DBTN1_i_i_rst FE_OFN33_FE_DBTN1_i_i_rst
+ FE_OFN19_FE_DBTN1_i_i_rst FE_OFN16_FE_DBTN1_i_i_rst FE_OFN12_FE_DBTN1_i_i_rst
+ FE_OFN6_FE_DBTN1_i_i_rst FE_OFN47_raw_prime_31 FE_OFN49_raw_prime_30
+ FE_OFN53_raw_prime_29 FE_OFN57_raw_prime_28 FE_OFN59_raw_prime_27
+ FE_OFN63_raw_prime_26 FE_OFN67_raw_prime_25 FE_OFN71_raw_prime_24
+ FE_OFN73_raw_prime_23 FE_OFN77_raw_prime_22 FE_OFN81_raw_prime_21
+ FE_OFN85_raw_prime_20 FE_OFN87_raw_prime_19 FE_OFN91_raw_prime_18
+ FE_OFN95_raw_prime_17 FE_OFN99_raw_prime_16 FE_OFN103_raw_prime_15
+ FE_OFN106_raw_prime_14 FE_OFN109_raw_prime_13 FE_OFN112_raw_prime_12
+ FE_OFN116_raw_prime_11 FE_OFN119_raw_prime_10 FE_OFN122_raw_prime_9
+ FE_OFN124_raw_prime_7 FE_OFN126_raw_prime_6 FE_OFN129_raw_prime_4
+ FE_OFN131_n312 FE_OFN141_raw_prime_8 FE_OFN137_raw_prime_8
+ FE_OFN135_raw_prime_8 FE_OFN146_raw_prime_2 FE_OFN148_raw_prime_3
+ FE_OFN153_raw_prime_5 FE_OFN156_raw_prime_8 FE_OFN165_n FE_OFN160_n
+ FE_OFN190_FE_OFN56_raw_prime_6 FE_OFN196_FE_OFN55_raw_prime_7
+ FE_OFN200_FE_OFN53_raw_prime_9 FE_OFN209_FE_OFN51_raw_prime_11
+ FE_OFN214_FE_OFN49_raw_prime_13 FE_OFN220_FE_OFN46_raw_prime_16
+ FE_OFN221_FE_OFN45_raw_prime_17 FE_OFN222_FE_OFN44_raw_prime_18
+ FE_OFN224_FE_OFN43_raw_prime_19 FE_OFN229_FE_OFN42_raw_prime_20
+ FE_OFN236_FE_OFN41_raw_prime_21 FE_OFN234_FE_OFN41_raw_prime_21
+ FE_OFN239_FE_OFN40_raw_prime_22 FE_OFN240_FE_OFN39_raw_prime_23
+ FE_OFN242_FE_OFN38_raw_prime_24 FE_OFN247_FE_OFN37_raw_prime_25
+ FE_OFN249_FE_OFN36_raw_prime_26 FE_OFN256_FE_OFN35_raw_prime_27
+ FE_OFN259_FE_OFN34_raw_prime_28 FE_OFN263_FE_OFN33_raw_prime_29
+ FE_OFN265_FE_OFN32_raw_prime_30 FE_OFN270_FE_OFN31_raw_prime_31
+ FE_OFN268_FE_OFN31_raw_prime_31 FE_OFN304_FE_OFN4_FE_DBTN1_i_i_rst
+ FE_OFN323_n FE_OFN321_n FE_OFN336_n FE_OFN334_n FE_OFN340_n FE_OFN344_n
+ FE_OFN342_n i_clk_clone1 i_clk_clone10 i_clk_clone9 i_clk_clone11
+ i_clk_clone8 i_clk_clone7 i_clk_clone6 i_clk_clone5 i_clk_clone4 i_clk_clone3
+ i_clk_clone2 i_clk p1 p2
XFE_PHC1638_y3_w_29 BUF12CK $PINS O=FE_PHN1638_y3_w_29 I=y3_w[29]
XFE_PHC1637_n858 BUF1CK $PINS O=FE_PHN1637_n858 I=FE_PHN814_n858
XFE_PHC1636_FE_DBTN70_x3_w_31 BUF1CK $PINS O=FE_PHN1636_FE_DBTN70_x3_w_31
+ I=FE_DBTN70_x3_w_31
XFE_PHC1635_n878 BUF1CK $PINS O=FE_PHN1635_n878 I=FE_PHN800_n878
XFE_PHC1634_n838 BUF1CK $PINS O=FE_PHN1634_n838 I=FE_PHN760_n838
XFE_PHC1633_y1_17 BUF1CK $PINS O=FE_PHN1633_y1_17 I=y1[17]
XFE_PHC1629_n988 BUF1CK $PINS O=FE_PHN1629_n988 I=n988
XFE_PHC1605_y1_15 BUF1CK $PINS O=FE_PHN1605_y1_15 I=y1[15]
XFE_PHC1604_y1_16 BUF1CK $PINS O=FE_PHN1604_y1_16 I=y1[16]
XFE_PHC1603_n1221 BUF1CK $PINS O=FE_PHN1603_n1221 I=FE_PHN1119_n1221
XFE_PHC1596_y1_20 BUF1CK $PINS O=FE_PHN1596_y1_20 I=y1[20]
XFE_PHC1591_n818 BUF1CK $PINS O=FE_PHN1591_n818 I=FE_PHN1092_n818
XFE_PHC1587_y1_18 BUF1CK $PINS O=FE_PHN1587_y1_18 I=FE_PHN1052_y1_18
XFE_PHC1585_y1_21 BUF1CK $PINS O=FE_PHN1585_y1_21 I=y1[21]
XFE_PHC1580_x1_1 BUF1CK $PINS O=FE_PHN1580_x1_1 I=x1[1]
XFE_PHC1578_n1011 BUF1CK $PINS O=FE_PHN1578_n1011 I=FE_PHN1448_n1011
XFE_PHC1577_x1_17 BUF1CK $PINS O=FE_PHN1577_x1_17 I=x1[17]
XFE_PHC1576_y1_7 BUF1CK $PINS O=FE_PHN1576_y1_7 I=y1[7]
XFE_PHC1574_y1_30 BUF1CK $PINS O=FE_PHN1574_y1_30 I=y1[30]
XFE_PHC1565_x1_21 BUF1CK $PINS O=FE_PHN1565_x1_21 I=x1[21]
XFE_PHC1563_n1312 BUF1CK $PINS O=FE_PHN1563_n1312 I=FE_PHN1090_n1312
XFE_PHC1558_x1_27 BUF1CK $PINS O=FE_PHN1558_x1_27 I=x1[27]
XFE_PHC1556_a_3 BUF1CK $PINS O=FE_PHN1556_a_3 I=FE_PHN1068_a_3
XFE_PHC1534_y1_3 BUF1CK $PINS O=FE_PHN1534_y1_3 I=y1[3]
XFE_PHC1517_n1332 BUF2CK $PINS O=FE_PHN1517_n1332 I=FE_PHN1100_n1332
XFE_PHC1513_n868 BUF1CK $PINS O=FE_PHN1513_n868 I=FE_PHN1061_n868
XFE_PHC1509_n848 BUF1CK $PINS O=FE_PHN1509_n848 I=FE_PHN1077_n848
XFE_PHC1507_a_2 BUF1CK $PINS O=FE_PHN1507_a_2 I=a[2]
XFE_PHC1501_n888 BUF1CK $PINS O=FE_PHN1501_n888 I=FE_PHN1074_n888
XFE_PHC1489_counter_1 BUF3 $PINS O=FE_PHN1489_counter_1 I=counter[1]
XFE_PHC1484_counter_0 BUF1CK $PINS O=FE_PHN1484_counter_0
+ I=FE_PHN1167_counter_0
XFE_PHC1483_n1222 BUF1CK $PINS O=FE_PHN1483_n1222 I=FE_PHN1095_n1222
XFE_PHC1479_n1212 BUF1CK $PINS O=FE_PHN1479_n1212 I=FE_PHN1078_n1212
XFE_PHC1475_n849 BUF1CK $PINS O=FE_PHN1475_n849 I=FE_PHN1096_n849
XFE_PHC1463_n1192 BUF1CK $PINS O=FE_PHN1463_n1192 I=FE_PHN1088_n1192
XFE_PHC1448_n1011 BUF3 $PINS O=FE_PHN1448_n1011 I=n1011
XFE_PHC1447_n925 BUF2CK $PINS O=FE_PHN1447_n925 I=n925
XFE_PHC1446_n1153 BUF1CK $PINS O=FE_PHN1446_n1153 I=n1153
XFE_PHC1445_n919 BUF3 $PINS O=FE_PHN1445_n919 I=n919
XFE_PHC1444_n904 BUF1S $PINS O=FE_PHN1444_n904 I=n904
XFE_PHC1443_n906 BUF1S $PINS O=FE_PHN1443_n906 I=n906
XFE_PHC1442_n896 BUF1S $PINS O=FE_PHN1442_n896 I=n896
XFE_PHC1441_n1013 BUF1S $PINS O=FE_PHN1441_n1013 I=n1013
XFE_PHC1440_n990 BUF1S $PINS O=n990 I=FE_PHN1440_n990
XFE_PHC1439_n910 BUF1S $PINS O=FE_PHN1439_n910 I=n910
XFE_PHC1438_n1009 BUF1S $PINS O=FE_PHN1438_n1009 I=n1009
XFE_PHC1436_n908 BUF1S $PINS O=FE_PHN1436_n908 I=n908
XFE_PHC1435_n951 BUF1S $PINS O=n951 I=FE_PHN1435_n951
XFE_PHC1433_n943 BUF1S $PINS O=FE_PHN1433_n943 I=n943
XFE_PHC1432_n902 BUF1S $PINS O=FE_PHN1432_n902 I=n902
XFE_PHC1431_n963 BUF1S $PINS O=n963 I=FE_PHN1431_n963
XFE_PHC1430_n962 BUF1S $PINS O=n962 I=FE_PHN1430_n962
XFE_PHC1428_n894 BUF1S $PINS O=FE_PHN1428_n894 I=n894
XFE_PHC1427_n1151 BUF1S $PINS O=FE_PHN1427_n1151 I=n1151
XFE_PHC1426_n954 BUF1S $PINS O=FE_PHN1426_n954 I=n954
XFE_PHC1425_n953 BUF1S $PINS O=n953 I=FE_PHN1425_n953
XFE_PHC1424_n1007 DELA $PINS O=n1007 I=FE_PHN1424_n1007
XFE_PHC1422_n993 DELA $PINS O=n993 I=FE_PHN1422_n993
XFE_PHC1421_n900 BUF1S $PINS O=FE_PHN1421_n900 I=n900
XFE_PHC1420_n980 DELA $PINS O=FE_PHN1420_n980 I=n980
XFE_PHC1418_n981 BUF1S $PINS O=FE_PHN1418_n981 I=n981
XFE_PHC1417_n982 DELA $PINS O=FE_PHN1417_n982 I=n982
XFE_PHC1416_n899 BUF1S $PINS O=FE_PHN1416_n899 I=n899
XFE_PHC1415_n903 DELA $PINS O=FE_PHN1415_n903 I=n903
XFE_PHC1412_n950 BUF4 $PINS O=FE_PHN1412_n950 I=n950
XFE_PHC1410_n891 DELA $PINS O=n891 I=FE_PHN1410_n891
XFE_PHC1409_n983 DELA $PINS O=n983 I=FE_PHN1409_n983
XFE_PHC1408_n892 DELA $PINS O=FE_PHN1408_n892 I=n892
XFE_PHC1407_n979 DELA $PINS O=FE_PHN1407_n979 I=n979
XFE_PHC1406_n999 BUF4CK $PINS O=FE_PHN1406_n999 I=n999
XFE_PHC1405_n898 DELA $PINS O=FE_PHN1405_n898 I=n898
XFE_PHC1403_n893 DELA $PINS O=FE_PHN1403_n893 I=n893
XFE_PHC1401_n890 DELA $PINS O=FE_PHN1401_n890 I=n890
XFE_PHC1400_n1015 BUF4 $PINS O=FE_PHN1400_n1015 I=n1015
XFE_PHC1399_n955 DELA $PINS O=FE_PHN1399_n955 I=n955
XFE_PHC1398_n909 DELA $PINS O=n909 I=FE_PHN1398_n909
XFE_PHC1397_n923 BUF3CK $PINS O=FE_PHN1397_n923 I=n923
XFE_PHC1396_n889 DELA $PINS O=FE_PHN1396_n889 I=n889
XFE_PHC1395_n901 DELA $PINS O=n901 I=FE_PHN1395_n901
XFE_PHC1394_n911 DELA $PINS O=n911 I=FE_PHN1394_n911
XFE_PHC1392_n922 BUF3 $PINS O=FE_PHN1392_n922 I=n922
XFE_PHC1391_n905 DELA $PINS O=FE_PHN1391_n905 I=n905
XFE_PHC1390_n915 BUF4 $PINS O=n915 I=FE_PHN1390_n915
XFE_PHC1388_n897 DELA $PINS O=FE_PHN1388_n897 I=n897
XFE_PHC1387_n918 BUF4 $PINS O=FE_PHN1387_n918 I=n918
XFE_PHC1386_n895 DELA $PINS O=FE_PHN1386_n895 I=n895
XFE_PHC1385_n913 DELA $PINS O=n913 I=FE_PHN1385_n913
XFE_PHC1384_n959 BUF4 $PINS O=FE_PHN1384_n959 I=n959
XFE_PHC1383_n984 DELA $PINS O=FE_PHN1383_n984 I=n984
XFE_PHC1382_n917 BUF3 $PINS O=FE_PHN1382_n917 I=n917
XFE_PHC1381_n914 DELA $PINS O=n914 I=FE_PHN1381_n914
XFE_PHC1380_n912 DELA $PINS O=FE_PHN1380_n912 I=n912
XFE_PHC1379_n930 BUF3 $PINS O=FE_PHN1379_n930 I=n930
XFE_PHC1377_n907 DELA $PINS O=n907 I=FE_PHN1377_n907
XFE_PHC1376_n958 DELA $PINS O=FE_PHN1376_n958 I=n958
XFE_PHC1375_n938 BUF1CK $PINS O=n938 I=FE_PHN1375_n938
XFE_PHC1374_n969 DELA $PINS O=FE_PHN1374_n969 I=n969
XFE_PHC1373_n1150 DELA $PINS O=FE_PHN1373_n1150 I=n1150
XFE_PHC1372_n942 BUF1CK $PINS O=FE_PHN1372_n942 I=n942
XFE_PHC1371_n945 BUF1CK $PINS O=FE_PHN1371_n945 I=n945
XFE_PHC1370_n932 BUF2CK $PINS O=FE_PHN1370_n932 I=n932
XFE_PHC1369_n1146 BUF1CK $PINS O=FE_PHN1369_n1146 I=n1146
XFE_PHC1368_n946 BUF1S $PINS O=FE_PHN1368_n946 I=n946
XFE_PHC1367_n948 BUF1CK $PINS O=n948 I=FE_PHN1367_n948
XFE_PHC1366_n1149 DELB $PINS O=FE_PHN1366_n1149 I=n1149
XFE_PHC1365_n933 BUF1S $PINS O=FE_PHN1365_n933 I=n933
XFE_PHC1363_n934 BUF1S $PINS O=n934 I=FE_PHN1363_n934
XFE_PHC1362_n1144 BUF1S $PINS O=FE_PHN1362_n1144 I=n1144
XFE_PHC1361_n947 BUF1S $PINS O=FE_PHN1361_n947 I=n947
XFE_PHC1360_n1016 BUF1S $PINS O=FE_PHN1360_n1016 I=n1016
XFE_PHC1359_n927 BUF1S $PINS O=FE_PHN1359_n927 I=n927
XFE_PHC1358_n935 BUF1CK $PINS O=n935 I=FE_PHN1358_n935
XFE_PHC1357_n921 BUF1S $PINS O=FE_PHN1357_n921 I=n921
XFE_PHC1356_n949 BUF1S $PINS O=FE_PHN1356_n949 I=n949
XFE_PHC1355_n940 BUF1S $PINS O=FE_PHN1355_n940 I=n940
XFE_PHC1354_n997 BUF1S $PINS O=FE_PHN1354_n997 I=n997
XFE_PHC1353_n1010 BUF1S $PINS O=FE_PHN1353_n1010 I=n1010
XFE_PHC1352_n944 BUF1S $PINS O=FE_PHN1352_n944 I=n944
XFE_PHC1351_n936 BUF1S $PINS O=FE_PHN1351_n936 I=n936
XFE_PHC1350_n985 BUF1S $PINS O=FE_PHN1350_n985 I=n985
XFE_PHC1349_n924 BUF1S $PINS O=FE_PHN1349_n924 I=n924
XFE_PHC1348_n928 BUF1S $PINS O=FE_PHN1348_n928 I=n928
XFE_PHC1347_n929 BUF1S $PINS O=n929 I=FE_PHN1347_n929
XFE_PHC1346_n920 BUF1S $PINS O=n920 I=FE_PHN1346_n920
XFE_PHC1345_n941 BUF1S $PINS O=FE_PHN1345_n941 I=n941
XFE_PHC1344_n952 BUF1S $PINS O=FE_PHN1344_n952 I=n952
XFE_PHC1343_n1012 BUF1S $PINS O=n1012 I=FE_PHN1343_n1012
XFE_PHC1342_n926 BUF1S $PINS O=FE_PHN1342_n926 I=n926
XFE_PHC1341_n939 BUF1S $PINS O=FE_PHN1341_n939 I=n939
XFE_PHC1340_n957 BUF1S $PINS O=FE_PHN1340_n957 I=n957
XFE_PHC1339_x3_w_0 BUF1CK $PINS O=FE_PHN1339_x3_w_0 I=x3_w[0]
XFE_PHC1337_x3_w_6 BUF1CK $PINS O=FE_PHN1337_x3_w_6 I=x3_w[6]
XFE_PHC1336_x3_w_3 BUF1S $PINS O=x3_w[3] I=FE_PHN1336_x3_w_3
XFE_PHC1328_y3_w_0 BUF1CK $PINS O=y3_w[0] I=FE_PHN1328_y3_w_0
XFE_PHC1300_y3_w_3 BUF1CK $PINS O=FE_PHN1300_y3_w_3 I=y3_w[3]
XFE_PHC1262_x3_w_14 BUF1CK $PINS O=FE_PHN1262_x3_w_14 I=x3_w[14]
XFE_PHC1242_x3_w_18 BUF1CK $PINS O=x3_w[18] I=FE_PHN1242_x3_w_18
XFE_PHC1235_x3_w_20 BUF1CK $PINS O=FE_PHN1235_x3_w_20 I=x3_w[20]
XFE_PHC1226_x3_w_22 BUF1CK $PINS O=x3_w[22] I=FE_PHN1226_x3_w_22
XFE_PHC1225_x3_w_12 BUF1CK $PINS O=FE_PHN1225_x3_w_12 I=x3_w[12]
XFE_PHC1217_n1416 BUF1CK $PINS O=FE_PHN1217_n1416 I=n1416
XFE_PHC1205_n1420 BUF1CK $PINS O=FE_PHN1205_n1420 I=n1420
XFE_PHC1199_n472 BUF1CK $PINS O=FE_PHN1199_n472 I=n472
XFE_PHC1194_n1428 BUF1CK $PINS O=FE_PHN1194_n1428 I=n1428
XFE_PHC1192_x3_w_30 BUF1CK $PINS O=FE_PHN1192_x3_w_30 I=x3_w[30]
XFE_PHC1185_n1414 BUF1CK $PINS O=FE_PHN1185_n1414 I=n1414
XFE_PHC1184_n1432 BUF1CK $PINS O=FE_PHN1184_n1432 I=n1432
XFE_PHC1182_n1424 BUF1CK $PINS O=FE_PHN1182_n1424 I=n1424
XFE_PHC1180_n1418 BUF1CK $PINS O=FE_PHN1180_n1418 I=n1418
XFE_PHC1179_n490 BUF1CK $PINS O=FE_PHN1179_n490 I=n490
XFE_PHC1174_n484 BUF1CK $PINS O=n484 I=FE_PHN1174_n484
XFE_PHC1171_key_counter_1 BUF1S $PINS O=FE_PHN1171_key_counter_1
+ I=key_counter[1]
XFE_PHC1168_x3_w_26 BUF1CK $PINS O=FE_PHN1168_x3_w_26 I=x3_w[26]
XFE_PHC1167_counter_0 BUF1S $PINS O=FE_PHN1167_counter_0 I=counter[0]
XFE_PHC1164_n1430 BUF1CK $PINS O=FE_PHN1164_n1430 I=n1430
XFE_PHC1159_x3_w_16 BUF1CK $PINS O=FE_PHN1159_x3_w_16 I=x3_w[16]
XFE_PHC1156_n311 BUF1CK $PINS O=n311 I=FE_PHN1156_n311
XFE_PHC1154_state_2 BUF1CK $PINS O=FE_PHN1154_state_2 I=state[2]
XFE_PHC1150_n1417 BUF1CK $PINS O=FE_PHN1150_n1417 I=n1417
XFE_PHC1141_n365 BUF1CK $PINS O=FE_PHN1141_n365 I=n365
XFE_PHC1140_n1419 BUF1CK $PINS O=FE_PHN1140_n1419 I=n1419
XFE_PHC1132_key_counter_3 BUF1S $PINS O=FE_PHN1132_key_counter_3
+ I=key_counter[3]
XFE_PHC1130_x3_w_4 BUF1CK $PINS O=FE_PHN1130_x3_w_4 I=x3_w[4]
XFE_PHC1128_n371 BUF1CK $PINS O=n371 I=FE_PHN1128_n371
XFE_PHC1126_n808 BUF4CK $PINS O=FE_PHN1126_n808 I=n808
XFE_PHC1124_n768 BUF4CK $PINS O=FE_PHN1124_n768 I=n768
XFE_PHC1119_n1221 BUF3CK $PINS O=FE_PHN1119_n1221 I=n1221
XFE_PHC1117_state_3 BUF1CK $PINS O=FE_PHN1117_state_3 I=state[3]
XFE_PHC1115_n828 BUF4CK $PINS O=FE_PHN1115_n828 I=n828
XFE_PHC1112_n323 BUF1CK $PINS O=FE_PHN1112_n323 I=n323
XFE_PHC1107_y1_28 BUF1CK $PINS O=FE_PHN1107_y1_28 I=y1[28]
XFE_PHC1105_a_9 DELA $PINS O=FE_PHN1105_a_9 I=a[9]
XFE_PHC1101_y1_24 BUF1CK $PINS O=FE_PHN1101_y1_24 I=y1[24]
XFE_PHC1100_n1332 BUF2CK $PINS O=FE_PHN1100_n1332 I=n1332
XFE_PHC1096_n849 BUF1S $PINS O=FE_PHN1096_n849 I=n849
XFE_PHC1095_n1222 BUF2CK $PINS O=FE_PHN1095_n1222 I=n1222
XFE_PHC1092_n818 BUF1S $PINS O=FE_PHN1092_n818 I=n818
XFE_PHC1090_n1312 BUF2CK $PINS O=FE_PHN1090_n1312 I=n1312
XFE_PHC1088_n1192 BUF1S $PINS O=FE_PHN1088_n1192 I=n1192
XFE_PHC1087_n788 BUF1S $PINS O=FE_PHN1087_n788 I=n788
XFE_PHC1085_a_7 DELA $PINS O=FE_PHN1085_a_7 I=a[7]
XFE_PHC1084_a_2 BUF1S $PINS O=FE_PHN1084_a_2 I=FE_PHN1507_a_2
XFE_PHC1083_n1427 BUF1CK $PINS O=FE_PHN1083_n1427 I=n1427
XFE_PHC1080_a_4 DELA $PINS O=FE_PHN1080_a_4 I=a[4]
XFE_PHC1079_n1421 BUF1CK $PINS O=FE_PHN1079_n1421 I=n1421
XFE_PHC1078_n1212 BUF1S $PINS O=FE_PHN1078_n1212 I=n1212
XFE_PHC1077_n848 BUF1S $PINS O=FE_PHN1077_n848 I=n848
XFE_PHC1075_n1241 BUF1S $PINS O=FE_PHN1075_n1241 I=n1241
XFE_PHC1074_n888 BUF1S $PINS O=FE_PHN1074_n888 I=n888
XFE_PHC1071_n1415 BUF1CK $PINS O=FE_PHN1071_n1415 I=n1415
XFE_PHC1068_a_3 BUF1S $PINS O=FE_PHN1068_a_3 I=a[3]
XFE_PHC1067_y1_10 BUF1S $PINS O=FE_PHN1067_y1_10 I=y1[10]
XFE_PHC1066_y1_30 BUF1S $PINS O=FE_PHN1066_y1_30 I=FE_PHN1574_y1_30
XFE_PHC1065_n1272 BUF4CK $PINS O=FE_PHN1065_n1272 I=n1272
XFE_PHC1064_y1_16 BUF1S $PINS O=FE_PHN1064_y1_16 I=FE_PHN1604_y1_16
XFE_PHC1063_n1431 BUF1CK $PINS O=FE_PHN1063_n1431 I=n1431
XFE_PHC1061_n868 BUF1S $PINS O=FE_PHN1061_n868 I=n868
XFE_PHC1059_y1_21 BUF1S $PINS O=FE_PHN1059_y1_21 I=FE_PHN1585_y1_21
XFE_PHC1058_n1311 BUF2CK $PINS O=FE_PHN1058_n1311 I=n1311
XFE_PHC1054_n269 BUF1CK $PINS O=FE_PHN1054_n269 I=n269
XFE_PHC1052_y1_18 BUF1S $PINS O=FE_PHN1052_y1_18 I=y1[18]
XFE_PHC1051_y1_20 BUF1S $PINS O=FE_PHN1051_y1_20 I=FE_PHN1596_y1_20
XFE_PHC1049_x1_21 BUF1S $PINS O=FE_PHN1049_x1_21 I=FE_PHN1565_x1_21
XFE_PHC1047_n1281 BUF4CK $PINS O=FE_PHN1047_n1281 I=n1281
XFE_PHC1046_a_1 DELA $PINS O=FE_PHN1046_a_1 I=a[1]
XFE_PHC1045_a_6 DELA $PINS O=FE_PHN1045_a_6 I=a[6]
XFE_PHC1042_n1372 DELA $PINS O=FE_PHN1042_n1372 I=n1372
XFE_PHC1041_n1342 DELA $PINS O=FE_PHN1041_n1342 I=n1342
XFE_PHC1039_n1211 DELA $PINS O=FE_PHN1039_n1211 I=n1211
XFE_PHC1037_y1_15 BUF1S $PINS O=FE_PHN1037_y1_15 I=FE_PHN1605_y1_15
XFE_PHC1036_a_8 DELA $PINS O=FE_PHN1036_a_8 I=a[8]
XFE_PHC1034_n389 BUF1CK $PINS O=FE_PHN1034_n389 I=n389
XFE_PHC1033_n1292 BUF4CK $PINS O=FE_PHN1033_n1292 I=n1292
XFE_PHC1031_n1362 DELA $PINS O=FE_PHN1031_n1362 I=n1362
XFE_PHC1026_n769 DELA $PINS O=FE_PHN1026_n769 I=n769
XFE_PHC1025_a_0 DELA $PINS O=FE_PHN1025_a_0 I=a[0]
XFE_PHC1014_n1371 BUF2CK $PINS O=FE_PHN1014_n1371 I=n1371
XFE_PHC1012_n1425 BUF1CK $PINS O=FE_PHN1012_n1425 I=n1425
XFE_PHC1011_n1322 DELA $PINS O=FE_PHN1011_n1322 I=n1322
XFE_PHC1006_n1352 DELA $PINS O=FE_PHN1006_n1352 I=n1352
XFE_PHC1000_n1232 DELA $PINS O=FE_PHN1000_n1232 I=n1232
XFE_PHC996_n1386 BUF3CK $PINS O=FE_PHN996_n1386 I=n1386
XFE_PHC993_n819 DELA $PINS O=FE_PHN993_n819 I=n819
XFE_PHC991_n1282 DELA $PINS O=FE_PHN991_n1282 I=n1282
XFE_PHC989_n799 DELA $PINS O=FE_PHN989_n799 I=n799
XFE_PHC986_n1423 BUF1CK $PINS O=FE_PHN986_n1423 I=n1423
XFE_PHC985_n859 DELA $PINS O=FE_PHN985_n859 I=n859
XFE_PHC983_n1242 DELA $PINS O=FE_PHN983_n1242 I=n1242
XFE_PHC982_n779 DELA $PINS O=FE_PHN982_n779 I=n779
XFE_PHC981_n1202 DELA $PINS O=FE_PHN981_n1202 I=n1202
XFE_PHC980_n1262 DELA $PINS O=FE_PHN980_n1262 I=n1262
XFE_PHC979_n1252 DELA $PINS O=FE_PHN979_n1252 I=n1252
XFE_PHC978_n1302 DELA $PINS O=FE_PHN978_n1302 I=n1302
XFE_PHC977_n789 DELA $PINS O=FE_PHN977_n789 I=n789
XFE_PHC976_n829 DELA $PINS O=FE_PHN976_n829 I=n829
XFE_PHC975_n9 BUF1CK $PINS O=FE_PHN975_n9 I=n9
XFE_PHC974_n251 BUF2CK $PINS O=FE_PHN974_n251 I=n251
XFE_PHC969_n879 DELA $PINS O=FE_PHN969_n879 I=n879
XFE_PHC968_n1301 BUF3 $PINS O=FE_PHN968_n1301 I=n1301
XFE_PHC967_n1291 BUF1CK $PINS O=FE_PHN967_n1291 I=n1291
XFE_PHC966_n809 DELA $PINS O=FE_PHN966_n809 I=n809
XFE_PHC965_n869 DELA $PINS O=FE_PHN965_n869 I=n869
XFE_PHC963_n839 DELA $PINS O=FE_PHN963_n839 I=n839
XFE_PHC949_n1385 BUF1CK $PINS O=FE_PHN949_n1385 I=n1385
XFE_PHC945_a_5 BUF2CK $PINS O=FE_PHN945_a_5 I=a[5]
XFE_PHC928_n1321 BUF1CK $PINS O=FE_PHN928_n1321 I=n1321
XFE_PHC923_state_0 BUF2CK $PINS O=FE_PHN923_state_0 I=state[0]
XFE_PHC901_y1_22 BUF1CK $PINS O=FE_PHN901_y1_22 I=y1[22]
XFE_PHC882_n1361 BUF1CK $PINS O=FE_PHN882_n1361 I=n1361
XFE_PHC873_n1351 BUF1CK $PINS O=FE_PHN873_n1351 I=n1351
XFE_PHC866_n1271 BUF1CK $PINS O=FE_PHN866_n1271 I=n1271
XFE_PHC862_n798 BUF2CK $PINS O=FE_PHN862_n798 I=n798
XFE_PHC856_n1201 BUF2CK $PINS O=FE_PHN856_n1201 I=n1201
XFE_PHC836_n1429 BUF1CK $PINS O=FE_PHN836_n1429 I=n1429
XFE_PHC829_n1251 BUF2CK $PINS O=FE_PHN829_n1251 I=n1251
XFE_PHC820_n1331 BUF1CK $PINS O=FE_PHN820_n1331 I=n1331
XFE_PHC814_n858 BUF2CK $PINS O=FE_PHN814_n858 I=n858
XFE_PHC805_n1341 BUF1CK $PINS O=FE_PHN805_n1341 I=n1341
XFE_PHC803_n185 BUF1CK $PINS O=FE_PHN803_n185 I=n185
XFE_PHC800_n878 BUF2CK $PINS O=FE_PHN800_n878 I=n878
XFE_PHC781_n1261 BUF1CK $PINS O=FE_PHN781_n1261 I=n1261
XFE_PHC779_y1_29 BUF1S $PINS O=FE_PHN779_y1_29 I=y1[29]
XFE_PHC772_y1_13 BUF1S $PINS O=FE_PHN772_y1_13 I=y1[13]
XFE_PHC769_y1_27 BUF1CK $PINS O=FE_PHN769_y1_27 I=y1[27]
XFE_PHC766_n778 BUF1CK $PINS O=FE_PHN766_n778 I=n778
XFE_PHC760_n838 BUF1S $PINS O=FE_PHN760_n838 I=n838
XFE_PHC757_y1_2 BUF1S $PINS O=FE_PHN757_y1_2 I=y1[2]
XFE_PHC755_x1_15 BUF1S $PINS O=FE_PHN755_x1_15 I=x1[15]
XFE_PHC753_n1231 BUF1CK $PINS O=FE_PHN753_n1231 I=n1231
XFE_PHC750_y1_8 BUF1S $PINS O=FE_PHN750_y1_8 I=y1[8]
XFE_PHC749_y1_25 BUF1S $PINS O=FE_PHN749_y1_25 I=y1[25]
XFE_PHC748_y1_14 BUF1S $PINS O=FE_PHN748_y1_14 I=y1[14]
XFE_PHC746_y1_11 BUF1S $PINS O=FE_PHN746_y1_11 I=y1[11]
XFE_PHC745_y1_12 BUF1S $PINS O=FE_PHN745_y1_12 I=y1[12]
XFE_OCPC662_FE_OFN87_n312 BUF1 $PINS O=FE_OCPN666_FE_OFN87_n312 I=FE_OFN87_n312
XCTS_ccl_a_INV_i_clk_G0_L7_18 INV12CK $PINS O=CTS_57 I=i_clk_clone2
XCTS_ccl_a_INV_i_clk_G0_L7_12 INV12CK $PINS O=CTS_55 I=CTS_56
XCTS_ccl_a_INV_i_clk_G0_L7_11 INV12CK $PINS O=CTS_54 I=CTS_56
XCTS_ccl_a_INV_i_clk_G0_L7_10 INV12CK $PINS O=CTS_53 I=CTS_56
XCTS_ccl_a_INV_i_clk_G0_L6_5 INV12CK $PINS O=CTS_56 I=i_clk_clone6
XCTS_ccl_a_INV_i_clk_G0_L7_7 INV12CK $PINS O=CTS_51 I=CTS_52
XCTS_ccl_a_INV_i_clk_G0_L7_6 INV12CK $PINS O=CTS_50 I=CTS_52
XCTS_ccl_a_INV_i_clk_G0_L6_3 INV8CK $PINS O=CTS_52 I=i_clk_clone8
XCTS_ccl_a_INV_i_clk_G0_L7_5 INV12CK $PINS O=CTS_48 I=CTS_49
XCTS_ccl_a_INV_i_clk_G0_L7_4 INV12CK $PINS O=CTS_47 I=CTS_49
XCTS_ccl_a_INV_i_clk_G0_L6_2 INV8CK $PINS O=CTS_49 I=i_clk_clone8
XCTS_ccl_a_INV_i_clk_G0_L7_1 INV12CK $PINS O=CTS_46 I=i_clk_clone11
XFE_OCPC654_FE_OFN345_FE_OFN325_n310 BUF1 $PINS
+ O=FE_OCPN659_FE_OFN345_FE_OFN325_n310 I=FE_OFN345_FE_OFN325_n310
XFE_OFC646_raw_prime_2 BUF4CK $PINS O=FE_OFN657_raw_prime_2 I=raw_prime[2]
XFE_OFC642_n31 BUF1 $PINS O=FE_OFN348_FE_OFN118_n31 I=FE_OFN118_n31
XFE_OFC641_n31 BUF2 $PINS O=FE_OFN118_n31 I=n31
XFE_OFC636_n1384 BUF4 $PINS O=FE_OFN653_n1384 I=n1384
XFE_OFC634_n748 BUF2 $PINS O=FE_OFN623_n748 I=n748
XFE_OFC625_n750 BUF2 $PINS O=FE_OFN349_FE_OFN116_n572 I=n750
XFE_OFC617_n310 BUF6 $PINS O=FE_OFN345_FE_OFN325_n310 I=raw_prime[0]
XFE_OFC615_n568 BUF2 $PINS O=FE_OFN346_FE_OFN322_n749 I=n749
XFE_OFC614_n568 BUF1 $PINS O=FE_OFN322_n749 I=n749
XFE_OFC613_n568 INV3CK $PINS O=n749 I=n568
XFE_OFC589_n745 BUF1 $PINS O=FE_OFN622_n745 I=n745
XFE_OFC588_n743 BUF1 $PINS O=FE_OFN621_n743 I=n743
XFE_OFC587_n498 BUF1 $PINS O=FE_OFN620_n498 I=n498
XFE_OFC586_n396 BUF1 $PINS O=FE_OFN619_n396 I=n396
XFE_OFC568_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN601_n I=FE_OFN334_n
XFE_OFC566_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN599_n I=FE_OFN334_n
XFE_OFC564_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN597_n I=FE_OFN595_n
XFE_OFC562_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN595_n
+ I=FE_OFN25_FE_DBTN1_i_i_rst
XFE_OFC561_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN594_n I=FE_OFN592_n
XFE_OFC560_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN593_n I=FE_OFN592_n
XFE_OFC559_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN592_n I=FE_OFN591_n
XFE_OFC558_FE_DBTN1_i_i_rst BUF1 $PINS O=FE_OFN591_n
+ I=FE_OFN26_FE_DBTN1_i_i_rst
XFE_OFC557_FE_DBTN1_i_i_rst BUF1 $PINS O=FE_OFN590_n I=FE_OFN588_n
XFE_OFC556_FE_DBTN1_i_i_rst BUF1 $PINS O=FE_OFN589_n
+ I=FE_OFN28_FE_DBTN1_i_i_rst
XFE_OFC555_FE_DBTN1_i_i_rst BUF1 $PINS O=FE_OFN588_n
+ I=FE_OFN28_FE_DBTN1_i_i_rst
XFE_OFC488_n1408 INV1S $PINS O=FE_OFN521_n1408 I=FE_OFN518_n1408
XFE_OFC487_n1408 INV1S $PINS O=FE_OFN520_n1408 I=FE_OFN518_n1408
XFE_OFC486_n1408 BUF1 $PINS O=FE_OFN519_n1408 I=n1408
XFE_OFC485_n1408 INV1S $PINS O=FE_OFN518_n1408 I=n1408
XFE_OFC483_n1380 BUF1 $PINS O=FE_OFN516_n1380 I=FE_OFN515_n1380
XFE_OFC482_n1380 BUF1 $PINS O=FE_OFN515_n1380 I=n1380
XFE_OFC481_n1380 BUF1 $PINS O=FE_OFN514_n1380 I=n1380
XFE_OFC480_n762 BUF1 $PINS O=FE_OFN513_n762 I=n762
XFE_OFC479_n742 BUF1 $PINS O=FE_OFN512_n742 I=n742
XFE_OFC478_n504 INV1S $PINS O=FE_OFN511_n504 I=FE_OFN509_n504
XFE_OFC477_n504 INV1S $PINS O=FE_OFN510_n504 I=FE_OFN509_n504
XFE_OFC476_n504 INV1S $PINS O=FE_OFN509_n504 I=n504
XFE_OFC475_n504 BUF1 $PINS O=FE_OFN508_n504 I=n504
XFE_OFC474_n500 INV1S $PINS O=FE_OFN507_n500 I=FE_OFN505_n500
XFE_OFC473_n500 INV1S $PINS O=FE_OFN506_n500 I=FE_OFN505_n500
XFE_OFC472_n500 INV1S $PINS O=FE_OFN505_n500 I=FE_OFN504_n500
XFE_OFC471_n500 BUF1 $PINS O=FE_OFN504_n500 I=n500
XFE_OFC470_n41 BUF1 $PINS O=FE_OFN503_n41 I=n41
XFE_OFC469_n30 BUF1 $PINS O=FE_OFN502_n30 I=n30
XFE_OFC468_n28 BUF1 $PINS O=FE_OFN501_n28 I=n28
XFE_OFC467_n26 BUF1 $PINS O=FE_OFN500_n26 I=n26
XFE_OFC466_n24 BUF1 $PINS O=FE_OFN499_n24 I=n24
XFE_OFC465_n16 BUF2CK $PINS O=FE_OFN498_n16 I=n16
XFE_OFC464_n12 BUF1 $PINS O=FE_OFN497_n12 I=n12
XFE_OFC463_raw_prime_14 BUF1 $PINS O=FE_OFN496_raw_prime_14 I=raw_prime[14]
XFE_OFC462_raw_prime_15 BUF1 $PINS O=FE_OFN495_raw_prime_15 I=raw_prime[15]
XFE_OFC453_FE_DBTN71_n2 BUF1 $PINS O=FE_OFN486_FE_DBTN71_n2
+ I=FE_OFN485_FE_DBTN71_n2
XFE_OFC452_FE_DBTN71_n2 BUF1 $PINS O=FE_OFN485_FE_DBTN71_n2 I=FE_DBTN71_n2
XFE_OFC451_FE_DBTN71_n2 BUF1 $PINS O=FE_OFN484_FE_DBTN71_n2 I=FE_DBTN71_n2
XFE_OFC433_FE_OFN6_FE_DBTN1_i_i_rst BUF1 $PINS
+ O=FE_OFN466_FE_OFN6_FE_DBTN1_i_i_rst I=FE_OFN16_FE_DBTN1_i_i_rst
XFE_OFC432_FE_OFN7_FE_DBTN1_i_i_rst BUF1 $PINS
+ O=FE_OFN465_FE_OFN7_FE_DBTN1_i_i_rst I=FE_OFN19_FE_DBTN1_i_i_rst
XFE_OFC430_FE_OFN8_FE_DBTN1_i_i_rst BUF1 $PINS
+ O=FE_OFN463_FE_OFN8_FE_DBTN1_i_i_rst I=FE_OFN462_FE_OFN8_FE_DBTN1_i_i_rst
XFE_OFC429_FE_OFN8_FE_DBTN1_i_i_rst BUF1 $PINS
+ O=FE_OFN462_FE_OFN8_FE_DBTN1_i_i_rst I=FE_OFN8_FE_DBTN1_i_i_rst
XFE_OFC428_FE_OFN8_FE_DBTN1_i_i_rst BUF1 $PINS
+ O=FE_OFN461_FE_OFN8_FE_DBTN1_i_i_rst I=FE_OFN8_FE_DBTN1_i_i_rst
XFE_OFC427_FE_OFN9_FE_DBTN1_i_i_rst BUF1 $PINS
+ O=FE_OFN460_FE_OFN9_FE_DBTN1_i_i_rst I=FE_OFN9_FE_DBTN1_i_i_rst
XFE_OFC426_FE_OFN9_FE_DBTN1_i_i_rst BUF1 $PINS
+ O=FE_OFN459_FE_OFN9_FE_DBTN1_i_i_rst I=FE_OFN9_FE_DBTN1_i_i_rst
XFE_OFC425_FE_OFN10_FE_DBTN1_i_i_rst BUF1 $PINS
+ O=FE_OFN458_FE_OFN10_FE_DBTN1_i_i_rst I=FE_OFN456_FE_OFN10_FE_DBTN1_i_i_rst
XFE_OFC424_FE_OFN10_FE_DBTN1_i_i_rst BUF1 $PINS
+ O=FE_OFN457_FE_OFN10_FE_DBTN1_i_i_rst I=FE_OFN456_FE_OFN10_FE_DBTN1_i_i_rst
XFE_OFC423_FE_OFN10_FE_DBTN1_i_i_rst BUF1 $PINS
+ O=FE_OFN456_FE_OFN10_FE_DBTN1_i_i_rst I=FE_OFN10_FE_DBTN1_i_i_rst
XFE_OFC422_FE_OFN11_FE_DBTN1_i_i_rst BUF1 $PINS
+ O=FE_OFN455_FE_OFN11_FE_DBTN1_i_i_rst I=FE_OFN453_FE_OFN11_FE_DBTN1_i_i_rst
XFE_OFC421_FE_OFN11_FE_DBTN1_i_i_rst BUF1 $PINS
+ O=FE_OFN454_FE_OFN11_FE_DBTN1_i_i_rst I=FE_OFN11_FE_DBTN1_i_i_rst
XFE_OFC420_FE_OFN11_FE_DBTN1_i_i_rst BUF1 $PINS
+ O=FE_OFN453_FE_OFN11_FE_DBTN1_i_i_rst I=FE_OFN11_FE_DBTN1_i_i_rst
XFE_OFC419_FE_OFN13_FE_DBTN1_i_i_rst BUF1 $PINS
+ O=FE_OFN452_FE_OFN13_FE_DBTN1_i_i_rst I=FE_OFN13_FE_DBTN1_i_i_rst
XFE_OFC418_FE_OFN13_FE_DBTN1_i_i_rst BUF1 $PINS
+ O=FE_OFN451_FE_OFN13_FE_DBTN1_i_i_rst I=FE_OFN13_FE_DBTN1_i_i_rst
XFE_OFC416_FE_OFN14_FE_DBTN1_i_i_rst BUF1 $PINS
+ O=FE_OFN449_FE_OFN14_FE_DBTN1_i_i_rst I=FE_OFN14_FE_DBTN1_i_i_rst
XFE_OFC415_FE_OFN14_FE_DBTN1_i_i_rst BUF1 $PINS
+ O=FE_OFN448_FE_OFN14_FE_DBTN1_i_i_rst I=FE_OFN14_FE_DBTN1_i_i_rst
XFE_OFC370_FE_OFN50_raw_prime_12 BUF1 $PINS O=FE_OFN403_FE_OFN50_raw_prime_12
+ I=FE_OFN112_raw_prime_12
XFE_OFC364_FE_OFN52_raw_prime_10 BUF1 $PINS O=FE_OFN397_FE_OFN52_raw_prime_10
+ I=raw_prime[10]
XFE_OFC359_FE_OFN56_raw_prime_6 BUF1 $PINS O=FE_OFN392_FE_OFN56_raw_prime_6
+ I=FE_OFN126_raw_prime_6
XFE_OFC355_FE_OFN61_n496 BUF1 $PINS O=FE_OFN388_FE_OFN61_n496 I=FE_OFN61_n496
XFE_OFC354_FE_OFN62_n1379 BUF1 $PINS O=FE_OFN387_FE_OFN62_n1379
+ I=FE_OFN386_FE_OFN62_n1379
XFE_OFC353_FE_OFN62_n1379 BUF1 $PINS O=FE_OFN386_FE_OFN62_n1379 I=n1379
XFE_OFC352_FE_OFN62_n1379 BUF1 $PINS O=FE_OFN385_FE_OFN62_n1379 I=n1379
XFE_OFC351_FE_OFN63_n1382 BUF1 $PINS O=FE_OFN384_FE_OFN63_n1382
+ I=FE_OFN383_FE_OFN63_n1382
XFE_OFC350_FE_OFN63_n1382 INV1S $PINS O=FE_OFN383_FE_OFN63_n1382
+ I=FE_OFN381_FE_OFN63_n1382
XFE_OFC349_FE_OFN63_n1382 INV1S $PINS O=FE_OFN382_FE_OFN63_n1382
+ I=FE_OFN381_FE_OFN63_n1382
XFE_OFC348_FE_OFN63_n1382 INV1S $PINS O=FE_OFN381_FE_OFN63_n1382
+ I=FE_OFN63_n1382
XFE_OFC329_FE_OFN81_n501 BUF1 $PINS O=FE_OFN362_FE_OFN81_n501
+ I=FE_OFN361_FE_OFN81_n501
XFE_OFC328_FE_OFN81_n501 BUF1 $PINS O=FE_OFN361_FE_OFN81_n501 I=FE_OFN81_n501
XFE_OFC327_FE_OFN85_raw_prime_4 BUF2CK $PINS O=FE_OFN360_FE_OFN85_raw_prime_4
+ I=FE_OFN85_raw_prime_4
XFE_OFC324_FE_OFN89_raw_prime_8 BUF1 $PINS O=FE_OFN357_FE_OFN89_raw_prime_8
+ I=FE_OFN89_raw_prime_8
XFE_OFC322_FE_OFN94_n560 BUF1 $PINS O=FE_OFN355_FE_OFN94_n560
+ I=FE_OFN354_FE_OFN94_n560
XFE_OFC321_FE_OFN94_n560 BUF1 $PINS O=FE_OFN354_FE_OFN94_n560 I=FE_OFN94_n560
XFE_OFC320_FE_OFN94_n560 BUF1 $PINS O=FE_OFN353_FE_OFN94_n560 I=FE_OFN94_n560
XFE_OFC319_FE_OFN95_raw_prime_7 BUF2CK $PINS O=FE_OFN352_FE_OFN95_raw_prime_7
+ I=FE_OFN95_raw_prime_7
XFE_OFC317_FE_OFN101_raw_prime_5 BUF2CK $PINS O=FE_OFN350_FE_OFN101_raw_prime_5
+ I=FE_OFN153_raw_prime_5
XFE_OFC314_FE_OFN316_n21 BUF2CK $PINS O=FE_OFN347_FE_OFN316_n21 I=FE_OFN316_n21
XFE_OCPC361_n310 BUF2 $PINS O=FE_OCPN361_n310 I=raw_prime[0]
XFE_RC_2267_0 ND3P $PINS O=n568 I1=n566 I2=n2 I3=n536
XFE_OFC296_x3_w_0 INV1S $PINS O=FE_OFN333_x3_w_0 I=FE_PHN1339_x3_w_0
XFE_OFC258_n21 BUF2 $PINS O=FE_OFN316_n21 I=n21
XFE_OFC251_n572 INV1S $PINS O=n750 I=n572
XFE_OFC245_n8 INV2 $PINS O=n299 I=n8
XFE_OFC242_n192 INV1S $PINS O=n201 I=n192
XFE_OFC202_raw_prime_9 INV2 $PINS O=FE_OFN98_raw_prime_9 I=FE_OFN97_raw_prime_9
XFE_OFC194_raw_prime_9 INV1S $PINS O=FE_OFN97_raw_prime_9
+ I=FE_OFN122_raw_prime_9
XFE_OFC159_raw_prime_7 BUF1 $PINS O=FE_OFN95_raw_prime_7
+ I=FE_OFN124_raw_prime_7
XFE_OFC157_n560 BUF1 $PINS O=FE_OFN94_n560 I=n499
XFE_OFC156_n560 INV1S $PINS O=n499 I=n560
XFE_OFC119_raw_prime_8 INV1S $PINS O=FE_OFN89_raw_prime_8 I=raw_prime[8]
XFE_OFC103_n312 BUF8 $PINS O=FE_OFN87_n312 I=raw_prime[1]
XFE_OFC87_raw_prime_4 BUF1 $PINS O=FE_OFN85_raw_prime_4 I=raw_prime[4]
XFE_OFC79_n501 BUF1CK $PINS O=FE_OFN81_n501 I=n501
XFE_OFC61_n1382 BUF1CK $PINS O=FE_OFN63_n1382 I=n1382
XFE_OFC59_n496 BUF1CK $PINS O=FE_OFN61_n496 I=n496
XFE_OFC26_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN28_FE_DBTN1_i_i_rst
+ I=FE_OFN20_FE_DBTN1_i_i_rst
XFE_OFC24_FE_DBTN1_i_i_rst INV2 $PINS O=FE_OFN26_FE_DBTN1_i_i_rst
+ I=FE_OFN18_FE_DBTN1_i_i_rst
XFE_OFC23_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN25_FE_DBTN1_i_i_rst
+ I=FE_OFN18_FE_DBTN1_i_i_rst
XFE_OFC18_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN20_FE_DBTN1_i_i_rst
+ I=FE_OFN10_FE_DBTN1_i_i_rst
XFE_OFC17_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN18_FE_DBTN1_i_i_rst
+ I=FE_OFN10_FE_DBTN1_i_i_rst
XFE_OFC14_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN15_FE_DBTN1_i_i_rst I=i_rst
XFE_OFC13_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN14_FE_DBTN1_i_i_rst I=i_rst
XFE_OFC12_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN13_FE_DBTN1_i_i_rst I=i_rst
XFE_OFC11_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN11_FE_DBTN1_i_i_rst I=i_rst
XFE_OFC10_FE_DBTN1_i_i_rst INV2 $PINS O=FE_OFN10_FE_DBTN1_i_i_rst I=i_rst
XFE_OFC9_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN9_FE_DBTN1_i_i_rst I=i_rst
XFE_OFC8_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN8_FE_DBTN1_i_i_rst I=i_rst
XFE_DBTC72_mode INV1S $PINS O=FE_DBTN72_mode I=mode
XFE_DBTC71_n2 INV1S $PINS O=FE_DBTN71_n2 I=n2
XFE_DBTC70_x3_w_31 INV1S $PINS O=FE_DBTN70_x3_w_31 I=x3_w[31]
XFE_DBTC69_x3_w_29 INV1S $PINS O=FE_DBTN69_x3_w_29 I=x3_w[29]
XFE_DBTC68_x3_w_27 INV1S $PINS O=FE_DBTN68_x3_w_27 I=x3_w[27]
XFE_DBTC67_x3_w_25 INV1S $PINS O=FE_DBTN67_x3_w_25 I=x3_w[25]
XFE_DBTC66_x3_w_23 INV1S $PINS O=FE_DBTN66_x3_w_23 I=x3_w[23]
XFE_DBTC65_x3_w_21 INV1S $PINS O=FE_DBTN65_x3_w_21 I=x3_w[21]
XFE_DBTC64_x3_w_19 INV1S $PINS O=FE_DBTN64_x3_w_19 I=x3_w[19]
XFE_DBTC63_x3_w_17 INV1S $PINS O=FE_DBTN63_x3_w_17 I=x3_w[17]
XFE_DBTC62_x3_w_15 INV1S $PINS O=FE_DBTN62_x3_w_15 I=x3_w[15]
XFE_DBTC61_x3_w_13 INV1S $PINS O=FE_DBTN61_x3_w_13 I=x3_w[13]
XFE_DBTC60_x3_w_11 INV1S $PINS O=FE_DBTN60_x3_w_11 I=x3_w[11]
XFE_DBTC59_x3_w_9 INV1S $PINS O=FE_DBTN59_x3_w_9 I=x3_w[9]
XFE_DBTC58_x3_w_7 INV1S $PINS O=FE_DBTN58_x3_w_7 I=x3_w[7]
XFE_DBTC57_x3_w_6 INV1S $PINS O=FE_DBTN57_x3_w_6 I=FE_PHN1337_x3_w_6
XFE_DBTC56_x3_w_5 INV1S $PINS O=FE_DBTN56_x3_w_5 I=x3_w[5]
XFE_DBTC55_x3_w_3 INV1S $PINS O=FE_DBTN55_x3_w_3 I=x3_w[3]
XFE_DBTC54_x3_w_1 INV1S $PINS O=FE_DBTN54_x3_w_1 I=x3_w[1]
XFE_DBTC52_y3_w_31 INV1S $PINS O=FE_DBTN52_y3_w_31 I=y3_w[31]
XFE_DBTC51_y3_w_29 INV1S $PINS O=FE_DBTN51_y3_w_29 I=y3_w[29]
XFE_DBTC50_y3_w_27 INV1S $PINS O=FE_DBTN50_y3_w_27 I=y3_w[27]
XFE_DBTC49_y3_w_25 INV1S $PINS O=FE_DBTN49_y3_w_25 I=y3_w[25]
XFE_DBTC48_y3_w_23 INV1S $PINS O=FE_DBTN48_y3_w_23 I=y3_w[23]
XFE_DBTC47_y3_w_21 INV1S $PINS O=FE_DBTN47_y3_w_21 I=y3_w[21]
XFE_DBTC46_y3_w_19 INV1S $PINS O=FE_DBTN46_y3_w_19 I=y3_w[19]
XFE_DBTC45_y3_w_17 INV1S $PINS O=FE_DBTN45_y3_w_17 I=y3_w[17]
XFE_DBTC44_y3_w_15 INV1S $PINS O=FE_DBTN44_y3_w_15 I=y3_w[15]
XFE_DBTC43_y3_w_13 INV1S $PINS O=FE_DBTN43_y3_w_13 I=y3_w[13]
XFE_DBTC42_y3_w_11 INV1S $PINS O=FE_DBTN42_y3_w_11 I=y3_w[11]
XFE_DBTC41_y3_w_9 INV1S $PINS O=FE_DBTN41_y3_w_9 I=y3_w[9]
XFE_DBTC40_y3_w_7 INV1S $PINS O=FE_DBTN40_y3_w_7 I=y3_w[7]
XFE_DBTC39_y3_w_6 INV1S $PINS O=FE_DBTN39_y3_w_6 I=y3_w[6]
XFE_DBTC38_y3_w_5 INV1S $PINS O=FE_DBTN38_y3_w_5 I=y3_w[5]
XFE_DBTC37_y3_w_3 INV1S $PINS O=FE_DBTN37_y3_w_3 I=FE_PHN1300_y3_w_3
XFE_DBTC36_y3_w_1 INV1S $PINS O=FE_DBTN36_y3_w_1 I=y3_w[1]
XFE_DBTC35_y3_w_0 INV1S $PINS O=FE_DBTN35_y3_w_0 I=y3_w[0]
XU1037 ND2 $PINS O=n575 I1=counter[2] I2=n576
XU1038 AN2B1S $PINS O=n576 I1=counter[1] B1=n577
XU1066 OR2B1S $PINS O=n674 I1=counter[3] B1=n673
XU1277 ND2 $PINS O=n631 I1=n1411 I2=n1412
Xd0 Domain_Transfer_1 $PINS reset=FE_OFN6_FE_DBTN1_i_i_rst ToMont=*Logic1*
+ in_sig=in_sig_w Px_i[31]=raw1[31] Px_i[30]=raw1[30] Px_i[29]=raw1[29]
+ Px_i[28]=raw1[28] Px_i[27]=raw1[27] Px_i[26]=raw1[26] Px_i[25]=raw1[25]
+ Px_i[24]=raw1[24] Px_i[23]=raw1[23] Px_i[22]=raw1[22] Px_i[21]=raw1[21]
+ Px_i[20]=raw1[20] Px_i[19]=raw1[19] Px_i[18]=raw1[18] Px_i[17]=raw1[17]
+ Px_i[16]=raw1[16] Px_i[15]=raw1[15] Px_i[14]=raw1[14] Px_i[13]=raw1[13]
+ Px_i[12]=raw1[12] Px_i[11]=raw1[11] Px_i[10]=raw1[10] Px_i[9]=raw1[9]
+ Px_i[8]=raw1[8] Px_i[7]=raw1[7] Px_i[6]=raw1[6] Px_i[5]=raw1[5] Px_i[4]=raw1[4]
+ Px_i[3]=raw1[3] Px_i[2]=raw1[2] Px_i[1]=raw1[1] Px_i[0]=raw1[0]
+ Py_i[31]=raw2[31] Py_i[30]=raw2[30] Py_i[29]=raw2[29] Py_i[28]=raw2[28]
+ Py_i[27]=raw2[27] Py_i[26]=raw2[26] Py_i[25]=raw2[25] Py_i[24]=raw2[24]
+ Py_i[23]=raw2[23] Py_i[22]=raw2[22] Py_i[21]=raw2[21] Py_i[20]=raw2[20]
+ Py_i[19]=raw2[19] Py_i[18]=raw2[18] Py_i[17]=raw2[17] Py_i[16]=raw2[16]
+ Py_i[15]=raw2[15] Py_i[14]=raw2[14] Py_i[13]=raw2[13] Py_i[12]=raw2[12]
+ Py_i[11]=raw2[11] Py_i[10]=raw2[10] Py_i[9]=raw2[9] Py_i[8]=raw2[8]
+ Py_i[7]=raw2[7] Py_i[6]=raw2[6] Py_i[5]=raw2[5] Py_i[4]=raw2[4] Py_i[3]=raw2[3]
+ Py_i[2]=raw2[2] Py_i[1]=raw2[1] Py_i[0]=raw2[0] A_i[31]=raw_a[31]
+ A_i[30]=raw_a[30] A_i[29]=raw_a[29] A_i[28]=raw_a[28] A_i[27]=raw_a[27]
+ A_i[26]=raw_a[26] A_i[25]=raw_a[25] A_i[24]=raw_a[24] A_i[23]=raw_a[23]
+ A_i[22]=raw_a[22] A_i[21]=raw_a[21] A_i[20]=raw_a[20] A_i[19]=raw_a[19]
+ A_i[18]=raw_a[18] A_i[17]=raw_a[17] A_i[16]=raw_a[16] A_i[15]=raw_a[15]
+ A_i[14]=raw_a[14] A_i[13]=raw_a[13] A_i[12]=raw_a[12] A_i[11]=raw_a[11]
+ A_i[10]=raw_a[10] A_i[9]=raw_a[9] A_i[8]=raw_a[8] A_i[7]=raw_a[7]
+ A_i[6]=raw_a[6] A_i[5]=raw_a[5] A_i[4]=raw_a[4] A_i[3]=raw_a[3] A_i[2]=raw_a[2]
+ A_i[1]=raw_a[1] A_i[0]=raw_a[0] Prime[31]=raw_prime[31] Prime[30]=raw_prime[30]
+ Prime[29]=raw_prime[29] Prime[28]=raw_prime[28] Prime[27]=raw_prime[27]
+ Prime[26]=raw_prime[26] Prime[25]=raw_prime[25] Prime[24]=raw_prime[24]
+ Prime[23]=raw_prime[23] Prime[22]=raw_prime[22] Prime[21]=raw_prime[21]
+ Prime[20]=raw_prime[20] Prime[19]=raw_prime[19] Prime[18]=raw_prime[18]
+ Prime[17]=raw_prime[17] Prime[16]=raw_prime[16] Prime[15]=raw_prime[15]
+ Prime[14]=raw_prime[14] Prime[13]=raw_prime[13] Prime[12]=raw_prime[12]
+ Prime[11]=raw_prime[11] Prime[10]=raw_prime[10] Prime[9]=raw_prime[9]
+ Prime[8]=raw_prime[8] Prime[7]=FE_OFN95_raw_prime_7 Prime[6]=raw_prime[6]
+ Prime[5]=raw_prime[5] Prime[4]=FE_OFN85_raw_prime_4 Prime[3]=raw_prime[3]
+ Prime[2]=FE_OFN93_raw_prime_2 Prime[1]=FE_OFN87_n312 Prime[0]=FE_OCPN361_n310
+ Px_out[31]=i1_w[31] Px_out[30]=i1_w[30] Px_out[29]=i1_w[29] Px_out[28]=i1_w[28]
+ Px_out[27]=i1_w[27] Px_out[26]=i1_w[26] Px_out[25]=i1_w[25] Px_out[24]=i1_w[24]
+ Px_out[23]=i1_w[23] Px_out[22]=i1_w[22] Px_out[21]=i1_w[21] Px_out[20]=i1_w[20]
+ Px_out[19]=i1_w[19] Px_out[18]=i1_w[18] Px_out[17]=i1_w[17] Px_out[16]=i1_w[16]
+ Px_out[15]=i1_w[15] Px_out[14]=i1_w[14] Px_out[13]=i1_w[13] Px_out[12]=i1_w[12]
+ Px_out[11]=i1_w[11] Px_out[10]=i1_w[10] Px_out[9]=i1_w[9] Px_out[8]=i1_w[8]
+ Px_out[7]=i1_w[7] Px_out[6]=i1_w[6] Px_out[5]=i1_w[5] Px_out[4]=i1_w[4]
+ Px_out[3]=i1_w[3] Px_out[2]=i1_w[2] Px_out[1]=i1_w[1] Px_out[0]=i1_w[0]
+ Py_out[31]=i2_w[31] Py_out[30]=i2_w[30] Py_out[29]=i2_w[29] Py_out[28]=i2_w[28]
+ Py_out[27]=i2_w[27] Py_out[26]=i2_w[26] Py_out[25]=i2_w[25] Py_out[24]=i2_w[24]
+ Py_out[23]=i2_w[23] Py_out[22]=i2_w[22] Py_out[21]=i2_w[21] Py_out[20]=i2_w[20]
+ Py_out[19]=i2_w[19] Py_out[18]=i2_w[18] Py_out[17]=i2_w[17] Py_out[16]=i2_w[16]
+ Py_out[15]=i2_w[15] Py_out[14]=i2_w[14] Py_out[13]=i2_w[13] Py_out[12]=i2_w[12]
+ Py_out[11]=i2_w[11] Py_out[10]=i2_w[10] Py_out[9]=i2_w[9] Py_out[8]=i2_w[8]
+ Py_out[7]=i2_w[7] Py_out[6]=i2_w[6] Py_out[5]=i2_w[5] Py_out[4]=i2_w[4]
+ Py_out[3]=i2_w[3] Py_out[2]=i2_w[2] Py_out[1]=i2_w[1] Py_out[0]=i2_w[0]
+ A_out[31]=transferred_a_w0[31] A_out[30]=transferred_a_w0[30]
+ A_out[29]=transferred_a_w0[29] A_out[28]=transferred_a_w0[28]
+ A_out[27]=transferred_a_w0[27] A_out[26]=transferred_a_w0[26]
+ A_out[25]=transferred_a_w0[25] A_out[24]=transferred_a_w0[24]
+ A_out[23]=transferred_a_w0[23] A_out[22]=transferred_a_w0[22]
+ A_out[21]=transferred_a_w0[21] A_out[20]=transferred_a_w0[20]
+ A_out[19]=transferred_a_w0[19] A_out[18]=transferred_a_w0[18]
+ A_out[17]=transferred_a_w0[17] A_out[16]=transferred_a_w0[16]
+ A_out[15]=transferred_a_w0[15] A_out[14]=transferred_a_w0[14]
+ A_out[13]=transferred_a_w0[13] A_out[12]=transferred_a_w0[12]
+ A_out[11]=transferred_a_w0[11] A_out[10]=transferred_a_w0[10]
+ A_out[9]=transferred_a_w0[9] A_out[8]=transferred_a_w0[8]
+ A_out[7]=transferred_a_w0[7] A_out[6]=transferred_a_w0[6]
+ A_out[5]=transferred_a_w0[5] A_out[4]=transferred_a_w0[4]
+ A_out[3]=transferred_a_w0[3] A_out[2]=transferred_a_w0[2]
+ A_out[1]=transferred_a_w0[1] A_out[0]=transferred_a_w0[0] done=Transfer_done_w0
+ p1=FE_DBTN3_i2_w_29 p2=FE_DBTN4_i2_w_27 p3=FE_DBTN5_i2_w_25 p4=FE_DBTN6_i2_w_23
+ p5=FE_DBTN7_i2_w_21 p6=FE_DBTN8_i2_w_19 p7=FE_DBTN9_i2_w_17
+ p8=FE_DBTN10_i2_w_15 p9=FE_DBTN11_i2_w_13 p10=FE_DBTN12_i2_w_11
+ p11=FE_DBTN13_i2_w_9 p12=FE_DBTN14_i2_w_7 p13=FE_DBTN15_i2_w_5
+ p14=FE_DBTN16_i2_w_3 p15=FE_DBTN17_i2_w_1 p16=FE_DBTN18_i2_w_0
+ p17=FE_DBTN19_i1_w_29 p18=FE_DBTN20_i1_w_27 p19=FE_DBTN21_i1_w_25
+ p20=FE_DBTN22_i1_w_23 p21=FE_DBTN23_i1_w_21 p22=FE_DBTN24_i1_w_19
+ p23=FE_DBTN25_i1_w_17 p24=FE_DBTN26_i1_w_15 p25=FE_DBTN27_i1_w_13
+ p26=FE_DBTN28_i1_w_11 p27=FE_DBTN29_i1_w_9 p28=FE_DBTN30_i1_w_7
+ p29=FE_DBTN31_i1_w_5 p30=FE_DBTN32_i1_w_3 p31=FE_DBTN33_i1_w_1
+ p32=FE_DBTN34_i1_w_0 FE_OFN41_FE_DBTN1_i_i_rst=FE_OFN40_FE_DBTN1_i_i_rst
+ FE_OFN37_FE_DBTN1_i_i_rst=FE_OFN35_FE_DBTN1_i_i_rst
+ FE_OFN34_FE_DBTN1_i_i_rst=FE_OFN33_FE_DBTN1_i_i_rst
+ FE_OFN28_FE_DBTN1_i_i_rst=FE_OFN13_FE_DBTN1_i_i_rst
+ FE_OFN23_FE_DBTN1_i_i_rst=FE_OFN459_FE_OFN9_FE_DBTN1_i_i_rst
+ FE_OFN20_FE_DBTN1_i_i_rst=FE_OFN462_FE_OFN8_FE_DBTN1_i_i_rst
+ FE_OFN48_raw_prime_31=FE_OFN47_raw_prime_31
+ FE_OFN50_raw_prime_30=FE_OFN49_raw_prime_30
+ FE_OFN54_raw_prime_29=FE_OFN53_raw_prime_29
+ FE_OFN58_raw_prime_28=FE_OFN57_raw_prime_28
+ FE_OFN60_raw_prime_27=FE_OFN59_raw_prime_27
+ FE_OFN64_raw_prime_26=FE_OFN63_raw_prime_26
+ FE_OFN68_raw_prime_25=FE_OFN67_raw_prime_25
+ FE_OFN72_raw_prime_24=FE_OFN71_raw_prime_24
+ FE_OFN74_raw_prime_23=FE_OFN73_raw_prime_23
+ FE_OFN78_raw_prime_22=FE_OFN77_raw_prime_22
+ FE_OFN82_raw_prime_21=FE_OFN81_raw_prime_21
+ FE_OFN86_raw_prime_20=FE_OFN85_raw_prime_20
+ FE_OFN88_raw_prime_19=FE_OFN87_raw_prime_19
+ FE_OFN92_raw_prime_18=FE_OFN91_raw_prime_18
+ FE_OFN96_raw_prime_17=FE_OFN95_raw_prime_17
+ FE_OFN100_raw_prime_16=FE_OFN99_raw_prime_16
+ FE_OFN104_raw_prime_15=FE_OFN103_raw_prime_15
+ FE_OFN107_raw_prime_14=FE_OFN106_raw_prime_14
+ FE_OFN110_raw_prime_13=FE_OFN109_raw_prime_13
+ FE_OFN113_raw_prime_12=FE_OFN112_raw_prime_12
+ FE_OFN117_raw_prime_11=FE_OFN116_raw_prime_11
+ FE_OFN120_raw_prime_10=FE_OFN119_raw_prime_10
+ FE_OFN123_raw_prime_9=FE_OFN122_raw_prime_9 FE_OFN125_raw_prime_7=raw_prime[7]
+ FE_OFN127_raw_prime_6=FE_OFN126_raw_prime_6
+ FE_OFN130_raw_prime_4=FE_OFN129_raw_prime_4
+ FE_OFN133_n312=FE_OCPN666_FE_OFN87_n312 FE_OFN132_n312=FE_OFN131_n312
+ FE_OFN143_raw_prime_8=FE_OFN141_raw_prime_8
+ FE_OFN139_raw_prime_8=FE_OFN89_raw_prime_8
+ FE_OFN138_raw_prime_8=FE_OFN137_raw_prime_8
+ FE_OFN136_raw_prime_8=FE_OFN135_raw_prime_8
+ FE_OFN147_raw_prime_2=FE_OFN146_raw_prime_2
+ FE_OFN149_raw_prime_3=FE_OFN148_raw_prime_3
+ FE_OFN151_raw_prime_9=FE_OFN98_raw_prime_9
+ FE_OFN150_raw_prime_9=FE_OFN97_raw_prime_9
+ FE_OFN154_raw_prime_5=FE_OFN153_raw_prime_5 FE_OFN158_raw_prime_8=raw_prime[8]
+ FE_OFN157_raw_prime_8=FE_OFN156_raw_prime_8 FE_OFN167_n=FE_OFN165_n
+ FE_OFN162_n=FE_OFN160_n FE_OFN168_n310=raw_prime[0]
+ FE_OFN178_FE_OFN325_n310=FE_OCPN659_FE_OFN345_FE_OFN325_n310
+ FE_OFN179_FE_OFN101_raw_prime_5=FE_OFN350_FE_OFN101_raw_prime_5
+ FE_OFN180_FE_OFN95_raw_prime_7=FE_OFN352_FE_OFN95_raw_prime_7
+ FE_OFN182_FE_OFN93_raw_prime_2=raw_prime[2]
+ FE_OFN183_FE_OFN89_raw_prime_8=FE_OFN357_FE_OFN89_raw_prime_8
+ FE_OFN186_FE_OFN87_n312=FE_OFN359_FE_OFN87_n312
+ FE_OFN187_FE_OFN85_raw_prime_4=FE_OFN360_FE_OFN85_raw_prime_4
+ FE_OFN189_FE_OFN59_raw_prime_3=FE_OFN389_FE_OFN59_raw_prime_3
+ FE_OFN192_FE_OFN56_raw_prime_6=FE_OFN392_FE_OFN56_raw_prime_6
+ FE_OFN191_FE_OFN56_raw_prime_6=FE_OFN190_FE_OFN56_raw_prime_6
+ FE_OFN197_FE_OFN55_raw_prime_7=FE_OFN196_FE_OFN55_raw_prime_7
+ FE_OFN201_FE_OFN53_raw_prime_9=FE_OFN200_FE_OFN53_raw_prime_9
+ FE_OFN206_FE_OFN52_raw_prime_10=FE_OFN119_raw_prime_10
+ FE_OFN204_FE_OFN52_raw_prime_10=FE_OFN397_FE_OFN52_raw_prime_10
+ FE_OFN212_FE_OFN50_raw_prime_12=FE_OFN403_FE_OFN50_raw_prime_12
+ FE_OFN215_FE_OFN49_raw_prime_13=FE_OFN214_FE_OFN49_raw_prime_13
+ FE_OFN225_FE_OFN43_raw_prime_19=FE_OFN224_FE_OFN43_raw_prime_19
+ FE_OFN230_FE_OFN42_raw_prime_20=FE_OFN229_FE_OFN42_raw_prime_20
+ FE_OFN235_FE_OFN41_raw_prime_21=FE_OFN234_FE_OFN41_raw_prime_21
+ FE_OFN241_FE_OFN39_raw_prime_23=FE_OFN240_FE_OFN39_raw_prime_23
+ FE_OFN243_FE_OFN38_raw_prime_24=FE_OFN242_FE_OFN38_raw_prime_24
+ FE_OFN248_FE_OFN37_raw_prime_25=FE_OFN247_FE_OFN37_raw_prime_25
+ FE_OFN257_FE_OFN35_raw_prime_27=FE_OFN256_FE_OFN35_raw_prime_27
+ FE_OFN260_FE_OFN34_raw_prime_28=FE_OFN259_FE_OFN34_raw_prime_28
+ FE_OFN266_FE_OFN32_raw_prime_30=FE_OFN265_FE_OFN32_raw_prime_30
+ FE_OFN269_FE_OFN31_raw_prime_31=FE_OFN268_FE_OFN31_raw_prime_31
+ FE_OFN279_FE_OFN13_FE_DBTN1_i_i_rst=FE_OFN452_FE_OFN13_FE_DBTN1_i_i_rst
+ FE_OFN291_FE_OFN8_FE_DBTN1_i_i_rst=FE_OFN463_FE_OFN8_FE_DBTN1_i_i_rst
+ FE_OFN305_FE_OFN4_FE_DBTN1_i_i_rst=FE_OFN304_FE_OFN4_FE_DBTN1_i_i_rst
+ FE_OFN314_raw_prime_15=FE_OFN495_raw_prime_15
+ FE_OFN316_raw_prime_14=FE_OFN496_raw_prime_14 FE_OFN322_n=FE_OFN321_n
+ FE_OFN338_n=FE_OFN601_n FE_OFN337_n=FE_OFN336_n FE_OFN335_n=FE_OFN599_n
+ FE_OFN341_n=FE_OFN340_n FE_OFN345_n=FE_OFN344_n FE_OFN343_n=FE_OFN342_n
+ FE_OFN348_raw_prime_2=FE_OFN657_raw_prime_2 clk_clone6=CTS_46
+ clk_clone5=i_clk_clone10 clk_clone4=i_clk_clone9 clk_clone3=i_clk_clone5
+ clk_clone2=i_clk_clone4 clk_clone1=i_clk_clone3 clk=CTS_57 p33=p1 p34=p2
Xd1 Domain_Transfer_0 $PINS reset=FE_OFN466_FE_OFN6_FE_DBTN1_i_i_rst
+ ToMont=net484 in_sig=in_sig_w Px_i[31]=x3_w[31] Px_i[30]=x3_w[30]
+ Px_i[29]=x3_w[29] Px_i[28]=x3_w[28] Px_i[27]=x3_w[27] Px_i[26]=x3_w[26]
+ Px_i[25]=x3_w[25] Px_i[24]=x3_w[24] Px_i[23]=x3_w[23] Px_i[22]=x3_w[22]
+ Px_i[21]=x3_w[21] Px_i[20]=FE_PHN1235_x3_w_20 Px_i[19]=x3_w[19]
+ Px_i[18]=x3_w[18] Px_i[17]=x3_w[17] Px_i[16]=x3_w[16] Px_i[15]=x3_w[15]
+ Px_i[14]=x3_w[14] Px_i[13]=x3_w[13] Px_i[12]=x3_w[12] Px_i[11]=x3_w[11]
+ Px_i[10]=x3_w[10] Px_i[9]=x3_w[9] Px_i[8]=x3_w[8] Px_i[7]=x3_w[7]
+ Px_i[6]=FE_PHN1337_x3_w_6 Px_i[5]=x3_w[5] Px_i[4]=x3_w[4] Px_i[3]=x3_w[3]
+ Px_i[2]=x3_w[2] Px_i[1]=x3_w[1] Px_i[0]=FE_PHN1339_x3_w_0 Py_i[31]=y3_w[31]
+ Py_i[30]=y3_w[30] Py_i[29]=y3_w[29] Py_i[28]=y3_w[28] Py_i[27]=y3_w[27]
+ Py_i[26]=y3_w[26] Py_i[25]=y3_w[25] Py_i[24]=y3_w[24] Py_i[23]=y3_w[23]
+ Py_i[22]=y3_w[22] Py_i[21]=y3_w[21] Py_i[20]=y3_w[20] Py_i[19]=y3_w[19]
+ Py_i[18]=y3_w[18] Py_i[17]=y3_w[17] Py_i[16]=y3_w[16] Py_i[15]=y3_w[15]
+ Py_i[14]=y3_w[14] Py_i[13]=y3_w[13] Py_i[12]=y3_w[12] Py_i[11]=y3_w[11]
+ Py_i[10]=y3_w[10] Py_i[9]=y3_w[9] Py_i[8]=y3_w[8] Py_i[7]=y3_w[7]
+ Py_i[6]=y3_w[6] Py_i[5]=y3_w[5] Py_i[4]=y3_w[4] Py_i[3]=FE_PHN1300_y3_w_3
+ Py_i[2]=y3_w[2] Py_i[1]=y3_w[1] Py_i[0]=y3_w[0] A_i[31]=raw_a[31]
+ A_i[30]=raw_a[30] A_i[29]=raw_a[29] A_i[28]=raw_a[28] A_i[27]=raw_a[27]
+ A_i[26]=raw_a[26] A_i[25]=raw_a[25] A_i[24]=raw_a[24] A_i[23]=raw_a[23]
+ A_i[22]=raw_a[22] A_i[21]=raw_a[21] A_i[20]=raw_a[20] A_i[19]=raw_a[19]
+ A_i[18]=raw_a[18] A_i[17]=raw_a[17] A_i[16]=raw_a[16] A_i[15]=raw_a[15]
+ A_i[14]=raw_a[14] A_i[13]=raw_a[13] A_i[12]=raw_a[12] A_i[11]=raw_a[11]
+ A_i[10]=raw_a[10] A_i[9]=raw_a[9] A_i[8]=raw_a[8] A_i[7]=raw_a[7]
+ A_i[6]=raw_a[6] A_i[5]=raw_a[5] A_i[4]=raw_a[4] A_i[3]=raw_a[3] A_i[2]=raw_a[2]
+ A_i[1]=raw_a[1] A_i[0]=raw_a[0] Prime[31]=FE_OFN268_FE_OFN31_raw_prime_31
+ Prime[30]=FE_OFN265_FE_OFN32_raw_prime_30 Prime[29]=FE_OFN53_raw_prime_29
+ Prime[28]=FE_OFN57_raw_prime_28 Prime[27]=FE_OFN256_FE_OFN35_raw_prime_27
+ Prime[26]=FE_OFN63_raw_prime_26 Prime[25]=FE_OFN247_FE_OFN37_raw_prime_25
+ Prime[24]=FE_OFN71_raw_prime_24 Prime[23]=FE_OFN240_FE_OFN39_raw_prime_23
+ Prime[22]=FE_OFN239_FE_OFN40_raw_prime_22
+ Prime[21]=FE_OFN234_FE_OFN41_raw_prime_21
+ Prime[20]=FE_OFN229_FE_OFN42_raw_prime_20 Prime[19]=FE_OFN87_raw_prime_19
+ Prime[18]=FE_OFN91_raw_prime_18 Prime[17]=FE_OFN221_FE_OFN45_raw_prime_17
+ Prime[16]=FE_OFN220_FE_OFN46_raw_prime_16 Prime[15]=FE_OFN495_raw_prime_15
+ Prime[14]=raw_prime[14] Prime[13]=raw_prime[13]
+ Prime[12]=FE_OFN112_raw_prime_12 Prime[11]=raw_prime[11]
+ Prime[10]=FE_OFN397_FE_OFN52_raw_prime_10
+ Prime[9]=FE_OFN200_FE_OFN53_raw_prime_9 Prime[8]=FE_OFN137_raw_prime_8
+ Prime[7]=FE_OFN352_FE_OFN95_raw_prime_7 Prime[6]=raw_prime[6]
+ Prime[5]=FE_OFN350_FE_OFN101_raw_prime_5
+ Prime[4]=FE_OFN360_FE_OFN85_raw_prime_4 Prime[3]=raw_prime[3]
+ Prime[2]=FE_OFN657_raw_prime_2 Prime[1]=FE_OFN87_n312
+ Prime[0]=FE_OFN345_FE_OFN325_n310 Px_out[31]=final_output_1[31]
+ Px_out[30]=final_output_1[30] Px_out[29]=final_output_1[29]
+ Px_out[28]=final_output_1[28] Px_out[27]=final_output_1[27]
+ Px_out[26]=final_output_1[26] Px_out[25]=final_output_1[25]
+ Px_out[24]=final_output_1[24] Px_out[23]=final_output_1[23]
+ Px_out[22]=final_output_1[22] Px_out[21]=final_output_1[21]
+ Px_out[20]=final_output_1[20] Px_out[19]=final_output_1[19]
+ Px_out[18]=final_output_1[18] Px_out[17]=final_output_1[17]
+ Px_out[16]=final_output_1[16] Px_out[15]=final_output_1[15]
+ Px_out[14]=final_output_1[14] Px_out[13]=final_output_1[13]
+ Px_out[12]=final_output_1[12] Px_out[11]=final_output_1[11]
+ Px_out[10]=final_output_1[10] Px_out[9]=final_output_1[9]
+ Px_out[8]=final_output_1[8] Px_out[7]=final_output_1[7]
+ Px_out[6]=final_output_1[6] Px_out[5]=final_output_1[5]
+ Px_out[4]=final_output_1[4] Px_out[3]=final_output_1[3]
+ Px_out[2]=final_output_1[2] Px_out[1]=final_output_1[1]
+ Px_out[0]=final_output_1[0] Py_out[31]=final_output_2[31]
+ Py_out[30]=final_output_2[30] Py_out[29]=final_output_2[29]
+ Py_out[28]=final_output_2[28] Py_out[27]=final_output_2[27]
+ Py_out[26]=final_output_2[26] Py_out[25]=final_output_2[25]
+ Py_out[24]=final_output_2[24] Py_out[23]=final_output_2[23]
+ Py_out[22]=final_output_2[22] Py_out[21]=final_output_2[21]
+ Py_out[20]=final_output_2[20] Py_out[19]=final_output_2[19]
+ Py_out[18]=final_output_2[18] Py_out[17]=final_output_2[17]
+ Py_out[16]=final_output_2[16] Py_out[15]=final_output_2[15]
+ Py_out[14]=final_output_2[14] Py_out[13]=final_output_2[13]
+ Py_out[12]=final_output_2[12] Py_out[11]=final_output_2[11]
+ Py_out[10]=final_output_2[10] Py_out[9]=final_output_2[9]
+ Py_out[8]=final_output_2[8] Py_out[7]=final_output_2[7]
+ Py_out[6]=final_output_2[6] Py_out[5]=final_output_2[5]
+ Py_out[4]=final_output_2[4] Py_out[3]=final_output_2[3]
+ Py_out[2]=final_output_2[2] Py_out[1]=final_output_2[1]
+ Py_out[0]=final_output_2[0] done=Transfer_done_w1 p1=FE_DBTN35_y3_w_0
+ p2=FE_DBTN36_y3_w_1 p3=FE_DBTN37_y3_w_3 p4=FE_DBTN38_y3_w_5 p5=FE_DBTN39_y3_w_6
+ p6=FE_DBTN40_y3_w_7 p7=FE_DBTN41_y3_w_9 p8=FE_DBTN42_y3_w_11
+ p9=FE_DBTN43_y3_w_13 p10=FE_DBTN44_y3_w_15 p11=FE_DBTN45_y3_w_17
+ p12=FE_DBTN46_y3_w_19 p13=FE_DBTN47_y3_w_21 p14=FE_DBTN48_y3_w_23
+ p15=FE_DBTN49_y3_w_25 p16=FE_DBTN50_y3_w_27 p17=FE_DBTN51_y3_w_29
+ p18=FE_DBTN52_y3_w_31 p19=FE_PHN1339_x3_w_0 p20=FE_DBTN54_x3_w_1
+ p21=FE_DBTN55_x3_w_3 p22=FE_DBTN56_x3_w_5 p23=FE_DBTN57_x3_w_6
+ p24=FE_DBTN58_x3_w_7 p25=FE_DBTN59_x3_w_9 p26=FE_DBTN60_x3_w_11
+ p27=FE_DBTN61_x3_w_13 p28=FE_DBTN62_x3_w_15 p29=FE_DBTN63_x3_w_17
+ p30=FE_DBTN64_x3_w_19 p31=FE_DBTN65_x3_w_21 p32=FE_DBTN66_x3_w_23
+ p33=FE_DBTN67_x3_w_25 p34=FE_DBTN68_x3_w_27 p35=FE_DBTN69_x3_w_29
+ p36=FE_DBTN70_x3_w_31 FE_OFN45_FE_DBTN1_i_i_rst=FE_OFN26_FE_DBTN1_i_i_rst
+ FE_OFN43_FE_DBTN1_i_i_rst=FE_OFN25_FE_DBTN1_i_i_rst
+ FE_OFN36_FE_DBTN1_i_i_rst=FE_OFN35_FE_DBTN1_i_i_rst
+ FE_OFN31_FE_DBTN1_i_i_rst=FE_OFN15_FE_DBTN1_i_i_rst
+ FE_OFN30_FE_DBTN1_i_i_rst=FE_OFN448_FE_OFN14_FE_DBTN1_i_i_rst
+ FE_OFN25_FE_DBTN1_i_i_rst=FE_OFN11_FE_DBTN1_i_i_rst
+ FE_OFN21_FE_DBTN1_i_i_rst=FE_OFN463_FE_OFN8_FE_DBTN1_i_i_rst
+ FE_OFN105_raw_prime_15=FE_OFN103_raw_prime_15
+ FE_OFN108_raw_prime_14=FE_OFN106_raw_prime_14
+ FE_OFN111_raw_prime_13=FE_OFN214_FE_OFN49_raw_prime_13
+ FE_OFN118_raw_prime_11=FE_OFN209_FE_OFN51_raw_prime_11
+ FE_OFN121_raw_prime_10=FE_OFN119_raw_prime_10
+ FE_OFN128_raw_prime_6=FE_OFN126_raw_prime_6
+ FE_OFN140_raw_prime_8=FE_OFN357_FE_OFN89_raw_prime_8
+ FE_OFN152_raw_prime_9=FE_OFN98_raw_prime_9 FE_OFN169_x3_w_0=FE_OFN333_x3_w_0
+ n466=n466 FE_OFN193_FE_OFN56_raw_prime_6=FE_OFN392_FE_OFN56_raw_prime_6
+ FE_OFN207_FE_OFN52_raw_prime_10=FE_OFN119_raw_prime_10
+ FE_OFN213_FE_OFN50_raw_prime_12=FE_OFN403_FE_OFN50_raw_prime_12
+ FE_OFN223_FE_OFN44_raw_prime_18=FE_OFN222_FE_OFN44_raw_prime_18
+ FE_OFN227_FE_OFN43_raw_prime_19=FE_OFN224_FE_OFN43_raw_prime_19
+ FE_OFN237_FE_OFN41_raw_prime_21=FE_OFN236_FE_OFN41_raw_prime_21
+ FE_OFN244_FE_OFN38_raw_prime_24=FE_OFN242_FE_OFN38_raw_prime_24
+ FE_OFN250_FE_OFN36_raw_prime_26=FE_OFN249_FE_OFN36_raw_prime_26
+ FE_OFN261_FE_OFN34_raw_prime_28=FE_OFN259_FE_OFN34_raw_prime_28
+ FE_OFN264_FE_OFN33_raw_prime_29=FE_OFN263_FE_OFN33_raw_prime_29
+ FE_OFN271_FE_OFN31_raw_prime_31=FE_OFN270_FE_OFN31_raw_prime_31
+ FE_OFN317_raw_prime_14=FE_OFN496_raw_prime_14 FE_OFN324_n=FE_OFN323_n
+ FE_OFN333_n=FE_OFN597_n FE_OFN332_n=FE_OFN595_n
+ FE_OCPN349_FE_OFN345_FE_OFN325_n310=FE_OCPN659_FE_OFN345_FE_OFN325_n310
+ clk_clone5=i_clk_clone10 clk_clone4=CTS_47 clk_clone3=CTS_50 clk_clone2=CTS_51
+ clk_clone1=i_clk_clone7 clk=CTS_53
+ FE_OCPN353_FE_OFN87_n312=FE_OCPN666_FE_OFN87_n312 p37=FE_PHN1225_x3_w_12
+ p38=FE_PHN1262_x3_w_14
Xlookup_0 lookup_table $PINS i_rst=FE_OFN8_FE_DBTN1_i_i_rst
+ lookup_table_done_from_control=lookup_table_done_from_control P_sel[1]=P_sel[1]
+ P_sel[0]=P_sel[0] mode=mode Px_in[31]=Px_in_to_look[31]
+ Px_in[30]=Px_in_to_look[30] Px_in[29]=Px_in_to_look[29]
+ Px_in[28]=Px_in_to_look[28] Px_in[27]=Px_in_to_look[27]
+ Px_in[26]=Px_in_to_look[26] Px_in[25]=Px_in_to_look[25]
+ Px_in[24]=Px_in_to_look[24] Px_in[23]=Px_in_to_look[23]
+ Px_in[22]=Px_in_to_look[22] Px_in[21]=Px_in_to_look[21]
+ Px_in[20]=Px_in_to_look[20] Px_in[19]=Px_in_to_look[19]
+ Px_in[18]=Px_in_to_look[18] Px_in[17]=Px_in_to_look[17]
+ Px_in[16]=Px_in_to_look[16] Px_in[15]=Px_in_to_look[15]
+ Px_in[14]=Px_in_to_look[14] Px_in[13]=Px_in_to_look[13]
+ Px_in[12]=Px_in_to_look[12] Px_in[11]=Px_in_to_look[11]
+ Px_in[10]=Px_in_to_look[10] Px_in[9]=Px_in_to_look[9] Px_in[8]=Px_in_to_look[8]
+ Px_in[7]=Px_in_to_look[7] Px_in[6]=Px_in_to_look[6] Px_in[5]=Px_in_to_look[5]
+ Px_in[4]=Px_in_to_look[4] Px_in[3]=Px_in_to_look[3] Px_in[2]=Px_in_to_look[2]
+ Px_in[1]=Px_in_to_look[1] Px_in[0]=Px_in_to_look[0] Py_in[31]=Py_in_to_look[31]
+ Py_in[30]=Py_in_to_look[30] Py_in[29]=Py_in_to_look[29]
+ Py_in[28]=Py_in_to_look[28] Py_in[27]=Py_in_to_look[27]
+ Py_in[26]=Py_in_to_look[26] Py_in[25]=Py_in_to_look[25]
+ Py_in[24]=Py_in_to_look[24] Py_in[23]=Py_in_to_look[23]
+ Py_in[22]=Py_in_to_look[22] Py_in[21]=Py_in_to_look[21]
+ Py_in[20]=Py_in_to_look[20] Py_in[19]=Py_in_to_look[19]
+ Py_in[18]=Py_in_to_look[18] Py_in[17]=Py_in_to_look[17]
+ Py_in[16]=Py_in_to_look[16] Py_in[15]=Py_in_to_look[15]
+ Py_in[14]=Py_in_to_look[14] Py_in[13]=Py_in_to_look[13]
+ Py_in[12]=Py_in_to_look[12] Py_in[11]=Py_in_to_look[11]
+ Py_in[10]=Py_in_to_look[10] Py_in[9]=Py_in_to_look[9] Py_in[8]=Py_in_to_look[8]
+ Py_in[7]=Py_in_to_look[7] Py_in[6]=Py_in_to_look[6] Py_in[5]=Py_in_to_look[5]
+ Py_in[4]=Py_in_to_look[4] Py_in[3]=Py_in_to_look[3] Py_in[2]=Py_in_to_look[2]
+ Py_in[1]=Py_in_to_look[1] Py_in[0]=Py_in_to_look[0]
+ Px_out[31]=Px_out_from_look[31] Px_out[30]=Px_out_from_look[30]
+ Px_out[29]=Px_out_from_look[29] Px_out[28]=Px_out_from_look[28]
+ Px_out[27]=Px_out_from_look[27] Px_out[26]=Px_out_from_look[26]
+ Px_out[25]=Px_out_from_look[25] Px_out[24]=Px_out_from_look[24]
+ Px_out[23]=Px_out_from_look[23] Px_out[22]=Px_out_from_look[22]
+ Px_out[21]=Px_out_from_look[21] Px_out[20]=Px_out_from_look[20]
+ Px_out[19]=Px_out_from_look[19] Px_out[18]=Px_out_from_look[18]
+ Px_out[17]=Px_out_from_look[17] Px_out[16]=Px_out_from_look[16]
+ Px_out[15]=Px_out_from_look[15] Px_out[14]=Px_out_from_look[14]
+ Px_out[13]=Px_out_from_look[13] Px_out[12]=Px_out_from_look[12]
+ Px_out[11]=Px_out_from_look[11] Px_out[10]=Px_out_from_look[10]
+ Px_out[9]=Px_out_from_look[9] Px_out[8]=Px_out_from_look[8]
+ Px_out[7]=Px_out_from_look[7] Px_out[6]=Px_out_from_look[6]
+ Px_out[5]=Px_out_from_look[5] Px_out[4]=Px_out_from_look[4]
+ Px_out[3]=Px_out_from_look[3] Px_out[2]=Px_out_from_look[2]
+ Px_out[1]=Px_out_from_look[1] Px_out[0]=Px_out_from_look[0]
+ Py_out[31]=Py_out_from_look[31] Py_out[30]=Py_out_from_look[30]
+ Py_out[29]=Py_out_from_look[29] Py_out[28]=Py_out_from_look[28]
+ Py_out[27]=Py_out_from_look[27] Py_out[26]=Py_out_from_look[26]
+ Py_out[25]=Py_out_from_look[25] Py_out[24]=Py_out_from_look[24]
+ Py_out[23]=Py_out_from_look[23] Py_out[22]=Py_out_from_look[22]
+ Py_out[21]=Py_out_from_look[21] Py_out[20]=Py_out_from_look[20]
+ Py_out[19]=Py_out_from_look[19] Py_out[18]=Py_out_from_look[18]
+ Py_out[17]=Py_out_from_look[17] Py_out[16]=Py_out_from_look[16]
+ Py_out[15]=Py_out_from_look[15] Py_out[14]=Py_out_from_look[14]
+ Py_out[13]=Py_out_from_look[13] Py_out[12]=Py_out_from_look[12]
+ Py_out[11]=Py_out_from_look[11] Py_out[10]=Py_out_from_look[10]
+ Py_out[9]=Py_out_from_look[9] Py_out[8]=Py_out_from_look[8]
+ Py_out[7]=Py_out_from_look[7] Py_out[6]=Py_out_from_look[6]
+ Py_out[5]=Py_out_from_look[5] Py_out[4]=Py_out_from_look[4]
+ Py_out[3]=Py_out_from_look[3] Py_out[2]=Py_out_from_look[2]
+ Py_out[1]=Py_out_from_look[1] Py_out[0]=Py_out_from_look[0] Port99=net484
+ p1=FE_DBTN72_mode FE_OFN46_FE_DBTN1_i_i_rst=FE_OFN28_FE_DBTN1_i_i_rst
+ FE_OFN44_FE_DBTN1_i_i_rst=FE_OFN26_FE_DBTN1_i_i_rst
+ FE_OFN42_FE_DBTN1_i_i_rst=FE_OFN25_FE_DBTN1_i_i_rst
+ FE_OFN32_FE_DBTN1_i_i_rst=FE_OFN15_FE_DBTN1_i_i_rst
+ FE_OFN29_FE_DBTN1_i_i_rst=FE_OFN14_FE_DBTN1_i_i_rst
+ FE_OFN27_FE_DBTN1_i_i_rst=FE_OFN13_FE_DBTN1_i_i_rst
+ FE_OFN26_FE_DBTN1_i_i_rst=FE_OFN11_FE_DBTN1_i_i_rst
+ FE_OFN24_FE_DBTN1_i_i_rst=FE_OFN10_FE_DBTN1_i_i_rst
+ FE_OFN22_FE_DBTN1_i_i_rst=FE_OFN9_FE_DBTN1_i_i_rst
+ FE_OFN276_FE_OFN14_FE_DBTN1_i_i_rst=FE_OFN449_FE_OFN14_FE_DBTN1_i_i_rst
+ FE_OFN275_FE_OFN14_FE_DBTN1_i_i_rst=FE_OFN448_FE_OFN14_FE_DBTN1_i_i_rst
+ FE_OFN278_FE_OFN13_FE_DBTN1_i_i_rst=FE_OFN452_FE_OFN13_FE_DBTN1_i_i_rst
+ FE_OFN277_FE_OFN13_FE_DBTN1_i_i_rst=FE_OFN451_FE_OFN13_FE_DBTN1_i_i_rst
+ FE_OFN282_FE_OFN11_FE_DBTN1_i_i_rst=FE_OFN455_FE_OFN11_FE_DBTN1_i_i_rst
+ FE_OFN281_FE_OFN11_FE_DBTN1_i_i_rst=FE_OFN454_FE_OFN11_FE_DBTN1_i_i_rst
+ FE_OFN280_FE_OFN11_FE_DBTN1_i_i_rst=FE_OFN453_FE_OFN11_FE_DBTN1_i_i_rst
+ FE_OFN285_FE_OFN10_FE_DBTN1_i_i_rst=FE_OFN458_FE_OFN10_FE_DBTN1_i_i_rst
+ FE_OFN284_FE_OFN10_FE_DBTN1_i_i_rst=FE_OFN457_FE_OFN10_FE_DBTN1_i_i_rst
+ FE_OFN283_FE_OFN10_FE_DBTN1_i_i_rst=FE_OFN456_FE_OFN10_FE_DBTN1_i_i_rst
+ FE_OFN287_FE_OFN9_FE_DBTN1_i_i_rst=FE_OFN460_FE_OFN9_FE_DBTN1_i_i_rst
+ FE_OFN286_FE_OFN9_FE_DBTN1_i_i_rst=FE_OFN459_FE_OFN9_FE_DBTN1_i_i_rst
+ FE_OFN290_FE_OFN8_FE_DBTN1_i_i_rst=FE_OFN463_FE_OFN8_FE_DBTN1_i_i_rst
+ FE_OFN289_FE_OFN8_FE_DBTN1_i_i_rst=FE_OFN462_FE_OFN8_FE_DBTN1_i_i_rst
+ FE_OFN288_FE_OFN8_FE_DBTN1_i_i_rst=FE_OFN461_FE_OFN8_FE_DBTN1_i_i_rst
+ FE_OFN329_n=FE_OFN590_n FE_OFN328_n=FE_OFN589_n FE_OFN327_n=FE_OFN588_n
+ FE_OFN331_n=FE_OFN594_n FE_OFN330_n=FE_OFN591_n i_clk_clone10=CTS_46
+ i_clk_clone9=i_clk_clone9 i_clk_clone8=CTS_47 i_clk_clone7=CTS_48
+ i_clk_clone6=CTS_50 i_clk_clone5=CTS_51 i_clk_clone4=i_clk_clone7
+ i_clk_clone3=CTS_53 i_clk_clone2=CTS_54 i_clk_clone1=CTS_55 i_clk=CTS_57
Xkey_counter_reg[4] QDFFRBN $PINS Q=key_counter[4] D=FE_PHN1362_n1144
+ CK=i_clk_clone4 RB=FE_OFN40_FE_DBTN1_i_i_rst
Xkey_counter_reg[2] QDFFRBN $PINS Q=key_counter[2] D=FE_PHN1369_n1146
+ CK=i_clk_clone4 RB=FE_OFN40_FE_DBTN1_i_i_rst
Xkey_counter_reg[3] QDFFRBN $PINS Q=key_counter[3] D=n1145 CK=i_clk_clone4
+ RB=FE_OFN40_FE_DBTN1_i_i_rst
Xkey_counter_reg[1] QDFFRBN $PINS Q=key_counter[1] D=n1147 CK=i_clk_clone4
+ RB=FE_OFN599_n
Xkey_counter_reg[0] QDFFRBN $PINS Q=key_counter[0] D=n1148 CK=i_clk_clone4
+ RB=FE_OFN599_n
Xx3_reg[29] QDFFRBN $PINS Q=x3_w[29] D=n1082 CK=i_clk_clone7 RB=FE_OFN590_n
Xx3_reg[26] QDFFRBN $PINS Q=x3_w[26] D=n1085 CK=i_clk_clone7 RB=FE_OFN588_n
Xy3_reg[29] QDFFRBN $PINS Q=y3_w[29] D=n1019 CK=i_clk_clone7 RB=FE_OFN590_n
Xx3_reg[28] QDFFRBN $PINS Q=x3_w[28] D=n1083 CK=i_clk_clone7 RB=FE_OFN588_n
Xy3_reg[26] QDFFRBN $PINS Q=y3_w[26] D=n1022 CK=i_clk_clone7
+ RB=FE_OFN466_FE_OFN6_FE_DBTN1_i_i_rst
Xx3_reg[30] QDFFRBN $PINS Q=x3_w[30] D=n1081 CK=i_clk_clone7 RB=FE_OFN590_n
Xy3_reg[28] QDFFRBN $PINS Q=y3_w[28] D=n1020 CK=i_clk_clone7
+ RB=FE_OFN466_FE_OFN6_FE_DBTN1_i_i_rst
Xy3_reg[30] QDFFRBN $PINS Q=y3_w[30] D=n1018 CK=i_clk_clone7
+ RB=FE_OFN466_FE_OFN6_FE_DBTN1_i_i_rst
Xx3_reg[27] QDFFRBN $PINS Q=x3_w[27] D=n1084 CK=i_clk_clone7 RB=FE_OFN590_n
Xx3_reg[25] QDFFRBN $PINS Q=x3_w[25] D=n1086 CK=i_clk_clone7 RB=FE_OFN590_n
Xx3_reg[23] QDFFRBN $PINS Q=x3_w[23] D=n1088 CK=i_clk_clone7 RB=FE_OFN590_n
Xx3_reg[24] QDFFRBN $PINS Q=x3_w[24] D=n1087 CK=i_clk_clone7 RB=FE_OFN590_n
Xy3_reg[27] QDFFRBN $PINS Q=y3_w[27] D=n1021 CK=CTS_53 RB=FE_OFN589_n
Xy3_reg[25] QDFFRBN $PINS Q=y3_w[25] D=n1023 CK=CTS_53 RB=FE_OFN590_n
Xy3_reg[23] QDFFRBN $PINS Q=y3_w[23] D=n1025 CK=CTS_53 RB=FE_OFN597_n
Xy3_reg[24] QDFFRBN $PINS Q=y3_w[24] D=n1024 CK=i_clk_clone7 RB=FE_OFN590_n
Xa_reg[31] QDFFRBN $PINS Q=a[31] D=FE_PHN1446_n1153 CK=i_clk_clone3
+ RB=FE_OFN336_n
Xa_reg[30] QDFFRBN $PINS Q=a[30] D=n1154 CK=i_clk_clone4 RB=FE_OFN601_n
Xa_reg[29] QDFFRBN $PINS Q=a[29] D=n1155 CK=i_clk_clone3 RB=FE_OFN336_n
Xa_reg[28] QDFFRBN $PINS Q=a[28] D=n1156 CK=i_clk_clone4 RB=FE_OFN336_n
Xa_reg[27] QDFFRBN $PINS Q=a[27] D=n1157 CK=i_clk_clone3 RB=FE_OFN336_n
Xa_reg[26] QDFFRBN $PINS Q=a[26] D=n1158 CK=i_clk_clone4 RB=FE_OFN601_n
Xcounter_reg[3] QDFFRBN $PINS Q=counter[3] D=FE_PHN1366_n1149 CK=i_clk_clone4
+ RB=FE_OFN599_n
Xcounter_reg[0] QDFFRBN $PINS Q=counter[0] D=n1152 CK=i_clk_clone4
+ RB=FE_OFN599_n
Xcounter_reg[1] QDFFRBN $PINS Q=counter[1] D=FE_PHN1427_n1151 CK=i_clk_clone4
+ RB=FE_OFN599_n
Xcounter_reg[2] QDFFRBN $PINS Q=counter[2] D=FE_PHN1373_n1150 CK=i_clk_clone4
+ RB=FE_OFN599_n
Xx3_reg[21] QDFFRBN $PINS Q=x3_w[21] D=n1090 CK=i_clk_clone7 RB=FE_OFN589_n
Xx3_reg[19] QDFFRBN $PINS Q=x3_w[19] D=n1092 CK=CTS_53 RB=FE_OFN597_n
Xx3_reg[22] QDFFRBN $PINS Q=FE_PHN1226_x3_w_22 D=n1089 CK=i_clk_clone7
+ RB=FE_OFN590_n
Xx3_reg[20] QDFFRBN $PINS Q=x3_w[20] D=n1091 CK=CTS_53 RB=FE_OFN589_n
Xy3_reg[21] QDFFRBN $PINS Q=y3_w[21] D=n1027 CK=CTS_53 RB=FE_OFN597_n
Xy3_reg[19] QDFFRBN $PINS Q=y3_w[19] D=n1029 CK=CTS_53 RB=FE_OFN597_n
Xy3_reg[22] QDFFRBN $PINS Q=y3_w[22] D=n1026 CK=CTS_53 RB=FE_OFN597_n
Xy3_reg[20] QDFFRBN $PINS Q=y3_w[20] D=n1028 CK=CTS_53 RB=FE_OFN589_n
Xa_reg[25] QDFFRBN $PINS Q=a[25] D=n1159 CK=i_clk_clone3 RB=FE_OFN336_n
Xa_reg[24] QDFFRBN $PINS Q=a[24] D=n1160 CK=i_clk_clone4 RB=FE_OFN336_n
Xa_reg[23] QDFFRBN $PINS Q=a[23] D=n1161 CK=i_clk_clone4 RB=FE_OFN601_n
Xa_reg[22] QDFFRBN $PINS Q=a[22] D=n1162 CK=i_clk_clone4 RB=FE_OFN336_n
Xa_reg[21] QDFFRBN $PINS Q=a[21] D=n1163 CK=i_clk_clone4 RB=FE_OFN601_n
Xa_reg[20] QDFFRBN $PINS Q=a[20] D=n1164 CK=i_clk_clone4 RB=FE_OFN601_n
Xa_reg[19] QDFFRBN $PINS Q=a[19] D=n1165 CK=i_clk_clone4 RB=FE_OFN601_n
Xa_reg[18] QDFFRBN $PINS Q=a[18] D=n1166 CK=i_clk_clone4 RB=FE_OFN599_n
Xa_reg[17] QDFFRBN $PINS Q=a[17] D=n1167 CK=i_clk_clone4 RB=FE_OFN336_n
Xa_reg[16] QDFFRBN $PINS Q=a[16] D=n1168 CK=i_clk_clone4 RB=FE_OFN599_n
Xa_reg[15] QDFFRBN $PINS Q=a[15] D=n1169 CK=i_clk_clone4 RB=FE_OFN601_n
Xa_reg[14] QDFFRBN $PINS Q=a[14] D=n1170 CK=i_clk_clone4 RB=FE_OFN599_n
Xa_reg[13] QDFFRBN $PINS Q=a[13] D=n1171 CK=i_clk_clone4
+ RB=FE_OFN40_FE_DBTN1_i_i_rst
Xa_reg[12] QDFFRBN $PINS Q=a[12] D=n1172 CK=i_clk_clone4
+ RB=FE_OFN40_FE_DBTN1_i_i_rst
Xa_reg[11] QDFFRBN $PINS Q=a[11] D=n1173 CK=i_clk_clone4
+ RB=FE_OFN40_FE_DBTN1_i_i_rst
Xa_reg[10] QDFFRBN $PINS Q=a[10] D=n1174 CK=i_clk_clone4
+ RB=FE_OFN40_FE_DBTN1_i_i_rst
Xx3_reg[17] QDFFRBN $PINS Q=x3_w[17] D=n1094 CK=CTS_53 RB=FE_OFN597_n
Xx3_reg[18] QDFFRBN $PINS Q=FE_PHN1242_x3_w_18 D=n1093 CK=CTS_53 RB=FE_OFN597_n
Xy3_reg[17] QDFFRBN $PINS Q=y3_w[17] D=n1031 CK=CTS_53 RB=FE_OFN597_n
Xy3_reg[18] QDFFRBN $PINS Q=y3_w[18] D=n1030 CK=CTS_53 RB=FE_OFN597_n
Xx3_reg[16] QDFFRBN $PINS Q=x3_w[16] D=n1095 CK=CTS_53 RB=FE_OFN597_n
Xy3_reg[16] QDFFRBN $PINS Q=y3_w[16] D=n1032 CK=CTS_55 RB=FE_OFN597_n
Xr2_reg[31] QDFFRBN $PINS Q=r2[31] D=n1048 CK=CTS_54 RB=FE_OFN588_n
Xr2_reg[30] QDFFRBN $PINS Q=r2[30] D=n1049 CK=i_clk_clone7 RB=FE_OFN588_n
Xr2_reg[29] QDFFRBN $PINS Q=r2[29] D=n1050 CK=CTS_54
+ RB=FE_OFN10_FE_DBTN1_i_i_rst
Xr2_reg[28] QDFFRBN $PINS Q=r2[28] D=n1051 CK=CTS_54 RB=FE_OFN588_n
Xr2_reg[27] QDFFRBN $PINS Q=r2[27] D=n1052 CK=CTS_54
+ RB=FE_OFN10_FE_DBTN1_i_i_rst
Xr2_reg[26] QDFFRBN $PINS Q=r2[26] D=n1053 CK=CTS_54
+ RB=FE_OFN10_FE_DBTN1_i_i_rst
Xr2_reg[25] QDFFRBN $PINS Q=r2[25] D=n1054 CK=CTS_54
+ RB=FE_OFN19_FE_DBTN1_i_i_rst
Xr2_reg[24] QDFFRBN $PINS Q=r2[24] D=n1055 CK=i_clk_clone7
+ RB=FE_OFN466_FE_OFN6_FE_DBTN1_i_i_rst
Xr2_reg[23] QDFFRBN $PINS Q=r2[23] D=n1056 CK=CTS_54
+ RB=FE_OFN465_FE_OFN7_FE_DBTN1_i_i_rst
Xr2_reg[22] QDFFRBN $PINS Q=r2[22] D=n1057 CK=CTS_54
+ RB=FE_OFN466_FE_OFN6_FE_DBTN1_i_i_rst
Xr2_reg[21] QDFFRBN $PINS Q=r2[21] D=n1058 CK=CTS_57
+ RB=FE_OFN465_FE_OFN7_FE_DBTN1_i_i_rst
Xr2_reg[20] QDFFRBN $PINS Q=r2[20] D=n1059 CK=CTS_54
+ RB=FE_OFN466_FE_OFN6_FE_DBTN1_i_i_rst
Xr2_reg[19] QDFFRBN $PINS Q=r2[19] D=n1060 CK=i_clk
+ RB=FE_OFN19_FE_DBTN1_i_i_rst
Xr2_reg[18] QDFFRBN $PINS Q=r2[18] D=n1061 CK=CTS_54
+ RB=FE_OFN466_FE_OFN6_FE_DBTN1_i_i_rst
Xr2_reg[17] QDFFRBN $PINS Q=r2[17] D=n1062 CK=i_clk
+ RB=FE_OFN19_FE_DBTN1_i_i_rst
Xr2_reg[16] QDFFRBN $PINS Q=r2[16] D=n1063 CK=CTS_54
+ RB=FE_OFN466_FE_OFN6_FE_DBTN1_i_i_rst
Xr2_reg[15] QDFFRBN $PINS Q=r2[15] D=n1064 CK=i_clk
+ RB=FE_OFN19_FE_DBTN1_i_i_rst
Xr2_reg[14] QDFFRBN $PINS Q=r2[14] D=n1065 CK=CTS_54
+ RB=FE_OFN19_FE_DBTN1_i_i_rst
Xr2_reg[13] QDFFRBN $PINS Q=r2[13] D=n1066 CK=i_clk
+ RB=FE_OFN19_FE_DBTN1_i_i_rst
Xr2_reg[12] QDFFRBN $PINS Q=r2[12] D=n1067 CK=CTS_54
+ RB=FE_OFN19_FE_DBTN1_i_i_rst
Xr2_reg[11] QDFFRBN $PINS Q=r2[11] D=n1068 CK=i_clk
+ RB=FE_OFN19_FE_DBTN1_i_i_rst
Xr2_reg[10] QDFFRBN $PINS Q=r2[10] D=n1069 CK=i_clk
+ RB=FE_OFN19_FE_DBTN1_i_i_rst
Xr2_reg[9] QDFFRBN $PINS Q=r2[9] D=n1070 CK=i_clk RB=FE_OFN19_FE_DBTN1_i_i_rst
Xr2_reg[8] QDFFRBN $PINS Q=r2[8] D=n1071 CK=i_clk RB=FE_OFN19_FE_DBTN1_i_i_rst
Xr2_reg[7] QDFFRBN $PINS Q=r2[7] D=n1072 CK=i_clk RB=FE_OFN19_FE_DBTN1_i_i_rst
Xr2_reg[6] QDFFRBN $PINS Q=r2[6] D=n1073 CK=i_clk RB=FE_OFN19_FE_DBTN1_i_i_rst
Xr2_reg[5] QDFFRBN $PINS Q=r2[5] D=n1074 CK=CTS_57
+ RB=FE_OFN465_FE_OFN7_FE_DBTN1_i_i_rst
Xr2_reg[4] QDFFRBN $PINS Q=r2[4] D=n1075 CK=i_clk RB=FE_OFN19_FE_DBTN1_i_i_rst
Xr2_reg[3] QDFFRBN $PINS Q=r2[3] D=n1076 CK=CTS_57
+ RB=FE_OFN465_FE_OFN7_FE_DBTN1_i_i_rst
Xr2_reg[2] QDFFRBN $PINS Q=r2[2] D=n1077 CK=CTS_57
+ RB=FE_OFN465_FE_OFN7_FE_DBTN1_i_i_rst
Xr2_reg[1] QDFFRBN $PINS Q=r2[1] D=n1078 CK=CTS_57
+ RB=FE_OFN465_FE_OFN7_FE_DBTN1_i_i_rst
Xr1_reg[31] QDFFRBN $PINS Q=r1[31] D=n1112 CK=CTS_54 RB=FE_OFN588_n
Xr1_reg[30] QDFFRBN $PINS Q=r1[30] D=n1113 CK=CTS_54
+ RB=FE_OFN10_FE_DBTN1_i_i_rst
Xr1_reg[29] QDFFRBN $PINS Q=r1[29] D=n1114 CK=CTS_54
+ RB=FE_OFN456_FE_OFN10_FE_DBTN1_i_i_rst
Xr1_reg[28] QDFFRBN $PINS Q=r1[28] D=n1115 CK=CTS_54
+ RB=FE_OFN10_FE_DBTN1_i_i_rst
Xr1_reg[27] QDFFRBN $PINS Q=r1[27] D=n1116 CK=CTS_54
+ RB=FE_OFN10_FE_DBTN1_i_i_rst
Xr1_reg[26] QDFFRBN $PINS Q=r1[26] D=n1117 CK=CTS_54
+ RB=FE_OFN10_FE_DBTN1_i_i_rst
Xr1_reg[25] QDFFRBN $PINS Q=r1[25] D=n1118 CK=CTS_54
+ RB=FE_OFN465_FE_OFN7_FE_DBTN1_i_i_rst
Xr1_reg[24] QDFFRBN $PINS Q=r1[24] D=n1119 CK=i_clk_clone7 RB=FE_OFN588_n
Xr1_reg[23] QDFFRBN $PINS Q=r1[23] D=n1120 CK=CTS_54
+ RB=FE_OFN465_FE_OFN7_FE_DBTN1_i_i_rst
Xr1_reg[22] QDFFRBN $PINS Q=r1[22] D=n1121 CK=CTS_54 RB=FE_OFN588_n
Xr1_reg[21] QDFFRBN $PINS Q=r1[21] D=n1122 CK=CTS_57
+ RB=FE_OFN465_FE_OFN7_FE_DBTN1_i_i_rst
Xr1_reg[20] QDFFRBN $PINS Q=r1[20] D=n1123 CK=CTS_54
+ RB=FE_OFN466_FE_OFN6_FE_DBTN1_i_i_rst
Xr1_reg[19] QDFFRBN $PINS Q=r1[19] D=n1124 CK=i_clk
+ RB=FE_OFN465_FE_OFN7_FE_DBTN1_i_i_rst
Xr1_reg[18] QDFFRBN $PINS Q=r1[18] D=n1125 CK=CTS_54
+ RB=FE_OFN10_FE_DBTN1_i_i_rst
Xr1_reg[17] QDFFRBN $PINS Q=r1[17] D=n1126 CK=i_clk
+ RB=FE_OFN465_FE_OFN7_FE_DBTN1_i_i_rst
Xr1_reg[16] QDFFRBN $PINS Q=r1[16] D=n1127 CK=CTS_54
+ RB=FE_OFN466_FE_OFN6_FE_DBTN1_i_i_rst
Xr1_reg[15] QDFFRBN $PINS Q=r1[15] D=n1128 CK=i_clk
+ RB=FE_OFN19_FE_DBTN1_i_i_rst
Xr1_reg[14] QDFFRBN $PINS Q=r1[14] D=n1129 CK=CTS_54
+ RB=FE_OFN19_FE_DBTN1_i_i_rst
Xr1_reg[13] QDFFRBN $PINS Q=r1[13] D=n1130 CK=CTS_57
+ RB=FE_OFN465_FE_OFN7_FE_DBTN1_i_i_rst
Xr1_reg[12] QDFFRBN $PINS Q=r1[12] D=n1131 CK=CTS_54
+ RB=FE_OFN19_FE_DBTN1_i_i_rst
Xr1_reg[11] QDFFRBN $PINS Q=r1[11] D=n1132 CK=i_clk
+ RB=FE_OFN465_FE_OFN7_FE_DBTN1_i_i_rst
Xr1_reg[10] QDFFRBN $PINS Q=r1[10] D=n1133 CK=CTS_54
+ RB=FE_OFN465_FE_OFN7_FE_DBTN1_i_i_rst
Xr1_reg[9] QDFFRBN $PINS Q=r1[9] D=n1134 CK=i_clk
+ RB=FE_OFN465_FE_OFN7_FE_DBTN1_i_i_rst
Xr1_reg[8] QDFFRBN $PINS Q=r1[8] D=n1135 CK=i_clk
+ RB=FE_OFN465_FE_OFN7_FE_DBTN1_i_i_rst
Xr1_reg[7] QDFFRBN $PINS Q=r1[7] D=n1136 CK=CTS_57
+ RB=FE_OFN465_FE_OFN7_FE_DBTN1_i_i_rst
Xr1_reg[6] QDFFRBN $PINS Q=r1[6] D=n1137 CK=CTS_54
+ RB=FE_OFN465_FE_OFN7_FE_DBTN1_i_i_rst
Xr1_reg[5] QDFFRBN $PINS Q=r1[5] D=n1138 CK=CTS_57
+ RB=FE_OFN458_FE_OFN10_FE_DBTN1_i_i_rst
Xr1_reg[4] QDFFRBN $PINS Q=r1[4] D=n1139 CK=i_clk
+ RB=FE_OFN465_FE_OFN7_FE_DBTN1_i_i_rst
Xr1_reg[3] QDFFRBN $PINS Q=r1[3] D=n1140 CK=CTS_57
+ RB=FE_OFN458_FE_OFN10_FE_DBTN1_i_i_rst
Xr1_reg[2] QDFFRBN $PINS Q=r1[2] D=n1141 CK=CTS_57
+ RB=FE_OFN458_FE_OFN10_FE_DBTN1_i_i_rst
Xr1_reg[1] QDFFRBN $PINS Q=r1[1] D=n1142 CK=CTS_57
+ RB=FE_OFN458_FE_OFN10_FE_DBTN1_i_i_rst
Xy2_reg[1] QDFFRBN $PINS Q=y2[1] D=n983 CK=CTS_46
+ RB=FE_OFN462_FE_OFN8_FE_DBTN1_i_i_rst
Xy2_reg[2] QDFFRBN $PINS Q=y2[2] D=FE_PHN1417_n982 CK=CTS_46
+ RB=FE_OFN8_FE_DBTN1_i_i_rst
Xy2_reg[3] QDFFRBN $PINS Q=y2[3] D=FE_PHN1418_n981 CK=CTS_46
+ RB=FE_OFN8_FE_DBTN1_i_i_rst
Xy2_reg[4] QDFFRBN $PINS Q=y2[4] D=FE_PHN1420_n980 CK=CTS_46
+ RB=FE_OFN461_FE_OFN8_FE_DBTN1_i_i_rst
Xy2_reg[5] QDFFRBN $PINS Q=y2[5] D=FE_PHN1407_n979 CK=CTS_46
+ RB=FE_OFN8_FE_DBTN1_i_i_rst
Xy2_reg[6] QDFFRBN $PINS Q=y2[6] D=n978 CK=CTS_51
+ RB=FE_OFN455_FE_OFN11_FE_DBTN1_i_i_rst
Xy2_reg[7] QDFFRBN $PINS Q=y2[7] D=n977 CK=CTS_46
+ RB=FE_OFN455_FE_OFN11_FE_DBTN1_i_i_rst
Xy2_reg[8] QDFFRBN $PINS Q=y2[8] D=n976 CK=CTS_51
+ RB=FE_OFN453_FE_OFN11_FE_DBTN1_i_i_rst
Xy2_reg[9] QDFFRBN $PINS Q=y2[9] D=n975 CK=CTS_51
+ RB=FE_OFN455_FE_OFN11_FE_DBTN1_i_i_rst
Xy2_reg[10] QDFFRBN $PINS Q=y2[10] D=n974 CK=CTS_51
+ RB=FE_OFN453_FE_OFN11_FE_DBTN1_i_i_rst
Xy2_reg[11] QDFFRBN $PINS Q=y2[11] D=n973 CK=CTS_51
+ RB=FE_OFN455_FE_OFN11_FE_DBTN1_i_i_rst
Xy2_reg[12] QDFFRBN $PINS Q=y2[12] D=n972 CK=CTS_47
+ RB=FE_OFN449_FE_OFN14_FE_DBTN1_i_i_rst
Xy2_reg[13] QDFFRBN $PINS Q=y2[13] D=n971 CK=CTS_46
+ RB=FE_OFN455_FE_OFN11_FE_DBTN1_i_i_rst
Xy2_reg[14] QDFFRBN $PINS Q=y2[14] D=n970 CK=CTS_51
+ RB=FE_OFN454_FE_OFN11_FE_DBTN1_i_i_rst
Xy2_reg[15] QDFFRBN $PINS Q=y2[15] D=FE_PHN1374_n969 CK=CTS_46
+ RB=FE_OFN13_FE_DBTN1_i_i_rst
Xy2_reg[16] QDFFRBN $PINS Q=y2[16] D=n968 CK=CTS_47
+ RB=FE_OFN454_FE_OFN11_FE_DBTN1_i_i_rst
Xy2_reg[17] QDFFRBN $PINS Q=y2[17] D=n967 CK=CTS_48
+ RB=FE_OFN451_FE_OFN13_FE_DBTN1_i_i_rst
Xy2_reg[18] QDFFRBN $PINS Q=y2[18] D=n966 CK=CTS_51
+ RB=FE_OFN454_FE_OFN11_FE_DBTN1_i_i_rst
Xy2_reg[19] QDFFRBN $PINS Q=y2[19] D=n965 CK=CTS_46
+ RB=FE_OFN455_FE_OFN11_FE_DBTN1_i_i_rst
Xy2_reg[20] QDFFRBN $PINS Q=y2[20] D=n964 CK=CTS_51
+ RB=FE_OFN454_FE_OFN11_FE_DBTN1_i_i_rst
Xy2_reg[21] QDFFRBN $PINS Q=y2[21] D=n963 CK=CTS_46
+ RB=FE_OFN461_FE_OFN8_FE_DBTN1_i_i_rst
Xy2_reg[22] QDFFRBN $PINS Q=y2[22] D=n962 CK=CTS_51
+ RB=FE_OFN11_FE_DBTN1_i_i_rst
Xy2_reg[23] QDFFRBN $PINS Q=y2[23] D=n961 CK=CTS_51
+ RB=FE_OFN455_FE_OFN11_FE_DBTN1_i_i_rst
Xy2_reg[24] QDFFRBN $PINS Q=y2[24] D=n960 CK=CTS_51
+ RB=FE_OFN11_FE_DBTN1_i_i_rst
Xy2_reg[25] QDFFRBN $PINS Q=y2[25] D=FE_PHN1384_n959 CK=CTS_51
+ RB=FE_OFN455_FE_OFN11_FE_DBTN1_i_i_rst
Xy2_reg[26] QDFFRBN $PINS Q=y2[26] D=FE_PHN1376_n958 CK=CTS_51
+ RB=FE_OFN11_FE_DBTN1_i_i_rst
Xy2_reg[27] QDFFRBN $PINS Q=y2[27] D=FE_PHN1340_n957 CK=CTS_51
+ RB=FE_OFN455_FE_OFN11_FE_DBTN1_i_i_rst
Xy2_reg[28] QDFFRBN $PINS Q=y2[28] D=n956 CK=CTS_50
+ RB=FE_OFN453_FE_OFN11_FE_DBTN1_i_i_rst
Xy2_reg[29] QDFFRBN $PINS Q=y2[29] D=FE_PHN1399_n955 CK=CTS_50
+ RB=FE_OFN455_FE_OFN11_FE_DBTN1_i_i_rst
Xy2_reg[30] QDFFRBN $PINS Q=y2[30] D=FE_PHN1426_n954 CK=CTS_50
+ RB=FE_OFN453_FE_OFN11_FE_DBTN1_i_i_rst
Xy2_reg[31] QDFFRBN $PINS Q=y2[31] D=n953 CK=CTS_50
+ RB=FE_OFN453_FE_OFN11_FE_DBTN1_i_i_rst
Xx2_reg[1] QDFFRBN $PINS Q=x2[1] D=FE_PHN1445_n919 CK=CTS_57
+ RB=FE_OFN9_FE_DBTN1_i_i_rst
Xx2_reg[2] QDFFRBN $PINS Q=x2[2] D=FE_PHN1387_n918 CK=CTS_57
+ RB=FE_OFN9_FE_DBTN1_i_i_rst
Xx2_reg[3] QDFFRBN $PINS Q=x2[3] D=FE_PHN1382_n917 CK=CTS_57
+ RB=FE_OFN9_FE_DBTN1_i_i_rst
Xx2_reg[4] QDFFRBN $PINS Q=x2[4] D=n916 CK=CTS_57
+ RB=FE_OFN460_FE_OFN9_FE_DBTN1_i_i_rst
Xx2_reg[5] QDFFRBN $PINS Q=x2[5] D=n915 CK=CTS_57
+ RB=FE_OFN460_FE_OFN9_FE_DBTN1_i_i_rst
Xx2_reg[6] QDFFRBN $PINS Q=x2[6] D=n914 CK=CTS_55
+ RB=FE_OFN457_FE_OFN10_FE_DBTN1_i_i_rst
Xx2_reg[7] QDFFRBN $PINS Q=x2[7] D=n913 CK=CTS_57 RB=FE_OFN9_FE_DBTN1_i_i_rst
Xx2_reg[8] QDFFRBN $PINS Q=x2[8] D=FE_PHN1380_n912 CK=CTS_54
+ RB=FE_OFN456_FE_OFN10_FE_DBTN1_i_i_rst
Xx2_reg[9] QDFFRBN $PINS Q=x2[9] D=n911 CK=CTS_55
+ RB=FE_OFN457_FE_OFN10_FE_DBTN1_i_i_rst
Xx2_reg[10] QDFFRBN $PINS Q=x2[10] D=FE_PHN1439_n910 CK=CTS_54
+ RB=FE_OFN456_FE_OFN10_FE_DBTN1_i_i_rst
Xx2_reg[11] QDFFRBN $PINS Q=x2[11] D=n909 CK=CTS_55
+ RB=FE_OFN457_FE_OFN10_FE_DBTN1_i_i_rst
Xx2_reg[12] QDFFRBN $PINS Q=x2[12] D=FE_PHN1436_n908 CK=CTS_55
+ RB=FE_OFN456_FE_OFN10_FE_DBTN1_i_i_rst
Xx2_reg[13] QDFFRBN $PINS Q=x2[13] D=n907 CK=CTS_55
+ RB=FE_OFN457_FE_OFN10_FE_DBTN1_i_i_rst
Xx2_reg[14] QDFFRBN $PINS Q=x2[14] D=FE_PHN1443_n906 CK=CTS_55
+ RB=FE_OFN456_FE_OFN10_FE_DBTN1_i_i_rst
Xx2_reg[15] QDFFRBN $PINS Q=x2[15] D=FE_PHN1391_n905 CK=CTS_57
+ RB=FE_OFN458_FE_OFN10_FE_DBTN1_i_i_rst
Xx2_reg[16] QDFFRBN $PINS Q=x2[16] D=FE_PHN1444_n904 CK=CTS_55
+ RB=FE_OFN10_FE_DBTN1_i_i_rst
Xx2_reg[17] QDFFRBN $PINS Q=x2[17] D=FE_PHN1415_n903 CK=CTS_57
+ RB=FE_OFN458_FE_OFN10_FE_DBTN1_i_i_rst
Xx2_reg[18] QDFFRBN $PINS Q=x2[18] D=FE_PHN1432_n902 CK=CTS_55
+ RB=FE_OFN456_FE_OFN10_FE_DBTN1_i_i_rst
Xx2_reg[19] QDFFRBN $PINS Q=x2[19] D=n901 CK=CTS_57
+ RB=FE_OFN458_FE_OFN10_FE_DBTN1_i_i_rst
Xx2_reg[20] QDFFRBN $PINS Q=x2[20] D=FE_PHN1421_n900 CK=CTS_54
+ RB=FE_OFN456_FE_OFN10_FE_DBTN1_i_i_rst
Xx2_reg[21] QDFFRBN $PINS Q=x2[21] D=FE_PHN1416_n899 CK=CTS_57
+ RB=FE_OFN458_FE_OFN10_FE_DBTN1_i_i_rst
Xx2_reg[22] QDFFRBN $PINS Q=x2[22] D=FE_PHN1405_n898 CK=CTS_54
+ RB=FE_OFN10_FE_DBTN1_i_i_rst
Xx2_reg[23] QDFFRBN $PINS Q=x2[23] D=FE_PHN1388_n897 CK=CTS_54
+ RB=FE_OFN458_FE_OFN10_FE_DBTN1_i_i_rst
Xx2_reg[24] QDFFRBN $PINS Q=x2[24] D=FE_PHN1442_n896 CK=CTS_54
+ RB=FE_OFN456_FE_OFN10_FE_DBTN1_i_i_rst
Xx2_reg[25] QDFFRBN $PINS Q=x2[25] D=FE_PHN1386_n895 CK=CTS_57
+ RB=FE_OFN458_FE_OFN10_FE_DBTN1_i_i_rst
Xx2_reg[26] QDFFRBN $PINS Q=x2[26] D=FE_PHN1428_n894 CK=CTS_54
+ RB=FE_OFN456_FE_OFN10_FE_DBTN1_i_i_rst
Xx2_reg[27] QDFFRBN $PINS Q=x2[27] D=FE_PHN1403_n893 CK=CTS_54
+ RB=FE_OFN458_FE_OFN10_FE_DBTN1_i_i_rst
Xx2_reg[28] QDFFRBN $PINS Q=x2[28] D=FE_PHN1408_n892 CK=CTS_54
+ RB=FE_OFN28_FE_DBTN1_i_i_rst
Xx2_reg[29] QDFFRBN $PINS Q=x2[29] D=n891 CK=CTS_54
+ RB=FE_OFN458_FE_OFN10_FE_DBTN1_i_i_rst
Xx2_reg[30] QDFFRBN $PINS Q=x2[30] D=FE_PHN1401_n890 CK=CTS_55
+ RB=FE_OFN10_FE_DBTN1_i_i_rst
Xx2_reg[31] QDFFRBN $PINS Q=x2[31] D=FE_PHN1396_n889 CK=CTS_55
+ RB=FE_OFN10_FE_DBTN1_i_i_rst
Xa_reg[9] QDFFRBN $PINS Q=a[9] D=n1175 CK=i_clk_clone4
+ RB=FE_OFN40_FE_DBTN1_i_i_rst
Xa_reg[8] QDFFRBN $PINS Q=a[8] D=n1176 CK=i_clk_clone4
+ RB=FE_OFN40_FE_DBTN1_i_i_rst
Xa_reg[7] QDFFRBN $PINS Q=a[7] D=n1177 CK=i_clk_clone4 RB=FE_OFN336_n
Xa_reg[6] QDFFRBN $PINS Q=a[6] D=n1178 CK=i_clk_clone4 RB=FE_OFN601_n
Xa_reg[5] QDFFRBN $PINS Q=a[5] D=n1179 CK=i_clk_clone4 RB=FE_OFN336_n
Xa_reg[4] QDFFRBN $PINS Q=a[4] D=n1180 CK=i_clk_clone4 RB=FE_OFN601_n
Xa_reg[3] QDFFRBN $PINS Q=a[3] D=n1181 CK=i_clk_clone4 RB=FE_OFN336_n
Xa_reg[2] QDFFRBN $PINS Q=a[2] D=n1182 CK=i_clk_clone4 RB=FE_OFN336_n
Xa_reg[1] QDFFRBN $PINS Q=a[1] D=n1183 CK=i_clk_clone3 RB=FE_OFN336_n
Xy1_reg[1] QDFFRBN $PINS Q=y1[1] D=FE_PHN1400_n1015 CK=CTS_46
+ RB=FE_OFN462_FE_OFN8_FE_DBTN1_i_i_rst
Xy1_reg[2] QDFFRBN $PINS Q=y1[2] D=n1014 CK=CTS_46 RB=FE_OFN8_FE_DBTN1_i_i_rst
Xy1_reg[3] QDFFRBN $PINS Q=y1[3] D=FE_PHN1441_n1013 CK=CTS_46
+ RB=FE_OFN462_FE_OFN8_FE_DBTN1_i_i_rst
Xy1_reg[4] QDFFRBN $PINS Q=y1[4] D=n1012 CK=CTS_46
+ RB=FE_OFN461_FE_OFN8_FE_DBTN1_i_i_rst
Xy1_reg[5] QDFFRBN $PINS Q=y1[5] D=FE_PHN1578_n1011 CK=CTS_46
+ RB=FE_OFN461_FE_OFN8_FE_DBTN1_i_i_rst
Xy1_reg[6] QDFFRBN $PINS Q=y1[6] D=FE_PHN1353_n1010 CK=CTS_51
+ RB=FE_OFN455_FE_OFN11_FE_DBTN1_i_i_rst
Xy1_reg[7] QDFFRBN $PINS Q=y1[7] D=FE_PHN1438_n1009 CK=CTS_46
+ RB=FE_OFN455_FE_OFN11_FE_DBTN1_i_i_rst
Xy1_reg[8] QDFFRBN $PINS Q=y1[8] D=n1008 CK=CTS_51
+ RB=FE_OFN454_FE_OFN11_FE_DBTN1_i_i_rst
Xy1_reg[9] QDFFRBN $PINS Q=y1[9] D=n1007 CK=CTS_48 RB=FE_OFN14_FE_DBTN1_i_i_rst
Xy1_reg[10] QDFFRBN $PINS Q=y1[10] D=n1006 CK=CTS_51
+ RB=FE_OFN454_FE_OFN11_FE_DBTN1_i_i_rst
Xy1_reg[11] QDFFRBN $PINS Q=y1[11] D=n1005 CK=CTS_48
+ RB=FE_OFN449_FE_OFN14_FE_DBTN1_i_i_rst
Xy1_reg[12] QDFFRBN $PINS Q=y1[12] D=n1004 CK=CTS_47
+ RB=FE_OFN449_FE_OFN14_FE_DBTN1_i_i_rst
Xy1_reg[13] QDFFRBN $PINS Q=y1[13] D=n1003 CK=CTS_48
+ RB=FE_OFN14_FE_DBTN1_i_i_rst
Xy1_reg[14] QDFFRBN $PINS Q=y1[14] D=n1002 CK=CTS_47
+ RB=FE_OFN449_FE_OFN14_FE_DBTN1_i_i_rst
Xy1_reg[15] QDFFRBN $PINS Q=y1[15] D=n1001 CK=CTS_48
+ RB=FE_OFN13_FE_DBTN1_i_i_rst
Xy1_reg[16] QDFFRBN $PINS Q=y1[16] D=n1000 CK=CTS_47
+ RB=FE_OFN448_FE_OFN14_FE_DBTN1_i_i_rst
Xy1_reg[17] QDFFRBN $PINS Q=y1[17] D=FE_PHN1406_n999 CK=CTS_48
+ RB=FE_OFN451_FE_OFN13_FE_DBTN1_i_i_rst
Xy1_reg[18] QDFFRBN $PINS Q=y1[18] D=n998 CK=CTS_47
+ RB=FE_OFN14_FE_DBTN1_i_i_rst
Xy1_reg[19] QDFFRBN $PINS Q=y1[19] D=FE_PHN1354_n997 CK=CTS_48
+ RB=FE_OFN451_FE_OFN13_FE_DBTN1_i_i_rst
Xy1_reg[20] QDFFRBN $PINS Q=y1[20] D=n996 CK=CTS_51
+ RB=FE_OFN454_FE_OFN11_FE_DBTN1_i_i_rst
Xy1_reg[21] QDFFRBN $PINS Q=y1[21] D=n995 CK=CTS_46
+ RB=FE_OFN13_FE_DBTN1_i_i_rst
Xy1_reg[22] QDFFRBN $PINS Q=y1[22] D=n994 CK=CTS_51
+ RB=FE_OFN454_FE_OFN11_FE_DBTN1_i_i_rst
Xy1_reg[23] QDFFRBN $PINS Q=y1[23] D=n993 CK=CTS_51
+ RB=FE_OFN453_FE_OFN11_FE_DBTN1_i_i_rst
Xy1_reg[24] QDFFRBN $PINS Q=y1[24] D=n992 CK=CTS_51
+ RB=FE_OFN454_FE_OFN11_FE_DBTN1_i_i_rst
Xy1_reg[25] QDFFRBN $PINS Q=y1[25] D=n991 CK=CTS_51
+ RB=FE_OFN453_FE_OFN11_FE_DBTN1_i_i_rst
Xy1_reg[26] QDFFRBN $PINS Q=y1[26] D=n990 CK=CTS_50
+ RB=FE_OFN11_FE_DBTN1_i_i_rst
Xy1_reg[27] QDFFRBN $PINS Q=y1[27] D=n989 CK=CTS_50
+ RB=FE_OFN453_FE_OFN11_FE_DBTN1_i_i_rst
Xy1_reg[28] QDFFRBN $PINS Q=y1[28] D=FE_PHN1629_n988 CK=CTS_50
+ RB=FE_OFN453_FE_OFN11_FE_DBTN1_i_i_rst
Xy1_reg[29] QDFFRBN $PINS Q=y1[29] D=n987 CK=CTS_50
+ RB=FE_OFN455_FE_OFN11_FE_DBTN1_i_i_rst
Xy1_reg[30] QDFFRBN $PINS Q=y1[30] D=n986 CK=CTS_50
+ RB=FE_OFN11_FE_DBTN1_i_i_rst
Xy1_reg[31] QDFFRBN $PINS Q=y1[31] D=FE_PHN1350_n985 CK=CTS_50
+ RB=FE_OFN11_FE_DBTN1_i_i_rst
Xx1_reg[3] QDFFRBN $PINS Q=x1[3] D=FE_PHN1356_n949 CK=CTS_46
+ RB=FE_OFN460_FE_OFN9_FE_DBTN1_i_i_rst
Xx1_reg[4] QDFFRBN $PINS Q=x1[4] D=n948 CK=CTS_46
+ RB=FE_OFN460_FE_OFN9_FE_DBTN1_i_i_rst
Xx1_reg[5] QDFFRBN $PINS Q=x1[5] D=FE_PHN1361_n947 CK=CTS_46
+ RB=FE_OFN460_FE_OFN9_FE_DBTN1_i_i_rst
Xx1_reg[6] QDFFRBN $PINS Q=x1[6] D=FE_PHN1368_n946 CK=CTS_55 RB=FE_OFN591_n
Xx1_reg[7] QDFFRBN $PINS Q=x1[7] D=FE_PHN1371_n945 CK=CTS_57
+ RB=FE_OFN9_FE_DBTN1_i_i_rst
Xx1_reg[8] QDFFRBN $PINS Q=x1[8] D=FE_PHN1352_n944 CK=CTS_54
+ RB=FE_OFN456_FE_OFN10_FE_DBTN1_i_i_rst
Xx1_reg[9] QDFFRBN $PINS Q=x1[9] D=FE_PHN1433_n943 CK=CTS_55 RB=FE_OFN591_n
Xx1_reg[10] QDFFRBN $PINS Q=x1[10] D=FE_PHN1372_n942 CK=CTS_55
+ RB=FE_OFN26_FE_DBTN1_i_i_rst
Xx1_reg[11] QDFFRBN $PINS Q=x1[11] D=FE_PHN1345_n941 CK=CTS_55 RB=FE_OFN591_n
Xx1_reg[12] QDFFRBN $PINS Q=x1[12] D=FE_PHN1355_n940 CK=CTS_55
+ RB=FE_OFN26_FE_DBTN1_i_i_rst
Xx1_reg[13] QDFFRBN $PINS Q=x1[13] D=FE_PHN1341_n939 CK=CTS_57
+ RB=FE_OFN9_FE_DBTN1_i_i_rst
Xx1_reg[14] QDFFRBN $PINS Q=x1[14] D=n938 CK=CTS_55
+ RB=FE_OFN26_FE_DBTN1_i_i_rst
Xx1_reg[15] QDFFRBN $PINS Q=x1[15] D=n937 CK=CTS_57 RB=FE_OFN9_FE_DBTN1_i_i_rst
Xx1_reg[16] QDFFRBN $PINS Q=x1[16] D=FE_PHN1351_n936 CK=CTS_55
+ RB=FE_OFN28_FE_DBTN1_i_i_rst
Xx1_reg[17] QDFFRBN $PINS Q=x1[17] D=n935 CK=CTS_57
+ RB=FE_OFN457_FE_OFN10_FE_DBTN1_i_i_rst
Xx1_reg[18] QDFFRBN $PINS Q=x1[18] D=n934 CK=CTS_55
+ RB=FE_OFN28_FE_DBTN1_i_i_rst
Xx1_reg[19] QDFFRBN $PINS Q=x1[19] D=FE_PHN1365_n933 CK=CTS_55
+ RB=FE_OFN9_FE_DBTN1_i_i_rst
Xx1_reg[20] QDFFRBN $PINS Q=x1[20] D=FE_PHN1370_n932 CK=CTS_55
+ RB=FE_OFN28_FE_DBTN1_i_i_rst
Xx1_reg[21] QDFFRBN $PINS Q=x1[21] D=n931 CK=CTS_57
+ RB=FE_OFN458_FE_OFN10_FE_DBTN1_i_i_rst
Xx1_reg[22] QDFFRBN $PINS Q=x1[22] D=FE_PHN1379_n930 CK=CTS_54
+ RB=FE_OFN28_FE_DBTN1_i_i_rst
Xx1_reg[23] QDFFRBN $PINS Q=x1[23] D=n929 CK=CTS_54
+ RB=FE_OFN458_FE_OFN10_FE_DBTN1_i_i_rst
Xx1_reg[24] QDFFRBN $PINS Q=x1[24] D=FE_PHN1348_n928 CK=CTS_54
+ RB=FE_OFN28_FE_DBTN1_i_i_rst
Xx1_reg[25] QDFFRBN $PINS Q=x1[25] D=FE_PHN1359_n927 CK=CTS_54
+ RB=FE_OFN456_FE_OFN10_FE_DBTN1_i_i_rst
Xx1_reg[26] QDFFRBN $PINS Q=x1[26] D=FE_PHN1342_n926 CK=CTS_54
+ RB=FE_OFN10_FE_DBTN1_i_i_rst
Xx1_reg[27] QDFFRBN $PINS Q=x1[27] D=FE_PHN1447_n925 CK=CTS_54
+ RB=FE_OFN456_FE_OFN10_FE_DBTN1_i_i_rst
Xx1_reg[28] QDFFRBN $PINS Q=x1[28] D=FE_PHN1349_n924 CK=CTS_54
+ RB=FE_OFN10_FE_DBTN1_i_i_rst
Xx1_reg[29] QDFFRBN $PINS Q=x1[29] D=FE_PHN1397_n923 CK=CTS_54
+ RB=FE_OFN456_FE_OFN10_FE_DBTN1_i_i_rst
Xx1_reg[30] QDFFRBN $PINS Q=x1[30] D=FE_PHN1392_n922 CK=CTS_54
+ RB=FE_OFN28_FE_DBTN1_i_i_rst
Xx1_reg[31] QDFFRBN $PINS Q=x1[31] D=FE_PHN1357_n921 CK=CTS_55
+ RB=FE_OFN28_FE_DBTN1_i_i_rst
Xx3_reg[15] QDFFRBN $PINS Q=x3_w[15] D=n1096 CK=CTS_55 RB=FE_OFN591_n
Xx3_reg[13] QDFFRBN $PINS Q=x3_w[13] D=n1098 CK=CTS_55 RB=FE_OFN591_n
Xy3_reg[15] QDFFRBN $PINS Q=y3_w[15] D=n1033 CK=CTS_50
+ RB=FE_OFN26_FE_DBTN1_i_i_rst
Xy3_reg[13] QDFFRBN $PINS Q=y3_w[13] D=n1035 CK=CTS_50 RB=FE_OFN591_n
Xx3_reg[14] QDFFRBN $PINS Q=x3_w[14] D=n1097 CK=CTS_55
+ RB=FE_OFN26_FE_DBTN1_i_i_rst
Xy3_reg[12] QDFFRBN $PINS Q=y3_w[12] D=n1036 CK=CTS_55 RB=FE_OFN591_n
Xy3_reg[14] QDFFRBN $PINS Q=y3_w[14] D=n1034 CK=CTS_50
+ RB=FE_OFN26_FE_DBTN1_i_i_rst
Xr2_reg[0] QDFFRBN $PINS Q=r2[0] D=n1079 CK=CTS_57
+ RB=FE_OFN465_FE_OFN7_FE_DBTN1_i_i_rst
Xr1_reg[0] QDFFRBN $PINS Q=r1[0] D=n1143 CK=CTS_57
+ RB=FE_OFN458_FE_OFN10_FE_DBTN1_i_i_rst
Xy2_reg[0] QDFFRBN $PINS Q=y2[0] D=FE_PHN1383_n984 CK=CTS_46
+ RB=FE_OFN461_FE_OFN8_FE_DBTN1_i_i_rst
Xx2_reg[0] QDFFRBN $PINS Q=x2[0] D=n920 CK=CTS_57
+ RB=FE_OFN460_FE_OFN9_FE_DBTN1_i_i_rst
Xa_reg[0] QDFFRBN $PINS Q=a[0] D=n1184 CK=i_clk_clone3 RB=FE_OFN336_n
Xy1_reg[0] QDFFRBN $PINS Q=y1[0] D=FE_PHN1360_n1016 CK=CTS_46
+ RB=FE_OFN461_FE_OFN8_FE_DBTN1_i_i_rst
Xx1_reg[0] QDFFRBN $PINS Q=x1[0] D=FE_PHN1344_n952 CK=CTS_46
+ RB=FE_OFN460_FE_OFN9_FE_DBTN1_i_i_rst
Xx1_reg[1] QDFFRBN $PINS Q=x1[1] D=n951 CK=CTS_46
+ RB=FE_OFN460_FE_OFN9_FE_DBTN1_i_i_rst
Xx1_reg[2] QDFFRBN $PINS Q=x1[2] D=FE_PHN1412_n950 CK=CTS_57
+ RB=FE_OFN460_FE_OFN9_FE_DBTN1_i_i_rst
Xx3_reg[11] QDFFRBN $PINS Q=x3_w[11] D=n1100 CK=CTS_55 RB=FE_OFN591_n
Xx3_reg[9] QDFFRBN $PINS Q=x3_w[9] D=n1102 CK=CTS_55 RB=FE_OFN591_n
Xx3_reg[10] QDFFRBN $PINS Q=x3_w[10] D=n1101 CK=CTS_55
+ RB=FE_OFN26_FE_DBTN1_i_i_rst
Xy3_reg[11] QDFFRBN $PINS Q=y3_w[11] D=n1037 CK=CTS_50 RB=FE_OFN593_n
Xy3_reg[9] QDFFRBN $PINS Q=y3_w[9] D=n1039 CK=CTS_50 RB=FE_OFN593_n
Xx3_reg[12] QDFFRBN $PINS Q=x3_w[12] D=n1099 CK=CTS_55
+ RB=FE_OFN26_FE_DBTN1_i_i_rst
Xy3_reg[10] QDFFRBN $PINS Q=y3_w[10] D=n1038 CK=CTS_50 RB=FE_OFN593_n
Xx3_reg[7] QDFFRBN $PINS Q=x3_w[7] D=n1104 CK=CTS_50 RB=FE_OFN594_n
Xx3_reg[8] QDFFRBN $PINS Q=x3_w[8] D=n1103 CK=CTS_50 RB=FE_OFN591_n
Xy3_reg[7] QDFFRBN $PINS Q=y3_w[7] D=n1041 CK=CTS_50
+ RB=FE_OFN453_FE_OFN11_FE_DBTN1_i_i_rst
Xy3_reg[8] QDFFRBN $PINS Q=y3_w[8] D=n1040 CK=CTS_50 RB=FE_OFN593_n
Xx3_reg[6] QDFFRBN $PINS Q=x3_w[6] D=n1105 CK=CTS_50 RB=FE_OFN593_n
Xy3_reg[6] QDFFRBN $PINS Q=y3_w[6] D=n1042 CK=CTS_50
+ RB=FE_OFN453_FE_OFN11_FE_DBTN1_i_i_rst
Xx3_reg[5] QDFFRBN $PINS Q=x3_w[5] D=n1106 CK=CTS_50 RB=FE_OFN594_n
Xx3_reg[3] QDFFRBN $PINS Q=FE_PHN1336_x3_w_3 D=n1108 CK=CTS_50 RB=FE_OFN594_n
Xy3_reg[5] QDFFRBN $PINS Q=y3_w[5] D=n1043 CK=CTS_50
+ RB=FE_OFN455_FE_OFN11_FE_DBTN1_i_i_rst
Xy3_reg[3] QDFFRBN $PINS Q=y3_w[3] D=n1045 CK=CTS_50
+ RB=FE_OFN455_FE_OFN11_FE_DBTN1_i_i_rst
Xx3_reg[4] QDFFRBN $PINS Q=x3_w[4] D=n1107 CK=CTS_50 RB=FE_OFN594_n
Xy3_reg[4] QDFFRBN $PINS Q=y3_w[4] D=n1044 CK=CTS_50
+ RB=FE_OFN461_FE_OFN8_FE_DBTN1_i_i_rst
Xstate_reg[5] QDFFRBN $PINS Q=state[5] D=n1190 CK=i_clk_clone4
+ RB=FE_OFN12_FE_DBTN1_i_i_rst
Xy3_reg[0] QDFFRBN $PINS Q=FE_PHN1328_y3_w_0 D=n1191 CK=CTS_50
+ RB=FE_OFN453_FE_OFN11_FE_DBTN1_i_i_rst
Xstate_reg[2] QDFFRBN $PINS Q=state[2] D=n1187 CK=i_clk_clone1
+ RB=FE_OFN12_FE_DBTN1_i_i_rst
Xx3_reg[2] QDFFRBN $PINS Q=x3_w[2] D=n1109 CK=CTS_50 RB=FE_OFN594_n
Xx3_reg[1] QDFFRBN $PINS Q=x3_w[1] D=n1110 CK=CTS_50 RB=FE_OFN594_n
Xx3_reg[0] QDFFRBN $PINS Q=x3_w[0] D=n1111 CK=CTS_50 RB=FE_OFN593_n
Xy3_reg[2] QDFFRBN $PINS Q=y3_w[2] D=n1046 CK=CTS_50 RB=FE_OFN594_n
Xy3_reg[1] QDFFRBN $PINS Q=y3_w[1] D=n1047 CK=CTS_50 RB=FE_OFN594_n
Xstate_reg[0] QDFFRBN $PINS Q=state[0] D=n1189 CK=i_clk_clone4 RB=FE_OFN599_n
Xstate_reg[3] QDFFRBN $PINS Q=state[3] D=n1186 CK=i_clk_clone4
+ RB=FE_OFN40_FE_DBTN1_i_i_rst
Xstate_reg[1] QDFFRBN $PINS Q=state[1] D=n1188 CK=i_clk_clone4 RB=FE_OFN599_n
Xy3_reg[31] QDFFRBN $PINS Q=y3_w[31] D=n1017 CK=i_clk_clone7 RB=FE_OFN590_n
Xx3_reg[31] QDFFRBN $PINS Q=x3_w[31] D=n1080 CK=i_clk_clone7 RB=FE_OFN590_n
Xstate_reg[4] DFFRBN $PINS Q=n9 QB=n209 D=n1185 CK=i_clk_clone4
+ RB=FE_OFN12_FE_DBTN1_i_i_rst
XU3 MUX2S $PINS O=n1187 S=n65 A=n247 B=FE_PHN1154_state_2
XU6 OA222S $PINS O=n1267 A1=FE_OFN118_n31 A2=n1262 B1=FE_OFN316_n21 B2=n1261
+ C1=n1384 C2=n1260
XU7 OA222S $PINS O=n1257 A1=FE_OFN118_n31 A2=n1252 B1=FE_OFN347_FE_OFN316_n21
+ B2=n1251 C1=FE_OFN653_n1384 C2=n1250
XU8 OA222S $PINS O=n864 A1=FE_OFN118_n31 A2=n859 B1=FE_OFN347_FE_OFN316_n21
+ B2=n858 C1=FE_OFN653_n1384 C2=n857
XU9 OA222S $PINS O=n844 A1=FE_OFN118_n31 A2=n839 B1=FE_OFN316_n21 B2=n838
+ C1=n1384 C2=n837
XU10 OA222S $PINS O=n884 A1=FE_OFN118_n31 A2=n879 B1=FE_OFN347_FE_OFN316_n21
+ B2=n878 C1=FE_OFN653_n1384 C2=n877
XU11 OA222S $PINS O=n1227 A1=n31 A2=n1222 B1=FE_OFN316_n21 B2=n1221 C1=n1384
+ C2=n1220
XU12 OA222S $PINS O=n1207 A1=FE_OFN118_n31 A2=n1202 B1=FE_OFN316_n21 B2=n1201
+ C1=n1384 C2=n1200
XU13 OA222S $PINS O=n874 A1=FE_OFN118_n31 A2=n869 B1=FE_OFN347_FE_OFN316_n21
+ B2=n868 C1=FE_OFN653_n1384 C2=n867
XU14 OA222S $PINS O=n1217 A1=FE_OFN118_n31 A2=n1212 B1=FE_OFN347_FE_OFN316_n21
+ B2=n1211 C1=FE_OFN653_n1384 C2=n1210
XU15 OA222S $PINS O=n1197 A1=FE_OFN118_n31 A2=n1192 B1=FE_OFN347_FE_OFN316_n21
+ B2=n888 C1=FE_OFN653_n1384 C2=n887
XU16 OA222S $PINS O=n1247 A1=FE_OFN118_n31 A2=n1242 B1=FE_OFN316_n21 B2=n1241
+ C1=n1384 C2=n1240
XU17 OA222S $PINS O=n834 A1=FE_OFN118_n31 A2=n829 B1=FE_OFN347_FE_OFN316_n21
+ B2=n828 C1=FE_OFN653_n1384 C2=n827
XU18 OA222S $PINS O=n804 A1=n31 A2=n799 B1=FE_OFN316_n21 B2=n798 C1=n1384
+ C2=n797
XU19 OA222S $PINS O=n814 A1=FE_OFN118_n31 A2=n809 B1=FE_OFN316_n21 B2=n808
+ C1=n1384 C2=n807
XU20 OA222S $PINS O=n794 A1=n31 A2=n789 B1=FE_OFN316_n21 B2=n788 C1=n1384
+ C2=n787
XU21 OA222S $PINS O=n824 A1=n31 A2=n819 B1=FE_OFN316_n21 B2=n818 C1=n1384
+ C2=n817
XU22 OA222 $PINS O=n784 A1=n31 A2=n779 B1=FE_OFN316_n21 B2=n778 C1=n1384
+ C2=n777
XU23 OR3B2 $PINS O=n214 I1=n9 B1=n213 B2=n251
XU24 OR3B2S $PINS O=n193 I1=state[3] B1=state[2] B2=n251
XU25 INV2 $PINS O=n251 I=state[5]
XU26 ND2P $PINS O=Px_mont[24] I1=n1317 I2=n1316
XU27 ND2P $PINS O=Px_mont[22] I1=n1297 I2=n1296
XU28 ND2S $PINS O=n291 I1=n215 I2=n7
XU29 ND2S $PINS O=n286 I1=n7 I2=n58
XU30 ND2S $PINS O=n399 I1=n202 I2=n7
XU31 ND2S $PINS O=n522 I1=n207 I2=n7
XU32 ND2P $PINS O=n256 I1=n181 I2=n7
XU34 ND2 $PINS O=n1382 I1=n181 I2=n6
XU35 AN4 $PINS O=n748 I1=n29 I2=n764 I3=n24 I4=n758
XU36 INV2 $PINS O=n762 I=n511
XU37 ND2P $PINS O=Px_mont[2] I1=n794 I2=n793
XU38 ND2P $PINS O=n517 I1=n257 I2=n66
XU39 INV1S $PINS O=n257 I=n214
XU44 INV1S $PINS O=n766 I=n565
XU45 INV1S $PINS O=n213 I=n163
XU46 ND2 $PINS O=n511 I1=n255 I2=n555
XU47 INV1S $PINS O=n178 I=state[3]
XU48 INV2 $PINS O=n4 I=n3
XU49 ND2 $PINS O=n543 I1=n172 I2=n66
XU50 INV1S $PINS O=n181 I=n177
XU51 ND2 $PINS O=n560 I1=n202 I2=n66
XU52 ND3P $PINS O=n561 I1=n25 I2=n506 I3=n1405
XU53 ND2P $PINS O=Px_mont[0] I1=n774 I2=n773
XU54 ND2 $PINS O=n1405 I1=n5 I2=n184
XU61 AN2T $PINS O=n2 I1=n765 I2=n1379
XU64 ND2 $PINS O=n501 I1=n60 I2=n1382
XU66 AN2 $PINS O=n3 I1=n202 I2=n6
XU71 ND2S $PINS O=n264 I1=n257 I2=n6
XU72 ND2S $PINS O=n289 I1=n201 I2=n6
XU73 ND2S $PINS O=n514 I1=n215 I2=n6
XU74 ND2S $PINS O=n518 I1=n6 I2=n58
XU75 ND2S $PINS O=n526 I1=n27 I2=n6
XU76 ND2S $PINS O=n546 I1=n172 I2=n6
XU77 ND2S $PINS O=n541 I1=n180 I2=n6
XU78 ND2S $PINS O=n523 I1=n184 I2=n6
XU79 ND2P $PINS O=Px_mont[23] I1=n1307 I2=n1306
XU80 ND2 $PINS O=Px_mont[19] I1=n1267 I2=n1266
XU81 ND2P $PINS O=Px_mont[25] I1=n1327 I2=n1326
XU82 ND2 $PINS O=Px_mont[21] I1=n1287 I2=n1286
XU83 OA222S $PINS O=n1317 A1=FE_OFN348_FE_OFN118_n31 A2=n1312
+ B1=FE_OFN347_FE_OFN316_n21 B2=n1311 C1=FE_OFN653_n1384 C2=n1310
XU84 OA222S $PINS O=n1297 A1=FE_OFN348_FE_OFN118_n31 A2=n1292
+ B1=FE_OFN347_FE_OFN316_n21 B2=n1291 C1=FE_OFN653_n1384 C2=n1290
XU85 ND2P $PINS O=Px_mont[26] I1=n1337 I2=n1336
XU86 OA222S $PINS O=n1337 A1=FE_OFN348_FE_OFN118_n31 A2=n1332
+ B1=FE_OFN347_FE_OFN316_n21 B2=n1331 C1=FE_OFN653_n1384 C2=n1330
XU87 ND2P $PINS O=Px_mont[20] I1=n1277 I2=n1276
XU88 OA222S $PINS O=n1277 A1=FE_OFN118_n31 A2=n1272 B1=FE_OFN347_FE_OFN316_n21
+ B2=n1271 C1=FE_OFN653_n1384 C2=n1270
XU89 OA222 $PINS O=n774 A1=n31 A2=n769 B1=FE_OFN316_n21 B2=n768 C1=n1384
+ C2=n767
XU90 AN2 $PINS O=n24 I1=n228 I2=n208
XU92 ND2 $PINS O=n163 I1=n178 I2=n194
XU93 INV2 $PINS O=n194 I=state[2]
XU95 INV1S $PINS O=n759 I=n569
XU96 AN2 $PINS O=n17 I1=n30 I2=n570
XU97 AN2 $PINS O=n29 I1=n38 I2=n509
XU98 NR2 $PINS O=n35 I1=n36 I2=n37
XU99 OR3B2 $PINS O=n401 I1=n539 B1=n1399 B2=n1405
XU100 INV1S $PINS O=n165 I=state[0]
XU101 ND2 $PINS O=n1379 I1=n207 I2=n66
XU102 INV1S $PINS O=n180 I=n170
XU103 AN4S $PINS O=n182 I1=state[5] I2=state[2] I3=n9 I4=n178
XU104 AN2 $PINS O=n58 I1=n69 I2=n213
XU105 ND2 $PINS O=n208 I1=n181 I2=n66
XU107 INV2 $PINS O=n202 I=n171
XU108 INV1S $PINS O=n184 I=n166
XU109 INV1S $PINS O=n172 I=n164
XU110 AN2 $PINS O=n66 I1=state[1] I2=n165
XU112 INV1S $PINS O=n215 I=n210
XU113 INV1S $PINS O=n573 I=a[0]
XU114 ND2P $PINS O=Px_mont[1] I1=n784 I2=n783
XU115 AN2 $PINS O=n8 I1=n5 I2=n58
XU116 INV1S $PINS O=n269 I=state[1]
XU117 ND2 $PINS O=n273 I1=n59 I2=n66
XU118 INV1S $PINS O=n221 I=GFAU_done_to_control
XU120 AN2 $PINS O=n5 I1=state[1] I2=state[0]
XU121 AN2T $PINS O=n6 I1=state[0] I2=n269
XU122 AN2 $PINS O=n7 I1=n269 I2=n165
XU124 OA222S $PINS O=n1237 A1=FE_OFN118_n31 A2=n1232 B1=FE_OFN347_FE_OFN316_n21
+ B2=n1231 C1=FE_OFN653_n1384 C2=n1230
XU125 ND2P $PINS O=Py_mont[1] I1=n582 I2=n581
XU126 AN2 $PINS O=final_done I1=n508 I2=n507
XU127 OR3B2S $PINS O=n166 I1=n176 B1=state[2] B2=n178
XU128 ND2P $PINS O=Py_mont[2] I1=n588 I2=n587
XU129 ND2P $PINS O=Py_mont[3] I1=n594 I2=n593
XU131 AN2 $PINS O=n10 I1=n4 I2=n256
XU132 ND2S $PINS O=n559 I1=n182 I2=n6
XU133 ND3 $PINS O=n37 I1=n276 I2=n275 I3=n274
XU134 INV1S $PINS O=n758 I=n212
XU135 AN4S $PINS O=n763 I1=n286 I2=n540 I3=n285 I4=n284
XU136 AN4S $PINS O=n570 I1=n523 I2=n544 I3=n522 I4=n521
XU137 ND2S $PINS O=n255 I1=n68 I2=n7
XU138 ND2S $PINS O=n506 I1=n182 I2=n7
XU139 INV1S $PINS O=n755 I=n571
XU140 ND2 $PINS O=Py_mont[0] I1=n14 I2=n15
XU145 AN3S $PINS O=n510 I1=n28 I2=n29 I3=n758
XU146 OR3B2S $PINS O=n402 I1=n511 B1=n24 B2=n220
XU147 AN3S $PINS O=n220 I1=n28 I2=n219 I3=n47
XU148 OR3B2S $PINS O=n553 I1=n571 B1=n533 B2=n18
XU149 ND3S $PINS O=n33 I1=n757 I2=n756 I3=n1379
XU150 NR2 $PINS O=n21 I1=n22 I2=n23
XU151 ND3S $PINS O=n22 I1=n759 I2=n29 I3=n758
XU152 ND3 $PINS O=n23 I1=n762 I2=n761 I3=n760
XU153 ND2S $PINS O=n530 I1=n59 I2=n7
XU154 ND2S $PINS O=n544 I1=n27 I2=n7
XU155 ND3 $PINS O=n567 I1=n11 I2=n761 I3=n756
XU156 AN2 $PINS O=n11 I1=n757 I2=n760
XU157 AN3S $PINS O=n515 I1=n514 I2=n525 I3=n521
XU158 ND3S $PINS O=n40 I1=n277 I2=n530 I3=n522
XU159 AN3S $PINS O=n527 I1=n545 I2=n526 I3=n525
XU160 ND2S $PINS O=n549 I1=n518 I2=n286
XU161 AO12 $PINS O=n12 A1=n534 B1=n295 B2=n294
XU162 AN3S $PINS O=n42 I1=n208 I2=n761 I3=n1382
XU163 ND3S $PINS O=n199 I1=n543 I2=n546 I3=n173
XU164 ND3S $PINS O=n44 I1=n556 I2=n555 I3=n20
XU165 ND3S $PINS O=n45 I1=n558 I2=n1405 I3=n557
XU166 ND3S $PINS O=n539 I1=n291 I2=n52 I3=n293
XU167 AN3S $PINS O=n48 I1=n284 I2=n521 I3=n522
XU168 AN3S $PINS O=n280 I1=n530 I2=n521 I3=n522
XU169 ND2S $PINS O=n288 I1=n763 I2=n287
XU170 ND3S $PINS O=n265 I1=n13 I2=n541 I3=n1382
XU171 AN2 $PINS O=n13 I1=n757 I2=n289
XU172 ND3S $PINS O=n54 I1=n542 I2=n286 I3=n543
XU173 ND3S $PINS O=n55 I1=n235 I2=n399 I3=n291
XU174 ND2S $PINS O=n234 I1=n297 I2=n540
XU175 ND2S $PINS O=n226 I1=n631 I2=n4
XU176 ND2S $PINS O=n244 I1=n285 I2=n276
XU177 INV1S $PINS O=n207 I=n195
XU178 OA222S $PINS O=n640 A1=FE_OFN513_n762 A2=n882 B1=FE_OFN349_FE_OFN116_n572
+ B2=n878 C1=n1433 C2=FE_OFN502_n30
XU179 OA222S $PINS O=n716 A1=FE_OFN322_n749 A2=n1324 B1=FE_OFN623_n748 B2=n1320
+ C1=FE_OFN498_n16 C2=n1322
XU180 OA222S $PINS O=n706 A1=FE_OFN322_n749 A2=n1304 B1=FE_OFN623_n748 B2=n1300
+ C1=FE_OFN498_n16 C2=n1302
XU181 ND2 $PINS O=n525 I1=n180 I2=n7
XU182 OA222S $PINS O=n681 A1=FE_OFN346_FE_OFN322_n749 A2=n1254
+ B1=FE_OFN623_n748 B2=n1250 C1=FE_OFN498_n16 C2=n1252
XU183 OA222S $PINS O=n667 A1=FE_OFN346_FE_OFN322_n749 A2=n1234
+ B1=FE_OFN623_n748 B2=n1230 C1=FE_OFN498_n16 C2=n1232
XU184 OA222S $PINS O=n657 A1=FE_OFN346_FE_OFN322_n749 A2=n1214
+ B1=FE_OFN623_n748 B2=n1210 C1=FE_OFN498_n16 C2=n1212
XU185 OA222S $PINS O=n701 A1=FE_OFN346_FE_OFN322_n749 A2=n1294
+ B1=FE_OFN623_n748 B2=n1290 C1=FE_OFN498_n16 C2=n1292
XU186 OA222S $PINS O=n646 A1=FE_OFN513_n762 A2=n1195
+ B1=FE_OFN349_FE_OFN116_n572 B2=n888 C1=n1432 C2=FE_OFN502_n30
XU187 OA222S $PINS O=n647 A1=FE_OFN346_FE_OFN322_n749 A2=n1194
+ B1=FE_OFN623_n748 B2=n887 C1=FE_OFN498_n16 C2=n1192
XU188 ND2S $PINS O=n542 I1=n172 I2=n7
XU189 OA222S $PINS O=n635 A1=FE_OFN513_n762 A2=n872 B1=FE_OFN349_FE_OFN116_n572
+ B2=n868 C1=n1434 C2=FE_OFN502_n30
XU190 OA222S $PINS O=n636 A1=FE_OFN346_FE_OFN322_n749 A2=n871 B1=FE_OFN623_n748
+ B2=n867 C1=FE_OFN498_n16 C2=n869
XU191 ND2S $PINS O=n540 I1=n184 I2=n7
XU192 ND2S $PINS O=n756 I1=n66 I2=n184
XU193 ND2S $PINS O=n757 I1=n207 I2=n6
XU194 ND2S $PINS O=n275 I1=n201 I2=n7
XU195 ND2S $PINS O=n287 I1=n180 I2=n66
XU196 ND2S $PINS O=n277 I1=n68 I2=n66
XU197 ND2S $PINS O=n509 I1=n66 I2=n27
XU198 ND2S $PINS O=n285 I1=n68 I2=n6
XU199 ND2S $PINS O=n274 I1=n215 I2=n66
XU200 ND2S $PINS O=n228 I1=n207 I2=n5
XU201 ND2S $PINS O=n296 I1=n201 I2=n66
XU202 ND2S $PINS O=n240 I1=n59 I2=n6
XU203 OA222S $PINS O=n721 A1=FE_OFN346_FE_OFN322_n749 A2=n1334
+ B1=FE_OFN623_n748 B2=n1330 C1=FE_OFN498_n16 C2=n1332
XU204 OA222S $PINS O=n711 A1=FE_OFN346_FE_OFN322_n749 A2=n1314
+ B1=FE_OFN623_n748 B2=n1310 C1=FE_OFN498_n16 C2=n1312
XU205 ND2S $PINS O=n557 I1=n257 I2=n7
XU206 ND3S $PINS O=n62 I1=n278 I2=n523 I3=n525
XU207 ND3S $PINS O=n63 I1=n1392 I2=n1405 I3=n559
XU208 AN3S $PINS O=n60 I1=n399 I2=n1392 I3=n301
XU209 OA12S $PINS O=n65 A1=n221 B1=n567 B2=n402
XU210 OA222S $PINS O=n594 A1=n749 A2=n801 B1=n748 B2=n797 C1=n16 C2=n799
XU211 OA222S $PINS O=n600 A1=n749 A2=n811 B1=n748 B2=n807 C1=n16 C2=n809
XU212 OA222S $PINS O=n582 A1=n749 A2=n781 B1=n748 B2=n777 C1=n16 C2=n779
XU213 OA222S $PINS O=n588 A1=n749 A2=n791 B1=n748 B2=n787 C1=n16 C2=n789
XU214 OA222S $PINS O=n14 A1=n749 A2=n771 B1=n748 B2=n767 C1=n16 C2=n769
XU215 OA222S $PINS O=n15 A1=n762 A2=n772 B1=n750 B2=n768 C1=n30 C2=n573
XU216 OA222S $PINS O=n606 A1=n749 A2=n821 B1=n748 B2=n817 C1=n16 C2=n819
XU217 OA222S $PINS O=n630 A1=n749 A2=n861 B1=FE_OFN623_n748 B2=n857
+ C1=FE_OFN498_n16 C2=n859
XU218 OA222S $PINS O=n618 A1=n749 A2=n841 B1=n748 B2=n837 C1=n16 C2=n839
XU219 OA222S $PINS O=n612 A1=n749 A2=n831 B1=FE_OFN623_n748 B2=n827
+ C1=FE_OFN498_n16 C2=n829
XU220 OA222S $PINS O=n624 A1=n749 A2=n851 B1=FE_OFN623_n748 B2=n847
+ C1=FE_OFN498_n16 C2=n849
XU247 INV1S $PINS O=n300 I=n402
XU256 AN4 $PINS O=n1384 I1=n766 I2=n765 I3=n764 I4=n763
XU257 INV1S $PINS O=n764 I=n529
XU258 AN2 $PINS O=n16 I1=n35 I2=n759
XU259 INV1S $PINS O=n765 I=n561
XU265 INV1S $PINS O=n533 I=n512
XU266 INV1S $PINS O=n513 I=n544
XU267 INV1S $PINS O=n536 I=n567
XU268 AN2 $PINS O=n18 I1=n26 I2=n35
XU270 AN2 $PINS O=n19 I1=n399 I2=n1379
XU272 INV1S $PINS O=n71 I=n12
XU273 INV1S $PINS O=n534 I=n401
XU274 INV1S $PINS O=n97 I=n742
XU275 INV1S $PINS O=n556 I=n539
XU276 AN2 $PINS O=n20 I1=n219 I2=n278
XU281 INV1S $PINS O=n500 I=n302
XU292 AN2 $PINS O=n25 I1=n559 I2=n299
XU293 AN2 $PINS O=n26 I1=n273 I2=n272
XU294 AN2 $PINS O=n27 I1=n169 I2=n213
XU295 AN2 $PINS O=n28 I1=n558 I2=n291
XU296 INV1S $PINS O=n531 I=n525
XU297 AN2 $PINS O=n30 I1=n240 I2=n543
XU298 NR2P $PINS O=n31 I1=n32 I2=n33
XU299 ND3 $PINS O=n32 I1=n35 I2=n755 I3=n17
XU300 AN2 $PINS O=n34 I1=n514 I2=n546
XU301 ND3 $PINS O=n36 I1=n541 I2=n526 I3=n542
XU302 INV1S $PINS O=n211 I=n296
XU303 AN2 $PINS O=n38 I1=n287 I2=n297
XU305 AN4S $PINS O=n528 I1=n755 I2=n524 I3=n570 I4=n541
XU306 AN4S $PINS O=n524 I1=n275 I2=n514 I3=n517 I4=n274
XU307 INV1S $PINS O=n241 I=n545
XU308 AN2B1S $PINS O=n39 I1=n242 B1=n40
XU309 INV1S $PINS O=n191 I=n631
XU310 OA12 $PINS O=n41 A1=n61 B1=n64 B2=n552
XU311 INV1S $PINS O=n1380 I=n562
XU312 AO13 $PINS O=n396 A1=n71 B1=n762 B2=n297 B3=n296
XU313 AN4S $PINS O=n293 I1=n47 I2=n19 I3=n292 I4=n4
XU315 AO13S $PINS O=n742 A1=n534 B1=n537 B2=n536 B3=n535
XU316 INV1S $PINS O=n535 I=n553
XU317 INV1S $PINS O=n537 I=n532
XU318 AN4S $PINS O=n551 I1=n29 I2=n556 I3=n541 I4=n540
XU319 AN4B1S $PINS O=n278 I1=n42 I2=n299 I3=n756 B1=n179
XU320 AN4B1S $PINS O=n250 I1=n509 I2=n46 I3=n544 B1=n168
XU321 INV1S $PINS O=n167 I=n549
XU322 INV1S $PINS O=n1435 I=load_done
XU323 INV1S $PINS O=n292 I=n229
XU324 INV1S $PINS O=n225 I=n285
XU325 NR2 $PINS O=n43 I1=n44 I2=n45
XU326 AN2 $PINS O=n46 I1=n272 I2=n526
XU327 AN2 $PINS O=n47 I1=n218 I2=n217
XU328 AN4B1S $PINS O=n219 I1=n250 I2=n38 I3=n541 B1=n175
XU329 INV1S $PINS O=n174 I=n199
XU332 INV1S $PINS O=n504 I=n517
XU333 AN4S $PINS O=n548 I1=n545 I2=n544 I3=n543 I4=n542
XU334 NR2 $PINS O=n49 I1=n50 I2=n51
XU335 ND3 $PINS O=n50 I1=n56 I2=n253 I3=n509
XU336 ND3 $PINS O=n51 I1=n273 I2=n756 I3=n517
XU337 AN4S $PINS O=n253 I1=n761 I2=n277 I3=n223 I4=n274
XU338 INV1S $PINS O=n1398 I=n1405
XU339 INV1S $PINS O=n547 I=n546
XU340 INV1S $PINS O=n198 I=n265
XU341 AN2 $PINS O=n52 I1=n255 I2=n757
XU342 INV1S $PINS O=n266 I=n227
XU343 NR2 $PINS O=n53 I1=n54 I2=n55
XU344 NR3 $PINS O=n56 I1=n211 I2=n197 I3=n196
XU345 INV1S $PINS O=n258 I=n506
XU346 AN2 $PINS O=n57 I1=n239 I2=n238
XU347 INV1S $PINS O=n1393 I=n264
XU353 AN2 $PINS O=n59 I1=n203 I2=n209
XU354 INV1S $PINS O=n169 I=n176
XU355 INV1S $PINS O=n520 I=operation_select[0]
XU356 INV1S $PINS O=n507 I=n674
XU357 INV1S $PINS O=n508 I=n559
XU358 AN4S $PINS O=n1408 I1=n43 I2=Transfer_done_w0 I3=n559 I4=n1392
XU359 AN4B1S $PINS O=n1399 I1=n1392 I2=n20 I3=n555 B1=n183
XU360 INV1S $PINS O=n1395 I=n1394
XU361 INV1S $PINS O=n1411 I=key_from_key_shift[1]
XU362 NR2 $PINS O=n61 I1=n62 I2=n63
XU363 AN2 $PINS O=n64 I1=n282 I2=n281
XU364 INV1S $PINS O=n1412 I=key_from_key_shift[0]
XU365 NR2 $PINS O=n668 I1=n1409 I2=n631
XU366 INV1S $PINS O=n267 I=n523
XU367 INV1S $PINS O=n1409 I=n236
XU368 AN2 $PINS O=n645 I1=n673 I2=n674
XU369 INV1S $PINS O=n186 I=n248
XU372 INV1S $PINS O=n592 I=a[3]
XU373 INV1S $PINS O=n604 I=a[5]
XU374 INV1S $PINS O=n616 I=a[7]
XU375 INV1S $PINS O=n628 I=a[9]
XU376 INV1S $PINS O=n598 I=a[4]
XU377 INV1S $PINS O=n580 I=a[1]
XU378 INV1S $PINS O=n586 I=a[2]
XU379 INV1S $PINS O=n622 I=a[8]
XU380 INV1S $PINS O=n610 I=a[6]
XU381 AN2 $PINS O=n67 I1=state[3] I2=n251
XU382 AN2 $PINS O=n68 I1=n203 I2=n9
XU383 AN2 $PINS O=n69 I1=state[5] I2=n9
XU384 INV1S $PINS O=n203 I=n193
XU385 INV1S $PINS O=n768 I=r2[0]
XU386 INV1S $PINS O=n772 I=x2[0]
XU387 INV1S $PINS O=n769 I=r1[0]
XU388 INV1S $PINS O=n770 I=y2[0]
XU389 INV1S $PINS O=n777 I=x1[1]
XU390 INV1S $PINS O=n767 I=x1[0]
XU391 INV1S $PINS O=n787 I=x1[2]
XU392 INV1S $PINS O=n771 I=y1[0]
XU393 INV1S $PINS O=n1371 I=r2[30]
XU394 INV1S $PINS O=n1361 I=r2[29]
XU395 INV1S $PINS O=n1351 I=r2[28]
XU396 INV1S $PINS O=n1341 I=r2[27]
XU397 INV1S $PINS O=n1331 I=r2[26]
XU398 INV1S $PINS O=n1321 I=r2[25]
XU399 INV1S $PINS O=n1311 I=r2[24]
XU400 INV1S $PINS O=n1301 I=r2[23]
XU401 INV1S $PINS O=n1291 I=r2[22]
XU402 INV1S $PINS O=n1281 I=r2[21]
XU403 INV1S $PINS O=n1271 I=r2[20]
XU404 INV1S $PINS O=n1261 I=r2[19]
XU405 INV1S $PINS O=n1251 I=r2[18]
XU406 INV1S $PINS O=n1241 I=r2[17]
XU407 INV1S $PINS O=n1231 I=r2[16]
XU408 INV1S $PINS O=n1221 I=r2[15]
XU409 INV1S $PINS O=n1211 I=r2[14]
XU410 INV1S $PINS O=n1201 I=r2[13]
XU411 INV1S $PINS O=n888 I=r2[12]
XU412 INV1S $PINS O=n878 I=r2[11]
XU413 INV1S $PINS O=n868 I=r2[10]
XU414 INV1S $PINS O=n858 I=r2[9]
XU415 INV1S $PINS O=n848 I=r2[8]
XU416 INV1S $PINS O=n838 I=r2[7]
XU417 INV1S $PINS O=n828 I=r2[6]
XU418 INV1S $PINS O=n818 I=r2[5]
XU419 INV1S $PINS O=n808 I=r2[4]
XU420 INV1S $PINS O=n798 I=r2[3]
XU421 INV1S $PINS O=n788 I=r2[2]
XU422 INV1S $PINS O=n778 I=r2[1]
XU423 INV1S $PINS O=n1385 I=r2[31]
XU424 INV1S $PINS O=n1375 I=x2[30]
XU425 INV1S $PINS O=n1365 I=x2[29]
XU426 INV1S $PINS O=n1355 I=x2[28]
XU427 INV1S $PINS O=n1345 I=x2[27]
XU428 INV1S $PINS O=n1335 I=x2[26]
XU429 INV1S $PINS O=n1325 I=x2[25]
XU430 INV1S $PINS O=n1315 I=x2[24]
XU431 INV1S $PINS O=n1305 I=x2[23]
XU432 INV1S $PINS O=n1295 I=x2[22]
XU433 INV1S $PINS O=n1285 I=x2[21]
XU434 INV1S $PINS O=n1275 I=x2[20]
XU435 INV1S $PINS O=n1265 I=x2[19]
XU436 INV1S $PINS O=n1255 I=x2[18]
XU437 INV1S $PINS O=n1245 I=x2[17]
XU438 INV1S $PINS O=n1235 I=x2[16]
XU439 INV1S $PINS O=n1225 I=x2[15]
XU440 INV1S $PINS O=n1215 I=x2[14]
XU441 INV1S $PINS O=n1205 I=x2[13]
XU442 INV1S $PINS O=n1195 I=x2[12]
XU443 INV1S $PINS O=n882 I=x2[11]
XU444 INV1S $PINS O=n872 I=x2[10]
XU445 INV1S $PINS O=n862 I=x2[9]
XU446 INV1S $PINS O=n852 I=x2[8]
XU447 INV1S $PINS O=n842 I=x2[7]
XU448 INV1S $PINS O=n832 I=x2[6]
XU449 INV1S $PINS O=n822 I=x2[5]
XU450 INV1S $PINS O=n812 I=x2[4]
XU451 INV1S $PINS O=n802 I=x2[3]
XU452 INV1S $PINS O=n792 I=x2[2]
XU453 INV1S $PINS O=n782 I=x2[1]
XU454 INV1S $PINS O=n1389 I=x2[31]
XU455 INV1S $PINS O=n1372 I=r1[30]
XU456 INV1S $PINS O=n1362 I=r1[29]
XU457 INV1S $PINS O=n1352 I=r1[28]
XU458 INV1S $PINS O=n1342 I=r1[27]
XU459 INV1S $PINS O=n1332 I=r1[26]
XU460 INV1S $PINS O=n1322 I=r1[25]
XU461 INV1S $PINS O=n1312 I=r1[24]
XU462 INV1S $PINS O=n1302 I=r1[23]
XU463 INV1S $PINS O=n1292 I=r1[22]
XU464 INV1S $PINS O=n1282 I=r1[21]
XU465 INV1S $PINS O=n1272 I=r1[20]
XU466 INV1S $PINS O=n1262 I=r1[19]
XU467 INV1S $PINS O=n1252 I=r1[18]
XU468 INV1S $PINS O=n1242 I=r1[17]
XU469 INV1S $PINS O=n1232 I=r1[16]
XU470 INV1S $PINS O=n1222 I=r1[15]
XU471 INV1S $PINS O=n1212 I=r1[14]
XU472 INV1S $PINS O=n1202 I=r1[13]
XU473 INV1S $PINS O=n1192 I=r1[12]
XU474 INV1S $PINS O=n879 I=r1[11]
XU475 INV1S $PINS O=n869 I=r1[10]
XU476 INV1S $PINS O=n859 I=r1[9]
XU477 INV1S $PINS O=n849 I=r1[8]
XU478 INV1S $PINS O=n839 I=r1[7]
XU479 INV1S $PINS O=n829 I=r1[6]
XU480 INV1S $PINS O=n819 I=r1[5]
XU481 INV1S $PINS O=n809 I=r1[4]
XU482 INV1S $PINS O=n799 I=r1[3]
XU483 INV1S $PINS O=n789 I=r1[2]
XU484 INV1S $PINS O=n779 I=r1[1]
XU485 INV1S $PINS O=n1386 I=r1[31]
XU486 INV1S $PINS O=n1373 I=y2[30]
XU487 INV1S $PINS O=n1363 I=y2[29]
XU488 INV1S $PINS O=n1353 I=y2[28]
XU489 INV1S $PINS O=n1343 I=y2[27]
XU490 INV1S $PINS O=n1333 I=y2[26]
XU491 INV1S $PINS O=n1323 I=y2[25]
XU492 INV1S $PINS O=n1313 I=y2[24]
XU493 INV1S $PINS O=n1303 I=y2[23]
XU494 INV1S $PINS O=n1293 I=y2[22]
XU495 INV1S $PINS O=n1283 I=y2[21]
XU496 INV1S $PINS O=n1273 I=y2[20]
XU497 INV1S $PINS O=n1263 I=y2[19]
XU498 INV1S $PINS O=n1253 I=y2[18]
XU499 INV1S $PINS O=n1243 I=y2[17]
XU500 INV1S $PINS O=n1233 I=y2[16]
XU501 INV1S $PINS O=n1223 I=y2[15]
XU502 INV1S $PINS O=n1213 I=y2[14]
XU503 INV1S $PINS O=n1203 I=y2[13]
XU504 INV1S $PINS O=n1193 I=y2[12]
XU505 INV1S $PINS O=n880 I=y2[11]
XU506 INV1S $PINS O=n870 I=y2[10]
XU507 INV1S $PINS O=n860 I=y2[9]
XU508 INV1S $PINS O=n850 I=y2[8]
XU509 INV1S $PINS O=n840 I=y2[7]
XU510 INV1S $PINS O=n830 I=y2[6]
XU511 INV1S $PINS O=n820 I=y2[5]
XU512 INV1S $PINS O=n810 I=y2[4]
XU513 INV1S $PINS O=n800 I=y2[3]
XU514 INV1S $PINS O=n790 I=y2[2]
XU515 INV1S $PINS O=n780 I=y2[1]
XU516 INV1S $PINS O=n1387 I=y2[31]
XU517 INV1S $PINS O=n807 I=x1[4]
XU518 INV1S $PINS O=n867 I=x1[10]
XU519 INV1S $PINS O=n1230 I=x1[16]
XU520 INV1S $PINS O=n1270 I=x1[20]
XU521 INV1S $PINS O=n1290 I=x1[22]
XU522 INV1S $PINS O=n1350 I=x1[28]
XU523 INV1S $PINS O=n1370 I=x1[30]
XU524 INV1S $PINS O=n1210 I=x1[14]
XU525 INV1S $PINS O=n1220 I=x1[15]
XU526 INV1S $PINS O=n1330 I=x1[26]
XU527 INV1S $PINS O=n1310 I=x1[24]
XU528 INV1S $PINS O=n1383 I=x1[31]
XU529 INV1S $PINS O=n797 I=x1[3]
XU530 INV1S $PINS O=n837 I=x1[7]
XU531 INV1S $PINS O=n817 I=x1[5]
XU532 INV1S $PINS O=n1340 I=x1[27]
XU533 INV1S $PINS O=n1320 I=x1[25]
XU534 INV1S $PINS O=n1250 I=x1[18]
XU535 INV1S $PINS O=n1260 I=x1[19]
XU536 INV1S $PINS O=n1200 I=x1[13]
XU537 INV1S $PINS O=n887 I=x1[12]
XU538 INV1S $PINS O=n877 I=x1[11]
XU539 INV1S $PINS O=n847 I=x1[8]
XU540 INV1S $PINS O=n857 I=x1[9]
XU541 INV1S $PINS O=n827 I=x1[6]
XU542 INV1S $PINS O=n1240 I=x1[17]
XU543 INV1S $PINS O=n1300 I=x1[23]
XU544 INV1S $PINS O=n1280 I=x1[21]
XU545 INV1S $PINS O=n1360 I=x1[29]
XU546 INV1S $PINS O=n781 I=y1[1]
XU547 INV1S $PINS O=n811 I=y1[4]
XU548 INV1S $PINS O=n871 I=y1[10]
XU549 INV1S $PINS O=n1234 I=FE_PHN1604_y1_16
XU550 INV1S $PINS O=n1274 I=y1[20]
XU551 INV1S $PINS O=n1294 I=y1[22]
XU552 INV1S $PINS O=n1354 I=y1[28]
XU553 INV1S $PINS O=n1374 I=y1[30]
XU554 INV1S $PINS O=n1214 I=y1[14]
XU555 INV1S $PINS O=n1224 I=FE_PHN1605_y1_15
XU556 INV1S $PINS O=n1334 I=y1[26]
XU557 INV1S $PINS O=n1314 I=y1[24]
XU558 INV1S $PINS O=n1388 I=y1[31]
XU559 INV1S $PINS O=n791 I=y1[2]
XU560 INV1S $PINS O=n801 I=y1[3]
XU561 INV1S $PINS O=n841 I=y1[7]
XU562 INV1S $PINS O=n821 I=y1[5]
XU563 INV1S $PINS O=n1344 I=y1[27]
XU564 INV1S $PINS O=n1324 I=y1[25]
XU565 INV1S $PINS O=n1254 I=y1[18]
XU566 INV1S $PINS O=n1264 I=y1[19]
XU567 INV1S $PINS O=n1204 I=y1[13]
XU568 INV1S $PINS O=n1194 I=y1[12]
XU569 INV1S $PINS O=n881 I=y1[11]
XU570 INV1S $PINS O=n851 I=y1[8]
XU571 INV1S $PINS O=n861 I=y1[9]
XU572 INV1S $PINS O=n831 I=y1[6]
XU573 INV1S $PINS O=n1244 I=y1[17]
XU574 INV1S $PINS O=n1304 I=y1[23]
XU575 INV1S $PINS O=n1284 I=y1[21]
XU576 INV1S $PINS O=n1364 I=y1[29]
XU577 INV1S $PINS O=n1434 I=a[10]
XU578 INV1S $PINS O=n1428 I=a[16]
XU579 INV1S $PINS O=n1424 I=a[20]
XU580 INV1S $PINS O=n1422 I=a[22]
XU581 INV1S $PINS O=n1430 I=a[14]
XU582 INV1S $PINS O=n1429 I=a[15]
XU583 INV1S $PINS O=n1420 I=a[24]
XU584 INV1S $PINS O=n1419 I=a[25]
XU585 INV1S $PINS O=n1426 I=a[18]
XU586 INV1S $PINS O=n1425 I=a[19]
XU587 INV1S $PINS O=n1431 I=a[13]
XU588 INV1S $PINS O=n1432 I=a[12]
XU589 INV1S $PINS O=n1433 I=a[11]
XU590 INV1S $PINS O=n1427 I=a[17]
XU591 INV1S $PINS O=n1421 I=a[23]
XU592 INV1S $PINS O=n1423 I=a[21]
XU594 INV1S $PINS O=n564 I=Px_out_from_look[0]
XU596 INV1S $PINS O=n754 I=Py_out_from_look[0]
XU598 INV1S $PINS O=n729 I=Px_out_from_look[28]
XU599 INV1S $PINS O=n728 I=i1_w[28]
XU600 INV1S $PINS O=n689 I=Px_out_from_look[20]
XU601 INV1S $PINS O=n688 I=i1_w[20]
XU602 INV1S $PINS O=n644 I=Px_out_from_look[12]
XU603 INV1S $PINS O=n643 I=i1_w[12]
XU604 INV1S $PINS O=n1349 I=Py_out_from_look[28]
XU605 INV1S $PINS O=n1348 I=i2_w[28]
XU606 INV1S $PINS O=n1269 I=Py_out_from_look[20]
XU607 INV1S $PINS O=n1268 I=i2_w[20]
XU608 INV1S $PINS O=n886 I=Py_out_from_look[12]
XU609 INV1S $PINS O=n885 I=i2_w[12]
XU610 INV1S $PINS O=n665 I=Px_out_from_look[16]
XU611 INV1S $PINS O=n664 I=i1_w[16]
XU612 INV1S $PINS O=n1229 I=Py_out_from_look[16]
XU613 INV1S $PINS O=n1228 I=i2_w[16]
XU614 INV1S $PINS O=n699 I=Px_out_from_look[22]
XU615 INV1S $PINS O=n698 I=i1_w[22]
XU616 INV1S $PINS O=n679 I=Px_out_from_look[18]
XU617 INV1S $PINS O=n678 I=i1_w[18]
XU618 INV1S $PINS O=n655 I=Px_out_from_look[14]
XU619 INV1S $PINS O=n654 I=i1_w[14]
XU620 INV1S $PINS O=n1289 I=Py_out_from_look[22]
XU621 INV1S $PINS O=n1288 I=i2_w[22]
XU622 INV1S $PINS O=n1249 I=Py_out_from_look[18]
XU623 INV1S $PINS O=n1248 I=i2_w[18]
XU624 INV1S $PINS O=n1209 I=Py_out_from_look[14]
XU625 INV1S $PINS O=n1208 I=i2_w[14]
XU626 INV1S $PINS O=n719 I=Px_out_from_look[26]
XU627 INV1S $PINS O=n718 I=i1_w[26]
XU628 INV1S $PINS O=n709 I=Px_out_from_look[24]
XU629 INV1S $PINS O=n708 I=i1_w[24]
XU630 INV1S $PINS O=n634 I=Px_out_from_look[10]
XU631 INV1S $PINS O=n633 I=i1_w[10]
XU632 INV1S $PINS O=n621 I=Px_out_from_look[8]
XU633 INV1S $PINS O=n620 I=i1_w[8]
XU634 INV1S $PINS O=n609 I=Px_out_from_look[6]
XU635 INV1S $PINS O=n608 I=i1_w[6]
XU636 INV1S $PINS O=n597 I=Px_out_from_look[4]
XU637 INV1S $PINS O=n596 I=i1_w[4]
XU638 INV1S $PINS O=n585 I=Px_out_from_look[2]
XU639 INV1S $PINS O=n584 I=i1_w[2]
XU640 INV1S $PINS O=n1329 I=Py_out_from_look[26]
XU641 INV1S $PINS O=n1328 I=i2_w[26]
XU642 INV1S $PINS O=n1309 I=Py_out_from_look[24]
XU643 INV1S $PINS O=n1308 I=i2_w[24]
XU644 INV1S $PINS O=n866 I=Py_out_from_look[10]
XU645 INV1S $PINS O=n865 I=i2_w[10]
XU646 INV1S $PINS O=n846 I=Py_out_from_look[8]
XU647 INV1S $PINS O=n845 I=i2_w[8]
XU648 INV1S $PINS O=n826 I=Py_out_from_look[6]
XU649 INV1S $PINS O=n825 I=i2_w[6]
XU650 INV1S $PINS O=n806 I=Py_out_from_look[4]
XU651 INV1S $PINS O=n805 I=i2_w[4]
XU652 INV1S $PINS O=n786 I=Py_out_from_look[2]
XU653 INV1S $PINS O=n785 I=i2_w[2]
XU654 INV1S $PINS O=n734 I=Px_out_from_look[29]
XU656 INV1S $PINS O=n1359 I=Py_out_from_look[29]
XU658 INV1S $PINS O=n739 I=Px_out_from_look[30]
XU659 INV1S $PINS O=n738 I=i1_w[30]
XU660 INV1S $PINS O=n724 I=Px_out_from_look[27]
XU662 INV1S $PINS O=n714 I=Px_out_from_look[25]
XU664 INV1S $PINS O=n704 I=Px_out_from_look[23]
XU666 INV1S $PINS O=n694 I=Px_out_from_look[21]
XU668 INV1S $PINS O=n684 I=Px_out_from_look[19]
XU670 INV1S $PINS O=n671 I=Px_out_from_look[17]
XU672 INV1S $PINS O=n660 I=Px_out_from_look[15]
XU674 INV1S $PINS O=n650 I=Px_out_from_look[13]
XU676 INV1S $PINS O=n639 I=Px_out_from_look[11]
XU678 INV1S $PINS O=n627 I=Px_out_from_look[9]
XU680 INV1S $PINS O=n615 I=Px_out_from_look[7]
XU682 INV1S $PINS O=n603 I=Px_out_from_look[5]
XU684 INV1S $PINS O=n591 I=Px_out_from_look[3]
XU686 INV1S $PINS O=n579 I=Px_out_from_look[1]
XU688 INV1S $PINS O=n1369 I=Py_out_from_look[30]
XU689 INV1S $PINS O=n1368 I=i2_w[30]
XU690 INV1S $PINS O=n1339 I=Py_out_from_look[27]
XU692 INV1S $PINS O=n1319 I=Py_out_from_look[25]
XU694 INV1S $PINS O=n1299 I=Py_out_from_look[23]
XU696 INV1S $PINS O=n1279 I=Py_out_from_look[21]
XU698 INV1S $PINS O=n1259 I=Py_out_from_look[19]
XU700 INV1S $PINS O=n1239 I=Py_out_from_look[17]
XU702 INV1S $PINS O=n1219 I=Py_out_from_look[15]
XU704 INV1S $PINS O=n1199 I=Py_out_from_look[13]
XU706 INV1S $PINS O=n876 I=Py_out_from_look[11]
XU708 INV1S $PINS O=n856 I=Py_out_from_look[9]
XU710 INV1S $PINS O=n836 I=Py_out_from_look[7]
XU712 INV1S $PINS O=n816 I=Py_out_from_look[5]
XU714 INV1S $PINS O=n796 I=Py_out_from_look[3]
XU716 INV1S $PINS O=n776 I=Py_out_from_look[1]
XU718 INV1S $PINS O=n747 I=Px_out_from_look[31]
XU719 INV1S $PINS O=n746 I=i1_w[31]
XU720 INV1S $PINS O=n1381 I=Py_out_from_look[31]
XU721 INV1S $PINS O=n1378 I=i2_w[31]
XU724 INV1S $PINS O=n335 I=FE_PHN1235_x3_w_20
XU726 INV1S $PINS O=n329 I=x3_w[22]
XU728 INV1S $PINS O=n323 I=x3_w[24]
XU730 INV1S $PINS O=n317 I=FE_PHN1168_x3_w_26
XU732 INV1S $PINS O=FE_PHN1156_n311 I=x3_w[28]
XU735 INV1S $PINS O=n389 I=x3_w[2]
XU737 INV1S $PINS O=n383 I=FE_PHN1130_x3_w_4
XU741 INV1S $PINS O=FE_PHN1128_n371 I=x3_w[8]
XU743 INV1S $PINS O=n365 I=x3_w[10]
XU745 INV1S $PINS O=n359 I=FE_PHN1225_x3_w_12
XU747 INV1S $PINS O=n353 I=FE_PHN1262_x3_w_14
XU749 INV1S $PINS O=n347 I=FE_PHN1159_x3_w_16
XU751 INV1S $PINS O=n341 I=x3_w[18]
XU753 INV1S $PINS O=n490 I=y3_w[2]
XU757 INV1S $PINS O=FE_PHN1174_n484 I=y3_w[4]
XU760 INV1S $PINS O=n472 I=y3_w[8]
XU762 INV1S $PINS O=n454 I=y3_w[14]
XU763 INV1S $PINS O=n406 I=y3_w[30]
XU764 INV1S $PINS O=n448 I=y3_w[16]
XU765 INV1S $PINS O=n460 I=y3_w[12]
XU766 INV1S $PINS O=n412 I=y3_w[28]
XU767 INV1S $PINS O=n305 I=FE_PHN1192_x3_w_30
XU768 INV1S $PINS O=n436 I=y3_w[20]
XU769 INV1S $PINS O=n466 I=y3_w[10]
XU770 INV1S $PINS O=n442 I=y3_w[18]
XU771 INV1S $PINS O=n430 I=y3_w[22]
XU772 INV1S $PINS O=n424 I=y3_w[24]
XU773 INV1S $PINS O=n418 I=y3_w[26]
XU786 NR3 $PINS O=n673 I1=counter[1] I2=counter[2] I3=FE_PHN1167_counter_0
XU787 XOR2HS $PINS O=n1150 I1=counter[2] I2=n576
XU788 XNR2HS $PINS O=n1151 I1=FE_PHN1489_counter_1 I2=n577
XU789 XNR2HS $PINS O=n1149 I1=counter[3] I2=n575
XU790 MOAI1S $PINS O=n1174 A1=FE_OFN520_n1408 A2=n1434 B1=transferred_a_w0[10]
+ B2=FE_OFN520_n1408
XU791 MOAI1S $PINS O=n1173 A1=FE_OFN520_n1408 A2=n1433 B1=transferred_a_w0[11]
+ B2=FE_OFN520_n1408
XU792 MOAI1S $PINS O=n1172 A1=FE_OFN521_n1408 A2=FE_PHN1184_n1432
+ B1=transferred_a_w0[12] B2=FE_OFN521_n1408
XU793 MOAI1S $PINS O=n1171 A1=FE_OFN521_n1408 A2=FE_PHN1063_n1431
+ B1=transferred_a_w0[13] B2=FE_OFN521_n1408
XU794 MOAI1S $PINS O=n1170 A1=FE_OFN521_n1408 A2=FE_PHN1164_n1430
+ B1=transferred_a_w0[14] B2=FE_OFN521_n1408
XU795 MOAI1S $PINS O=n1169 A1=FE_OFN521_n1408 A2=FE_PHN836_n1429
+ B1=transferred_a_w0[15] B2=FE_OFN521_n1408
XU796 MOAI1S $PINS O=n1168 A1=FE_OFN521_n1408 A2=FE_PHN1194_n1428
+ B1=transferred_a_w0[16] B2=FE_OFN521_n1408
XU797 MOAI1S $PINS O=n1167 A1=FE_OFN520_n1408 A2=FE_PHN1083_n1427
+ B1=transferred_a_w0[17] B2=FE_OFN520_n1408
XU798 MOAI1S $PINS O=n1166 A1=FE_OFN521_n1408 A2=n1426 B1=transferred_a_w0[18]
+ B2=FE_OFN521_n1408
XU799 MOAI1S $PINS O=n1165 A1=FE_OFN521_n1408 A2=FE_PHN1012_n1425
+ B1=transferred_a_w0[19] B2=FE_OFN521_n1408
XU800 MOAI1S $PINS O=n1164 A1=n1408 A2=FE_PHN1182_n1424 B1=transferred_a_w0[20]
+ B2=n1408
XU801 MOAI1S $PINS O=n1163 A1=n1408 A2=FE_PHN986_n1423 B1=transferred_a_w0[21]
+ B2=n1408
XU802 MOAI1S $PINS O=n1162 A1=n1408 A2=n1422 B1=transferred_a_w0[22] B2=n1408
XU803 MOAI1S $PINS O=n1161 A1=n1408 A2=FE_PHN1079_n1421 B1=transferred_a_w0[23]
+ B2=n1408
XU804 MOAI1S $PINS O=n1160 A1=FE_OFN519_n1408 A2=FE_PHN1205_n1420
+ B1=transferred_a_w0[24] B2=FE_OFN519_n1408
XU805 MOAI1S $PINS O=n1159 A1=FE_OFN519_n1408 A2=FE_PHN1140_n1419
+ B1=transferred_a_w0[25] B2=FE_OFN519_n1408
XU806 MOAI1S $PINS O=n1158 A1=FE_OFN519_n1408 A2=FE_PHN1180_n1418
+ B1=transferred_a_w0[26] B2=FE_OFN519_n1408
XU807 MOAI1S $PINS O=n1157 A1=FE_OFN519_n1408 A2=FE_PHN1150_n1417
+ B1=transferred_a_w0[27] B2=FE_OFN519_n1408
XU808 MOAI1S $PINS O=n1156 A1=FE_OFN519_n1408 A2=FE_PHN1217_n1416
+ B1=transferred_a_w0[28] B2=FE_OFN519_n1408
XU809 MOAI1S $PINS O=n1155 A1=FE_OFN519_n1408 A2=FE_PHN1071_n1415
+ B1=transferred_a_w0[29] B2=FE_OFN519_n1408
XU810 MOAI1S $PINS O=n1154 A1=FE_OFN519_n1408 A2=FE_PHN1185_n1414
+ B1=transferred_a_w0[30] B2=FE_OFN519_n1408
XU811 MOAI1S $PINS O=n1153 A1=FE_OFN519_n1408 A2=n1413 B1=transferred_a_w0[31]
+ B2=FE_OFN519_n1408
XU812 INV1S $PINS O=n1416 I=a[28]
XU813 INV1S $PINS O=n1414 I=a[30]
XU814 INV1S $PINS O=n1418 I=a[26]
XU815 INV1S $PINS O=n1413 I=a[31]
XU816 INV1S $PINS O=n1417 I=a[27]
XU817 INV1S $PINS O=n1415 I=a[29]
XU818 INV1S $PINS O=n1404 I=n1403
XU819 INV1S $PINS O=n188 I=n187
XU820 AN3B2S $PINS O=n675 I1=FE_PHN1132_key_counter_3 B1=key_counter[0]
+ B2=n1407
XU821 INV1S $PINS O=n574 I=GFAU_out[1]
XU822 INV1S $PINS O=n637 I=GFAU_out[11]
XU823 INV1S $PINS O=n669 I=GFAU_out[17]
XU824 INV1S $PINS O=n712 I=GFAU_out[25]
XU825 INV1S $PINS O=n722 I=GFAU_out[27]
XU826 INV1S $PINS O=n601 I=GFAU_out[5]
XU827 INV1S $PINS O=n613 I=GFAU_out[7]
XU828 INV1S $PINS O=n625 I=GFAU_out[9]
XU829 INV1S $PINS O=n744 I=GFAU_out[31]
XU830 INV1S $PINS O=n554 I=GFAU_out[0]
XU831 INV1S $PINS O=n648 I=GFAU_out[13]
XU832 INV1S $PINS O=n692 I=GFAU_out[21]
XU833 INV1S $PINS O=n732 I=GFAU_out[29]
XU834 INV1S $PINS O=n1407 I=key_counter[4]
XU835 INV1S $PINS O=n589 I=GFAU_out[3]
XU836 INV1S $PINS O=n658 I=GFAU_out[15]
XU837 INV1S $PINS O=n682 I=GFAU_out[19]
XU838 INV1S $PINS O=n702 I=GFAU_out[23]
XU839 INV1S $PINS O=n583 I=GFAU_out[2]
XU840 INV1S $PINS O=n595 I=GFAU_out[4]
XU841 INV1S $PINS O=n607 I=GFAU_out[6]
XU842 INV1S $PINS O=n619 I=GFAU_out[8]
XU843 INV1S $PINS O=n632 I=GFAU_out[10]
XU844 INV1S $PINS O=n642 I=GFAU_out[12]
XU845 INV1S $PINS O=n653 I=GFAU_out[14]
XU846 INV1S $PINS O=n663 I=GFAU_out[16]
XU847 INV1S $PINS O=n677 I=GFAU_out[18]
XU848 INV1S $PINS O=n687 I=GFAU_out[20]
XU849 INV1S $PINS O=n697 I=GFAU_out[22]
XU850 INV1S $PINS O=n707 I=GFAU_out[24]
XU851 INV1S $PINS O=n717 I=GFAU_out[26]
XU852 INV1S $PINS O=n727 I=GFAU_out[28]
XU853 INV1S $PINS O=n737 I=GFAU_out[30]
XU854 INV1S $PINS O=n185 I=key_counter[0]
XU855 INV1S $PINS O=n1396 I=FE_PHN1171_key_counter_1
XU856 INV1S $PINS O=n1401 I=n1397
XU858 TIE1 $PINS O=*Logic1*
XU859 TIE0 $PINS O=net484
XU860 OAI112HS $PINS O=n1392 A1=n163 B1=n69 C1=state[3] C2=state[1]
XU861 ND2 $PINS O=n176 I1=state[5] I2=n209
XU862 OR3B2 $PINS O=n164 I1=n209 B1=state[2] B2=n67
XU863 ND2 $PINS O=n272 I1=n5 I2=n172
XU864 ND2 $PINS O=n168 I1=n523 I2=n167
XU865 OR3B2 $PINS O=n170 I1=n194 B1=state[3] B2=n169
XU866 ND2 $PINS O=n297 I1=n5 I2=n27
XU867 OR3B2 $PINS O=n171 I1=n209 B1=n67 B2=n194
XU868 ND2 $PINS O=n545 I1=n202 I2=n5
XU869 AN3 $PINS O=n173 I1=n525 I2=n545 I3=n542
XU870 ND2 $PINS O=n175 I1=n540 I2=n174
XU871 OR3B2 $PINS O=n177 I1=n176 B1=state[3] B2=n194
XU872 ND2 $PINS O=n761 I1=n66 I2=n58
XU873 ND2 $PINS O=n179 I1=n256 I2=n506
XU874 ND2 $PINS O=n555 I1=n180 I2=n5
XU875 ND2 $PINS O=n558 I1=n181 I2=n5
XU876 ND2 $PINS O=n183 I1=n558 I2=n559
XU877 ND2 $PINS O=n223 I1=n1398 I2=n185
XU878 OAI12HS $PINS O=n1148 A1=n223 B1=n1399 B2=FE_PHN803_n185
XU879 ND2 $PINS O=n248 I1=n1398 I2=key_counter[0]
XU880 ND2 $PINS O=n187 I1=n1399 I2=n223
XU881 MUX2 $PINS O=n1147 S=FE_PHN1171_key_counter_1 A=n186 B=n187
XU882 AN2 $PINS O=n190 I1=n186 I2=FE_PHN1171_key_counter_1
XU883 OAI12HS $PINS O=n189 A1=n188 B1=FE_PHN1171_key_counter_1 B2=n1405
XU884 MUX2 $PINS O=n1146 S=key_counter[2] A=n190 B=n189
XU885 OAI12HS $PINS O=mode A1=n4 B1=n256 B2=n191
XU886 OR3B2 $PINS O=n192 I1=n9 B1=n67 B2=n194
XU887 ND2 $PINS O=n284 I1=n201 I2=n5
XU888 ND2 $PINS O=n521 I1=n59 I2=n5
XU889 OR3B2 $PINS O=n195 I1=n194 B1=n67 B2=n209
XU890 ND2 $PINS O=n197 I1=n208 I2=n287
XU891 OR3B2 $PINS O=n236 I1=n1396 B1=n675 B2=key_counter[2]
XU892 OAI112HS $PINS O=n196 A1=n560 B1=n1379 C1=n1409 C2=n299
XU893 AN3 $PINS O=n200 I1=n198 I2=FE_DBTN72_mode I3=n558
XU894 AN4B1S $PINS O=n206 I1=n48 I2=n56 I3=n200 B1=n199
XU895 ND2 $PINS O=n760 I1=n68 I2=n5
XU896 OAI12HS $PINS O=n204 A1=n760 B1=n1409 B2=n256
XU897 AN4B1S $PINS O=n205 I1=n1405 I2=n275 I3=n399 B1=n204
XU898 ND2 $PINS O=n222 I1=n206 I2=n205
XU899 OR3B2 $PINS O=n210 I1=n209 B1=n213 B2=n251
XU900 ND2 $PINS O=n290 I1=n215 I2=n5
XU901 OR3B2 $PINS O=n212 I1=n211 B1=n290 B2=n289
XU902 ND2 $PINS O=n216 I1=n524 I2=n48
XU903 AN4B1S $PINS O=n218 I1=n530 I2=n273 I3=n758 B1=n216
XU904 ND2 $PINS O=n276 I1=n257 I2=n5
XU905 AN4B1S $PINS O=n217 I1=n277 I2=n276 I3=n240 B1=n225
XU906 MUX2 $PINS O=n1186 S=n65 A=n222 B=FE_PHN1117_state_3
XU907 OR2 $PINS O=n235 I1=n645 I2=n559
XU908 ND2 $PINS O=key_shift_done_from_control I1=n4 I2=n256
XU909 ND2 $PINS O=n224 I1=n34 I2=n518
XU910 AO112 $PINS O=n227 A1=n225 B1=n224 C1=n226 C2=key_shift_done_from_control
XU911 OR3B2 $PINS O=n229 I1=n499 B1=n228 B2=n760
XU912 ND2 $PINS O=n230 I1=n266 I2=n292
XU913 AN4B1S $PINS O=n232 I1=n53 I2=n253 I3=n762 B1=n230
XU914 AN4B1S $PINS O=n231 I1=n506 I2=n545 I3=n290 B1=n8
XU915 ND2 $PINS O=n233 I1=n232 I2=n231
XU916 MUX2 $PINS O=n1185 S=n65 A=n233 B=FE_PHN975_n9
XU917 AN4B1S $PINS O=n239 I1=n541 I2=n525 I3=n287 B1=n234
XU918 OAI12HS $PINS O=n237 A1=n235 B1=n299 B2=n236
XU919 AN4B1S $PINS O=n238 I1=n558 I2=n506 I3=n756 B1=n237
XU920 AN4B1S $PINS O=n242 I1=n30 I2=n523 I3=n546 B1=n241
XU921 ND2 $PINS O=n243 I1=n57 I2=n39
XU922 AN4B1S $PINS O=n246 I1=n52 I2=n273 I3=n542 B1=n243
XU923 AN4B1S $PINS O=n245 I1=n1379 I2=n290 I3=n284 B1=n244
XU924 ND2 $PINS O=n247 I1=n246 I2=n245
XU925 OAI112HS $PINS O=n249 A1=n248 B1=n555 C1=n668 C2=n256
XU926 AN4B1S $PINS O=n252 I1=n57 I2=n250 I3=n42 B1=n249
XU927 MXL2HS $PINS OB=n1190 S=n65 A=n252 B=FE_PHN974_n251
XU928 AN4B1S $PINS O=n254 I1=n53 I2=n49 I3=n540 B1=n513
XU929 AN4B1S $PINS O=n262 I1=n256 I2=n255 I3=n254 B1=n531
XU930 OR2 $PINS O=n505 I1=n1435 I2=n557
XU931 ND2 $PINS O=n259 I1=Transfer_done_w1 I2=n258
XU932 OAI112HS $PINS O=n260 A1=n505 B1=n259 C1=Transfer_done_w0 C2=n264
XU933 AN4B1S $PINS O=n261 I1=n530 I2=n275 I3=n522 B1=n260
XU934 ND2 $PINS O=n263 I1=n262 I2=n261
XU935 MUX2 $PINS O=n1189 S=n65 A=n263 B=FE_PHN923_state_0
XU936 ND2 $PINS O=n302 I1=n1393 I2=Transfer_done_w0
XU937 AN4B1S $PINS O=n268 I1=n266 I2=n30 I3=n49 B1=n265
XU938 AN4B1S $PINS O=n270 I1=n526 I2=n302 I3=n268 B1=n267
XU939 MXL2HS $PINS OB=n1188 S=n65 A=n270 B=FE_PHN1054_n269
XU940 OR3B2 $PINS O=lookup_table_done_from_control I1=mode B1=n19 B2=n517
XU941 OAI12HS $PINS O=P_sel[1] A1=n19 B1=n1411 B2=FE_DBTN72_mode
XU942 OAI112HS $PINS O=P_sel[0] A1=n399 B1=n517 C1=n1412 C2=FE_DBTN72_mode
XU943 ND2 $PINS O=n571 I1=n277 I2=n518
XU944 AN3 $PINS O=n279 I1=n292 I2=n19 I3=n30
XU945 ND2 $PINS O=n529 I1=n517 I2=n545
XU946 AN4B1S $PINS O=n282 I1=GFAU_done_to_control I2=n34 I3=n279 B1=n529
XU947 AN4B1S $PINS O=n281 I1=n4 I2=n757 I3=n280 B1=n513
XU948 ND2 $PINS O=n283 I1=n64 I2=n28
XU949 AN4B1S $PINS O=n295 I1=n18 I2=n755 I3=n61 B1=n283
XU950 AN4B1S $PINS O=n294 I1=n290 I2=n289 I3=n509 B1=n288
XU951 OAI22S $PINS O=n1080 A1=n744 A2=FE_OFN619_n396 B1=FE_OFN497_n12
+ B2=FE_PHN1636_FE_DBTN70_x3_w_31
XU952 AOI22S $PINS O=n304 A1=FE_OFN353_FE_OFN94_n560 A2=Px_out_from_look[31]
+ B1=x3_w[31] B2=FE_OFN484_FE_DBTN71_n2
XU953 AN3 $PINS O=n301 I1=n536 I2=n10 I3=n300
XU954 AOI22S $PINS O=n303 A1=x1[31] A2=n501 B1=n500 B2=i1_w[31]
XU955 ND2 $PINS O=n921 I1=n304 I2=n303
XU956 MUX2 $PINS O=Px_in_to_look[31] S=FE_OFN508_n504 A=x3_w[31] B=x1[31]
XU957 OAI22S $PINS O=n1081 A1=n737 A2=FE_OFN619_n396 B1=FE_OFN497_n12 B2=n305
XU958 AOI22S $PINS O=n307 A1=FE_OFN353_FE_OFN94_n560 A2=Px_out_from_look[30]
+ B1=FE_PHN1192_x3_w_30 B2=FE_OFN484_FE_DBTN71_n2
XU959 AOI22S $PINS O=n306 A1=x1[30] A2=n501 B1=n500 B2=i1_w[30]
XU960 ND2 $PINS O=n922 I1=n307 I2=n306
XU961 MUX2 $PINS O=Px_in_to_look[30] S=FE_OFN508_n504 A=FE_PHN1192_x3_w_30
+ B=x1[30]
XU962 OAI22S $PINS O=n1082 A1=n732 A2=FE_OFN619_n396 B1=FE_OFN497_n12
+ B2=FE_DBTN69_x3_w_29
XU963 AOI22S $PINS O=n310 A1=FE_OFN353_FE_OFN94_n560 A2=Px_out_from_look[29]
+ B1=x3_w[29] B2=FE_OFN484_FE_DBTN71_n2
XU964 AOI22S $PINS O=n309 A1=x1[29] A2=n501 B1=n500 B2=i1_w[29]
XU965 ND2 $PINS O=n923 I1=n310 I2=n309
XU966 MUX2 $PINS O=Px_in_to_look[29] S=FE_OFN508_n504 A=x3_w[29] B=x1[29]
XU967 OAI22S $PINS O=n1083 A1=n727 A2=FE_OFN619_n396 B1=FE_OFN497_n12 B2=n311
XU968 AOI22S $PINS O=n313 A1=FE_OFN353_FE_OFN94_n560 A2=Px_out_from_look[28]
+ B1=x3_w[28] B2=FE_OFN484_FE_DBTN71_n2
XU969 AOI22S $PINS O=n312 A1=x1[28] A2=n501 B1=n500 B2=i1_w[28]
XU970 ND2 $PINS O=n924 I1=n313 I2=n312
XU971 MUX2 $PINS O=Px_in_to_look[28] S=FE_OFN508_n504 A=x3_w[28] B=x1[28]
XU972 OAI22S $PINS O=n1084 A1=n722 A2=FE_OFN619_n396 B1=FE_OFN497_n12
+ B2=FE_DBTN68_x3_w_27
XU973 AOI22S $PINS O=n316 A1=FE_OFN353_FE_OFN94_n560 A2=Px_out_from_look[27]
+ B1=x3_w[27] B2=FE_OFN484_FE_DBTN71_n2
XU974 AOI22S $PINS O=n315 A1=FE_PHN1558_x1_27 A2=n501 B1=n500 B2=i1_w[27]
XU975 ND2 $PINS O=n925 I1=n316 I2=n315
XU976 MUX2 $PINS O=Px_in_to_look[27] S=FE_OFN508_n504 A=x3_w[27] B=x1[27]
XU977 OAI22S $PINS O=n1085 A1=n717 A2=FE_OFN619_n396 B1=FE_OFN497_n12 B2=n317
XU978 AOI22S $PINS O=n319 A1=FE_OFN353_FE_OFN94_n560 A2=Px_out_from_look[26]
+ B1=FE_PHN1168_x3_w_26 B2=FE_OFN484_FE_DBTN71_n2
XU979 AOI22S $PINS O=n318 A1=x1[26] A2=n501 B1=n500 B2=i1_w[26]
XU980 ND2 $PINS O=n926 I1=n319 I2=n318
XU981 MUX2 $PINS O=Px_in_to_look[26] S=FE_OFN508_n504 A=FE_PHN1168_x3_w_26
+ B=x1[26]
XU982 OAI22S $PINS O=n1086 A1=n712 A2=FE_OFN619_n396 B1=FE_OFN497_n12
+ B2=FE_DBTN67_x3_w_25
XU983 AOI22S $PINS O=n322 A1=FE_OFN353_FE_OFN94_n560 A2=Px_out_from_look[25]
+ B1=x3_w[25] B2=FE_OFN484_FE_DBTN71_n2
XU984 AOI22S $PINS O=n321 A1=x1[25] A2=n501 B1=n500 B2=i1_w[25]
XU985 ND2 $PINS O=n927 I1=n322 I2=n321
XU986 MUX2 $PINS O=Px_in_to_look[25] S=FE_OFN508_n504 A=x3_w[25] B=x1[25]
XU987 OAI22S $PINS O=n1087 A1=n707 A2=FE_OFN619_n396 B1=FE_OFN497_n12
+ B2=FE_PHN1112_n323
XU988 AOI22S $PINS O=n325 A1=FE_OFN353_FE_OFN94_n560 A2=Px_out_from_look[24]
+ B1=x3_w[24] B2=FE_OFN484_FE_DBTN71_n2
XU989 AOI22S $PINS O=n324 A1=x1[24] A2=n501 B1=n500 B2=i1_w[24]
XU990 ND2 $PINS O=n928 I1=n325 I2=n324
XU991 MUX2 $PINS O=Px_in_to_look[24] S=FE_OFN508_n504 A=x3_w[24] B=x1[24]
XU992 OAI22S $PINS O=n1088 A1=n702 A2=FE_OFN619_n396 B1=FE_OFN497_n12
+ B2=FE_DBTN66_x3_w_23
XU993 AOI22S $PINS O=n328 A1=FE_OFN353_FE_OFN94_n560 A2=Px_out_from_look[23]
+ B1=x3_w[23] B2=FE_OFN484_FE_DBTN71_n2
XU994 AOI22S $PINS O=n327 A1=x1[23] A2=n501 B1=n500 B2=i1_w[23]
XU995 ND2 $PINS O=FE_PHN1347_n929 I1=n328 I2=n327
XU996 MUX2 $PINS O=Px_in_to_look[23] S=FE_OFN508_n504 A=x3_w[23] B=x1[23]
XU997 OAI22S $PINS O=n1089 A1=n697 A2=FE_OFN619_n396 B1=FE_OFN497_n12 B2=n329
XU998 AOI22S $PINS O=n331 A1=FE_OFN353_FE_OFN94_n560 A2=Px_out_from_look[22]
+ B1=x3_w[22] B2=FE_OFN484_FE_DBTN71_n2
XU999 AOI22S $PINS O=n330 A1=x1[22] A2=n501 B1=n500 B2=i1_w[22]
XU1000 ND2 $PINS O=n930 I1=n331 I2=n330
XU1001 MUX2 $PINS O=Px_in_to_look[22] S=FE_OFN508_n504 A=x3_w[22] B=x1[22]
XU1002 OAI22S $PINS O=n1090 A1=n692 A2=FE_OFN619_n396 B1=FE_OFN497_n12
+ B2=FE_DBTN65_x3_w_21
XU1003 AOI22S $PINS O=n334 A1=FE_OFN353_FE_OFN94_n560 A2=Px_out_from_look[21]
+ B1=x3_w[21] B2=FE_DBTN71_n2
XU1004 AOI22S $PINS O=n333 A1=FE_PHN1049_x1_21 A2=n501 B1=n500 B2=i1_w[21]
XU1005 ND2 $PINS O=n931 I1=n334 I2=n333
XU1006 MUX2 $PINS O=Px_in_to_look[21] S=n504 A=x3_w[21] B=x1[21]
XU1007 OAI22S $PINS O=n1091 A1=n687 A2=FE_OFN619_n396 B1=FE_OFN497_n12 B2=n335
XU1008 AOI22S $PINS O=n337 A1=FE_OFN353_FE_OFN94_n560 A2=Px_out_from_look[20]
+ B1=FE_PHN1235_x3_w_20 B2=FE_OFN484_FE_DBTN71_n2
XU1009 AOI22S $PINS O=n336 A1=x1[20] A2=n501 B1=n500 B2=i1_w[20]
XU1010 ND2 $PINS O=n932 I1=n337 I2=n336
XU1011 MUX2 $PINS O=Px_in_to_look[20] S=FE_OFN508_n504 A=FE_PHN1235_x3_w_20
+ B=x1[20]
XU1012 OAI22S $PINS O=n1092 A1=n682 A2=FE_OFN619_n396 B1=FE_OFN497_n12
+ B2=FE_DBTN64_x3_w_19
XU1013 AOI22S $PINS O=n340 A1=FE_OFN94_n560 A2=Px_out_from_look[19] B1=x3_w[19]
+ B2=FE_DBTN71_n2
XU1014 AOI22S $PINS O=n339 A1=x1[19] A2=FE_OFN81_n501 B1=FE_OFN504_n500
+ B2=i1_w[19]
XU1015 ND2 $PINS O=n933 I1=n340 I2=n339
XU1016 MUX2 $PINS O=Px_in_to_look[19] S=n504 A=x3_w[19] B=x1[19]
XU1017 OAI22S $PINS O=n1093 A1=n677 A2=FE_OFN619_n396 B1=FE_OFN497_n12 B2=n341
XU1018 AOI22S $PINS O=n343 A1=FE_OFN353_FE_OFN94_n560 A2=Px_out_from_look[18]
+ B1=x3_w[18] B2=FE_OFN484_FE_DBTN71_n2
XU1019 AOI22S $PINS O=n342 A1=x1[18] A2=n501 B1=n500 B2=i1_w[18]
XU1020 ND2 $PINS O=FE_PHN1363_n934 I1=n343 I2=n342
XU1021 MUX2 $PINS O=Px_in_to_look[18] S=FE_OFN508_n504 A=x3_w[18] B=x1[18]
XU1022 OAI22S $PINS O=n1094 A1=n669 A2=FE_OFN619_n396 B1=FE_OFN497_n12
+ B2=FE_DBTN63_x3_w_17
XU1023 AOI22S $PINS O=n346 A1=FE_OFN94_n560 A2=Px_out_from_look[17] B1=x3_w[17]
+ B2=FE_DBTN71_n2
XU1024 AOI22S $PINS O=n345 A1=FE_PHN1577_x1_17 A2=FE_OFN81_n501
+ B1=FE_OFN504_n500 B2=i1_w[17]
XU1025 ND2 $PINS O=FE_PHN1358_n935 I1=n346 I2=n345
XU1026 MUX2 $PINS O=Px_in_to_look[17] S=n504 A=x3_w[17] B=x1[17]
XU1027 OAI22S $PINS O=n1095 A1=n663 A2=FE_OFN619_n396 B1=FE_OFN497_n12 B2=n347
XU1028 AOI22S $PINS O=n349 A1=FE_OFN353_FE_OFN94_n560 A2=Px_out_from_look[16]
+ B1=FE_PHN1159_x3_w_16 B2=FE_OFN484_FE_DBTN71_n2
XU1029 AOI22S $PINS O=n348 A1=x1[16] A2=n501 B1=n500 B2=i1_w[16]
XU1030 ND2 $PINS O=n936 I1=n349 I2=n348
XU1031 MUX2 $PINS O=Px_in_to_look[16] S=FE_OFN508_n504 A=FE_PHN1159_x3_w_16
+ B=x1[16]
XU1032 OAI22S $PINS O=n1096 A1=n658 A2=FE_OFN619_n396 B1=FE_OFN497_n12
+ B2=FE_DBTN62_x3_w_15
XU1033 AOI22S $PINS O=n352 A1=FE_OFN94_n560 A2=Px_out_from_look[15] B1=x3_w[15]
+ B2=FE_DBTN71_n2
XU1034 AOI22S $PINS O=n351 A1=FE_PHN755_x1_15 A2=FE_OFN81_n501
+ B1=FE_OFN504_n500 B2=i1_w[15]
XU1035 ND2 $PINS O=n937 I1=n352 I2=n351
XU1036 MUX2 $PINS O=Px_in_to_look[15] S=n504 A=x3_w[15] B=x1[15]
XU1039 OAI22S $PINS O=n1097 A1=n653 A2=FE_OFN619_n396 B1=FE_OFN497_n12 B2=n353
XU1040 AOI22S $PINS O=n355 A1=FE_OFN353_FE_OFN94_n560 A2=Px_out_from_look[14]
+ B1=FE_PHN1262_x3_w_14 B2=FE_OFN484_FE_DBTN71_n2
XU1041 AOI22S $PINS O=n354 A1=x1[14] A2=n501 B1=n500 B2=i1_w[14]
XU1042 ND2 $PINS O=FE_PHN1375_n938 I1=n355 I2=n354
XU1043 MUX2 $PINS O=Px_in_to_look[14] S=FE_OFN508_n504 A=FE_PHN1262_x3_w_14
+ B=x1[14]
XU1044 OAI22S $PINS O=n1098 A1=n648 A2=FE_OFN619_n396 B1=FE_OFN497_n12
+ B2=FE_DBTN61_x3_w_13
XU1045 AOI22S $PINS O=n358 A1=FE_OFN94_n560 A2=Px_out_from_look[13] B1=x3_w[13]
+ B2=FE_DBTN71_n2
XU1046 AOI22S $PINS O=n357 A1=x1[13] A2=FE_OFN81_n501 B1=FE_OFN504_n500
+ B2=i1_w[13]
XU1047 ND2 $PINS O=n939 I1=n358 I2=n357
XU1048 MUX2 $PINS O=Px_in_to_look[13] S=n504 A=x3_w[13] B=x1[13]
XU1049 OAI22S $PINS O=n1099 A1=n642 A2=FE_OFN619_n396 B1=FE_OFN497_n12 B2=n359
XU1050 AOI22S $PINS O=n361 A1=FE_OFN353_FE_OFN94_n560 A2=Px_out_from_look[12]
+ B1=FE_PHN1225_x3_w_12 B2=FE_OFN484_FE_DBTN71_n2
XU1051 AOI22S $PINS O=n360 A1=x1[12] A2=n501 B1=n500 B2=i1_w[12]
XU1052 ND2 $PINS O=n940 I1=n361 I2=n360
XU1053 MUX2 $PINS O=Px_in_to_look[12] S=FE_OFN508_n504 A=FE_PHN1225_x3_w_12
+ B=x1[12]
XU1054 OAI22S $PINS O=n1100 A1=n637 A2=n396 B1=n12 B2=FE_DBTN60_x3_w_11
XU1055 AOI22S $PINS O=n364 A1=FE_OFN94_n560 A2=Px_out_from_look[11] B1=x3_w[11]
+ B2=FE_DBTN71_n2
XU1056 AOI22S $PINS O=n363 A1=x1[11] A2=FE_OFN81_n501 B1=FE_OFN504_n500
+ B2=i1_w[11]
XU1057 ND2 $PINS O=n941 I1=n364 I2=n363
XU1058 MUX2 $PINS O=Px_in_to_look[11] S=n504 A=x3_w[11] B=x1[11]
XU1059 OAI22S $PINS O=n1101 A1=n632 A2=n396 B1=n12 B2=FE_PHN1141_n365
XU1060 AOI22S $PINS O=n367 A1=FE_OFN353_FE_OFN94_n560 A2=Px_out_from_look[10]
+ B1=x3_w[10] B2=FE_OFN484_FE_DBTN71_n2
XU1061 AOI22S $PINS O=n366 A1=x1[10] A2=n501 B1=n500 B2=i1_w[10]
XU1062 ND2 $PINS O=n942 I1=n367 I2=n366
XU1063 MUX2 $PINS O=Px_in_to_look[10] S=FE_OFN508_n504 A=x3_w[10] B=x1[10]
XU1064 OAI22S $PINS O=n1102 A1=n625 A2=n396 B1=n12 B2=FE_DBTN59_x3_w_9
XU1065 AOI22S $PINS O=n370 A1=FE_OFN94_n560 A2=Px_out_from_look[9] B1=x3_w[9]
+ B2=FE_DBTN71_n2
XU1067 AOI22S $PINS O=n369 A1=x1[9] A2=FE_OFN81_n501 B1=FE_OFN504_n500
+ B2=i1_w[9]
XU1068 ND2 $PINS O=n943 I1=n370 I2=n369
XU1069 MUX2 $PINS O=Px_in_to_look[9] S=n504 A=x3_w[9] B=x1[9]
XU1070 OAI22S $PINS O=n1103 A1=n619 A2=n396 B1=n12 B2=n371
XU1071 AOI22S $PINS O=n373 A1=FE_OFN353_FE_OFN94_n560 A2=Px_out_from_look[8]
+ B1=x3_w[8] B2=FE_OFN484_FE_DBTN71_n2
XU1072 AOI22S $PINS O=n372 A1=x1[8] A2=n501 B1=n500 B2=i1_w[8]
XU1073 ND2 $PINS O=n944 I1=n373 I2=n372
XU1074 MUX2 $PINS O=Px_in_to_look[8] S=FE_OFN508_n504 A=x3_w[8] B=x1[8]
XU1075 OAI22S $PINS O=n1104 A1=n613 A2=n396 B1=n12 B2=FE_DBTN58_x3_w_7
XU1076 AOI22S $PINS O=n376 A1=FE_OFN94_n560 A2=Px_out_from_look[7] B1=x3_w[7]
+ B2=FE_DBTN71_n2
XU1077 AOI22S $PINS O=n375 A1=x1[7] A2=FE_OFN81_n501 B1=FE_OFN504_n500
+ B2=i1_w[7]
XU1078 ND2 $PINS O=n945 I1=n376 I2=n375
XU1079 MUX2 $PINS O=Px_in_to_look[7] S=n504 A=x3_w[7] B=x1[7]
XU1080 OAI22S $PINS O=n1105 A1=n607 A2=n396 B1=n12 B2=FE_DBTN57_x3_w_6
XU1081 AOI22S $PINS O=n379 A1=FE_OFN94_n560 A2=Px_out_from_look[6]
+ B1=FE_PHN1337_x3_w_6 B2=FE_DBTN71_n2
XU1082 AOI22S $PINS O=n378 A1=x1[6] A2=FE_OFN81_n501 B1=FE_OFN504_n500
+ B2=i1_w[6]
XU1083 ND2 $PINS O=n946 I1=n379 I2=n378
XU1084 MUX2 $PINS O=Px_in_to_look[6] S=n504 A=FE_PHN1337_x3_w_6 B=x1[6]
XU1085 OAI22S $PINS O=n1106 A1=n601 A2=n396 B1=n12 B2=FE_DBTN56_x3_w_5
XU1086 AOI22S $PINS O=n382 A1=FE_OFN94_n560 A2=Px_out_from_look[5] B1=x3_w[5]
+ B2=FE_DBTN71_n2
XU1087 AOI22S $PINS O=n381 A1=x1[5] A2=FE_OFN81_n501 B1=FE_OFN504_n500
+ B2=i1_w[5]
XU1088 ND2 $PINS O=n947 I1=n382 I2=n381
XU1089 MUX2 $PINS O=Px_in_to_look[5] S=FE_OFN510_n504 A=x3_w[5] B=x1[5]
XU1090 OAI22S $PINS O=n1107 A1=n595 A2=n396 B1=n12 B2=n383
XU1091 AOI22S $PINS O=n385 A1=FE_OFN354_FE_OFN94_n560 A2=Px_out_from_look[4]
+ B1=FE_PHN1130_x3_w_4 B2=FE_DBTN71_n2
XU1092 AOI22S $PINS O=n384 A1=x1[4] A2=FE_OFN81_n501 B1=FE_OFN504_n500
+ B2=i1_w[4]
XU1093 ND2 $PINS O=FE_PHN1367_n948 I1=n385 I2=n384
XU1094 MUX2 $PINS O=Px_in_to_look[4] S=n504 A=FE_PHN1130_x3_w_4 B=x1[4]
XU1095 OAI22S $PINS O=n1108 A1=n589 A2=n396 B1=n12 B2=FE_DBTN55_x3_w_3
XU1096 AOI22S $PINS O=n388 A1=FE_OFN94_n560 A2=Px_out_from_look[3] B1=x3_w[3]
+ B2=FE_DBTN71_n2
XU1097 AOI22S $PINS O=n387 A1=x1[3] A2=FE_OFN81_n501 B1=FE_OFN504_n500
+ B2=i1_w[3]
XU1098 ND2 $PINS O=n949 I1=n388 I2=n387
XU1099 MUX2 $PINS O=Px_in_to_look[3] S=FE_OFN510_n504 A=x3_w[3] B=x1[3]
XU1100 OAI22S $PINS O=n1109 A1=n583 A2=n396 B1=n12 B2=FE_PHN1034_n389
XU1101 AOI22S $PINS O=n391 A1=FE_OFN94_n560 A2=Px_out_from_look[2] B1=x3_w[2]
+ B2=FE_DBTN71_n2
XU1102 AOI22S $PINS O=n390 A1=x1[2] A2=FE_OFN81_n501 B1=FE_OFN504_n500
+ B2=i1_w[2]
XU1103 ND2 $PINS O=n950 I1=n391 I2=n390
XU1104 MUX2 $PINS O=Px_in_to_look[2] S=FE_OFN510_n504 A=x3_w[2] B=x1[2]
XU1105 OAI22S $PINS O=n1110 A1=n574 A2=n396 B1=n12 B2=FE_DBTN54_x3_w_1
XU1106 AOI22S $PINS O=n394 A1=FE_OFN94_n560 A2=Px_out_from_look[1] B1=x3_w[1]
+ B2=FE_DBTN71_n2
XU1107 AOI22S $PINS O=n393 A1=FE_PHN1580_x1_1 A2=FE_OFN81_n501
+ B1=FE_OFN504_n500 B2=i1_w[1]
XU1108 ND2 $PINS O=FE_PHN1435_n951 I1=n394 I2=n393
XU1109 MUX2 $PINS O=Px_in_to_look[1] S=FE_OFN510_n504 A=x3_w[1] B=x1[1]
XU1110 OAI22S $PINS O=n1111 A1=n554 A2=n396 B1=FE_OFN333_x3_w_0 B2=n12
XU1111 AOI22S $PINS O=n398 A1=FE_OFN354_FE_OFN94_n560 A2=Px_out_from_look[0]
+ B1=FE_PHN1339_x3_w_0 B2=FE_OFN485_FE_DBTN71_n2
XU1112 AOI22S $PINS O=n397 A1=x1[0] A2=FE_OFN81_n501 B1=FE_OFN504_n500
+ B2=i1_w[0]
XU1113 ND2 $PINS O=n952 I1=n398 I2=n397
XU1114 MUX2 $PINS O=Px_in_to_look[0] S=FE_OFN510_n504 A=FE_PHN1339_x3_w_0
+ B=x1[0]
XU1115 AN3 $PINS O=n400 I1=n1382 I2=n10 I3=n399
XU1116 OR3B2 $PINS O=n565 I1=n499 B1=n1392 B2=n400
XU1117 OR3B2 $PINS O=n532 I1=n565 B1=GFAU_done_to_control B2=n2
XU1118 OAI12HS $PINS O=n496 A1=n401 B1=n402 B2=n532
XU1119 ND2 $PINS O=n498 I1=FE_OFN61_n496 I2=n567
XU1120 OAI22S $PINS O=n1017 A1=n744 A2=FE_OFN620_n498 B1=FE_OFN61_n496
+ B2=FE_DBTN52_y3_w_31
XU1121 AOI22S $PINS O=n405 A1=FE_OFN355_FE_OFN94_n560 A2=Py_out_from_look[31]
+ B1=y3_w[31] B2=FE_OFN486_FE_DBTN71_n2
XU1122 AOI22S $PINS O=n404 A1=y1[31] A2=FE_OFN362_FE_OFN81_n501
+ B1=FE_OFN506_n500 B2=i2_w[31]
XU1123 ND2 $PINS O=n985 I1=n405 I2=n404
XU1124 MUX2 $PINS O=Py_in_to_look[31] S=FE_OFN511_n504 A=y3_w[31] B=y1[31]
XU1125 OAI22S $PINS O=n1018 A1=n737 A2=FE_OFN620_n498 B1=FE_OFN61_n496 B2=n406
XU1126 AOI22S $PINS O=n408 A1=FE_OFN355_FE_OFN94_n560 A2=Py_out_from_look[30]
+ B1=y3_w[30] B2=FE_OFN486_FE_DBTN71_n2
XU1127 AOI22S $PINS O=n407 A1=FE_PHN1066_y1_30 A2=FE_OFN362_FE_OFN81_n501
+ B1=FE_OFN506_n500 B2=i2_w[30]
XU1128 ND2 $PINS O=n986 I1=n408 I2=n407
XU1129 MUX2 $PINS O=Py_in_to_look[30] S=FE_OFN511_n504 A=y3_w[30] B=y1[30]
XU1130 OAI22S $PINS O=n1019 A1=n732 A2=FE_OFN620_n498
+ B1=FE_OFN388_FE_OFN61_n496 B2=FE_DBTN51_y3_w_29
XU1131 AOI22S $PINS O=n411 A1=FE_OFN355_FE_OFN94_n560 A2=Py_out_from_look[29]
+ B1=FE_PHN1638_y3_w_29 B2=FE_OFN486_FE_DBTN71_n2
XU1132 AOI22S $PINS O=n410 A1=FE_PHN779_y1_29 A2=FE_OFN362_FE_OFN81_n501
+ B1=FE_OFN506_n500 B2=i2_w[29]
XU1133 ND2 $PINS O=n987 I1=n411 I2=n410
XU1134 MUX2 $PINS O=Py_in_to_look[29] S=FE_OFN511_n504 A=FE_PHN1638_y3_w_29
+ B=y1[29]
XU1135 OAI22S $PINS O=n1020 A1=n727 A2=FE_OFN620_n498 B1=FE_OFN61_n496 B2=n412
XU1136 AOI22S $PINS O=n414 A1=FE_OFN355_FE_OFN94_n560 A2=Py_out_from_look[28]
+ B1=y3_w[28] B2=FE_OFN486_FE_DBTN71_n2
XU1137 AOI22S $PINS O=n413 A1=FE_PHN1107_y1_28 A2=FE_OFN362_FE_OFN81_n501
+ B1=FE_OFN506_n500 B2=i2_w[28]
XU1138 ND2 $PINS O=n988 I1=n414 I2=n413
XU1139 MUX2 $PINS O=Py_in_to_look[28] S=FE_OFN511_n504 A=y3_w[28] B=y1[28]
XU1140 OAI22S $PINS O=n1021 A1=n722 A2=FE_OFN620_n498
+ B1=FE_OFN388_FE_OFN61_n496 B2=FE_DBTN50_y3_w_27
XU1141 AOI22S $PINS O=n417 A1=FE_OFN355_FE_OFN94_n560 A2=Py_out_from_look[27]
+ B1=y3_w[27] B2=FE_OFN486_FE_DBTN71_n2
XU1142 AOI22S $PINS O=n416 A1=FE_PHN769_y1_27 A2=FE_OFN362_FE_OFN81_n501
+ B1=FE_OFN506_n500 B2=i2_w[27]
XU1143 ND2 $PINS O=n989 I1=n417 I2=n416
XU1144 MUX2 $PINS O=Py_in_to_look[27] S=FE_OFN511_n504 A=y3_w[27] B=y1[27]
XU1145 OAI22S $PINS O=n1022 A1=n717 A2=FE_OFN620_n498 B1=FE_OFN61_n496 B2=n418
XU1146 AOI22S $PINS O=n420 A1=FE_OFN355_FE_OFN94_n560 A2=Py_out_from_look[26]
+ B1=y3_w[26] B2=FE_OFN486_FE_DBTN71_n2
XU1147 AOI22S $PINS O=n419 A1=y1[26] A2=FE_OFN362_FE_OFN81_n501
+ B1=FE_OFN506_n500 B2=i2_w[26]
XU1148 ND2 $PINS O=FE_PHN1440_n990 I1=n420 I2=n419
XU1149 MUX2 $PINS O=Py_in_to_look[26] S=FE_OFN511_n504 A=y3_w[26] B=y1[26]
XU1150 OAI22S $PINS O=n1023 A1=n712 A2=FE_OFN620_n498
+ B1=FE_OFN388_FE_OFN61_n496 B2=FE_DBTN49_y3_w_25
XU1151 AOI22S $PINS O=n423 A1=FE_OFN355_FE_OFN94_n560 A2=Py_out_from_look[25]
+ B1=y3_w[25] B2=FE_OFN486_FE_DBTN71_n2
XU1152 AOI22S $PINS O=n422 A1=FE_PHN749_y1_25 A2=FE_OFN362_FE_OFN81_n501
+ B1=FE_OFN506_n500 B2=i2_w[25]
XU1153 ND2 $PINS O=n991 I1=n423 I2=n422
XU1154 MUX2 $PINS O=Py_in_to_look[25] S=FE_OFN511_n504 A=y3_w[25] B=y1[25]
XU1155 OAI22S $PINS O=n1024 A1=n707 A2=FE_OFN620_n498 B1=FE_OFN61_n496 B2=n424
XU1156 AOI22S $PINS O=n426 A1=FE_OFN355_FE_OFN94_n560 A2=Py_out_from_look[24]
+ B1=y3_w[24] B2=FE_OFN486_FE_DBTN71_n2
XU1157 AOI22S $PINS O=n425 A1=FE_PHN1101_y1_24 A2=FE_OFN362_FE_OFN81_n501
+ B1=FE_OFN506_n500 B2=i2_w[24]
XU1158 ND2 $PINS O=n992 I1=n426 I2=n425
XU1159 MUX2 $PINS O=Py_in_to_look[24] S=FE_OFN511_n504 A=y3_w[24] B=y1[24]
XU1160 OAI22S $PINS O=n1025 A1=n702 A2=FE_OFN620_n498
+ B1=FE_OFN388_FE_OFN61_n496 B2=FE_DBTN48_y3_w_23
XU1161 AOI22S $PINS O=n429 A1=FE_OFN355_FE_OFN94_n560 A2=Py_out_from_look[23]
+ B1=y3_w[23] B2=FE_OFN486_FE_DBTN71_n2
XU1162 AOI22S $PINS O=n428 A1=y1[23] A2=FE_OFN362_FE_OFN81_n501
+ B1=FE_OFN506_n500 B2=i2_w[23]
XU1163 ND2 $PINS O=FE_PHN1422_n993 I1=n429 I2=n428
XU1164 MUX2 $PINS O=Py_in_to_look[23] S=FE_OFN511_n504 A=y3_w[23] B=y1[23]
XU1165 OAI22S $PINS O=n1026 A1=n697 A2=FE_OFN620_n498
+ B1=FE_OFN388_FE_OFN61_n496 B2=n430
XU1166 AOI22S $PINS O=n432 A1=FE_OFN355_FE_OFN94_n560 A2=Py_out_from_look[22]
+ B1=y3_w[22] B2=FE_OFN486_FE_DBTN71_n2
XU1167 AOI22S $PINS O=n431 A1=FE_PHN901_y1_22 A2=FE_OFN362_FE_OFN81_n501
+ B1=FE_OFN506_n500 B2=i2_w[22]
XU1168 ND2 $PINS O=n994 I1=n432 I2=n431
XU1169 MUX2 $PINS O=Py_in_to_look[22] S=FE_OFN511_n504 A=y3_w[22] B=y1[22]
XU1170 OAI22S $PINS O=n1027 A1=n692 A2=FE_OFN620_n498
+ B1=FE_OFN388_FE_OFN61_n496 B2=FE_DBTN47_y3_w_21
XU1171 AOI22S $PINS O=n435 A1=FE_OFN354_FE_OFN94_n560 A2=Py_out_from_look[21]
+ B1=y3_w[21] B2=FE_OFN485_FE_DBTN71_n2
XU1172 AOI22S $PINS O=n434 A1=FE_PHN1059_y1_21 A2=FE_OFN361_FE_OFN81_n501
+ B1=FE_OFN507_n500 B2=i2_w[21]
XU1173 ND2 $PINS O=n995 I1=n435 I2=n434
XU1174 MUX2 $PINS O=Py_in_to_look[21] S=FE_OFN510_n504 A=y3_w[21] B=y1[21]
XU1175 OAI22S $PINS O=n1028 A1=n687 A2=FE_OFN620_n498
+ B1=FE_OFN388_FE_OFN61_n496 B2=n436
XU1176 AOI22S $PINS O=n438 A1=FE_OFN355_FE_OFN94_n560 A2=Py_out_from_look[20]
+ B1=y3_w[20] B2=FE_OFN486_FE_DBTN71_n2
XU1177 AOI22S $PINS O=n437 A1=FE_PHN1051_y1_20 A2=FE_OFN362_FE_OFN81_n501
+ B1=FE_OFN506_n500 B2=i2_w[20]
XU1178 ND2 $PINS O=n996 I1=n438 I2=n437
XU1179 MUX2 $PINS O=Py_in_to_look[20] S=FE_OFN511_n504 A=y3_w[20]
+ B=FE_PHN1596_y1_20
XU1180 OAI22S $PINS O=n1029 A1=n682 A2=FE_OFN620_n498
+ B1=FE_OFN388_FE_OFN61_n496 B2=FE_DBTN46_y3_w_19
XU1181 AOI22S $PINS O=n441 A1=FE_OFN354_FE_OFN94_n560 A2=Py_out_from_look[19]
+ B1=y3_w[19] B2=FE_OFN485_FE_DBTN71_n2
XU1182 AOI22S $PINS O=n440 A1=y1[19] A2=FE_OFN361_FE_OFN81_n501
+ B1=FE_OFN507_n500 B2=i2_w[19]
XU1183 ND2 $PINS O=n997 I1=n441 I2=n440
XU1184 MUX2 $PINS O=Py_in_to_look[19] S=FE_OFN510_n504 A=y3_w[19] B=y1[19]
XU1185 OAI22S $PINS O=n1030 A1=n677 A2=FE_OFN620_n498
+ B1=FE_OFN388_FE_OFN61_n496 B2=n442
XU1186 AOI22S $PINS O=n444 A1=FE_OFN355_FE_OFN94_n560 A2=Py_out_from_look[18]
+ B1=y3_w[18] B2=FE_OFN486_FE_DBTN71_n2
XU1187 AOI22S $PINS O=n443 A1=FE_PHN1587_y1_18 A2=FE_OFN362_FE_OFN81_n501
+ B1=FE_OFN506_n500 B2=i2_w[18]
XU1188 ND2 $PINS O=n998 I1=n444 I2=n443
XU1189 MUX2 $PINS O=Py_in_to_look[18] S=FE_OFN511_n504 A=y3_w[18] B=y1[18]
XU1190 OAI22S $PINS O=n1031 A1=n669 A2=FE_OFN620_n498
+ B1=FE_OFN388_FE_OFN61_n496 B2=FE_DBTN45_y3_w_17
XU1191 AOI22S $PINS O=n447 A1=FE_OFN354_FE_OFN94_n560 A2=Py_out_from_look[17]
+ B1=y3_w[17] B2=FE_OFN485_FE_DBTN71_n2
XU1192 AOI22S $PINS O=n446 A1=FE_PHN1633_y1_17 A2=FE_OFN361_FE_OFN81_n501
+ B1=FE_OFN507_n500 B2=i2_w[17]
XU1193 ND2 $PINS O=n999 I1=n447 I2=n446
XU1194 MUX2 $PINS O=Py_in_to_look[17] S=FE_OFN510_n504 A=y3_w[17] B=y1[17]
XU1195 OAI22S $PINS O=n1032 A1=n663 A2=FE_OFN620_n498
+ B1=FE_OFN388_FE_OFN61_n496 B2=n448
XU1196 AOI22S $PINS O=n450 A1=FE_OFN355_FE_OFN94_n560 A2=Py_out_from_look[16]
+ B1=y3_w[16] B2=FE_OFN486_FE_DBTN71_n2
XU1197 AOI22S $PINS O=n449 A1=FE_PHN1064_y1_16 A2=FE_OFN362_FE_OFN81_n501
+ B1=FE_OFN506_n500 B2=i2_w[16]
XU1198 ND2 $PINS O=n1000 I1=n450 I2=n449
XU1199 MUX2 $PINS O=Py_in_to_look[16] S=FE_OFN511_n504 A=y3_w[16] B=y1[16]
XU1200 OAI22S $PINS O=n1033 A1=n658 A2=FE_OFN620_n498
+ B1=FE_OFN388_FE_OFN61_n496 B2=FE_DBTN44_y3_w_15
XU1201 AOI22S $PINS O=n453 A1=FE_OFN354_FE_OFN94_n560 A2=Py_out_from_look[15]
+ B1=y3_w[15] B2=FE_OFN485_FE_DBTN71_n2
XU1202 AOI22S $PINS O=n452 A1=FE_PHN1037_y1_15 A2=FE_OFN361_FE_OFN81_n501
+ B1=FE_OFN507_n500 B2=i2_w[15]
XU1203 ND2 $PINS O=n1001 I1=n453 I2=n452
XU1204 MUX2 $PINS O=Py_in_to_look[15] S=FE_OFN510_n504 A=y3_w[15]
+ B=FE_PHN1605_y1_15
XU1205 OAI22S $PINS O=n1034 A1=n653 A2=FE_OFN620_n498
+ B1=FE_OFN388_FE_OFN61_n496 B2=n454
XU1206 AOI22S $PINS O=n456 A1=FE_OFN355_FE_OFN94_n560 A2=Py_out_from_look[14]
+ B1=y3_w[14] B2=FE_OFN486_FE_DBTN71_n2
XU1207 AOI22S $PINS O=n455 A1=FE_PHN748_y1_14 A2=FE_OFN362_FE_OFN81_n501
+ B1=FE_OFN506_n500 B2=i2_w[14]
XU1208 ND2 $PINS O=n1002 I1=n456 I2=n455
XU1209 MUX2 $PINS O=Py_in_to_look[14] S=FE_OFN511_n504 A=y3_w[14] B=y1[14]
XU1210 OAI22S $PINS O=n1035 A1=n648 A2=FE_OFN620_n498
+ B1=FE_OFN388_FE_OFN61_n496 B2=FE_DBTN43_y3_w_13
XU1211 AOI22S $PINS O=n459 A1=FE_OFN354_FE_OFN94_n560 A2=Py_out_from_look[13]
+ B1=y3_w[13] B2=FE_OFN485_FE_DBTN71_n2
XU1212 AOI22S $PINS O=n458 A1=FE_PHN772_y1_13 A2=FE_OFN361_FE_OFN81_n501
+ B1=FE_OFN507_n500 B2=i2_w[13]
XU1213 ND2 $PINS O=n1003 I1=n459 I2=n458
XU1214 MUX2 $PINS O=Py_in_to_look[13] S=FE_OFN510_n504 A=y3_w[13] B=y1[13]
XU1215 OAI22S $PINS O=n1036 A1=n642 A2=FE_OFN620_n498
+ B1=FE_OFN388_FE_OFN61_n496 B2=n460
XU1216 AOI22S $PINS O=n462 A1=FE_OFN355_FE_OFN94_n560 A2=Py_out_from_look[12]
+ B1=y3_w[12] B2=FE_OFN485_FE_DBTN71_n2
XU1217 AOI22S $PINS O=n461 A1=FE_PHN745_y1_12 A2=FE_OFN362_FE_OFN81_n501
+ B1=FE_OFN506_n500 B2=i2_w[12]
XU1218 ND2 $PINS O=n1004 I1=n462 I2=n461
XU1219 MUX2 $PINS O=Py_in_to_look[12] S=FE_OFN511_n504 A=y3_w[12] B=y1[12]
XU1220 OAI22S $PINS O=n1037 A1=n637 A2=n498 B1=FE_OFN388_FE_OFN61_n496
+ B2=FE_DBTN42_y3_w_11
XU1221 AOI22S $PINS O=n465 A1=FE_OFN354_FE_OFN94_n560 A2=Py_out_from_look[11]
+ B1=y3_w[11] B2=FE_OFN485_FE_DBTN71_n2
XU1222 AOI22S $PINS O=n464 A1=FE_PHN746_y1_11 A2=FE_OFN361_FE_OFN81_n501
+ B1=FE_OFN507_n500 B2=i2_w[11]
XU1223 ND2 $PINS O=n1005 I1=n465 I2=n464
XU1224 MUX2 $PINS O=Py_in_to_look[11] S=FE_OFN510_n504 A=y3_w[11] B=y1[11]
XU1225 OAI22S $PINS O=n1038 A1=n632 A2=n498 B1=FE_OFN388_FE_OFN61_n496 B2=n466
XU1226 AOI22S $PINS O=n468 A1=FE_OFN355_FE_OFN94_n560 A2=Py_out_from_look[10]
+ B1=y3_w[10] B2=FE_OFN486_FE_DBTN71_n2
XU1227 AOI22S $PINS O=n467 A1=FE_PHN1067_y1_10 A2=FE_OFN362_FE_OFN81_n501
+ B1=FE_OFN506_n500 B2=i2_w[10]
XU1228 ND2 $PINS O=n1006 I1=n468 I2=n467
XU1229 MUX2 $PINS O=Py_in_to_look[10] S=FE_OFN511_n504 A=y3_w[10] B=y1[10]
XU1230 OAI22S $PINS O=n1039 A1=n625 A2=n498 B1=FE_OFN388_FE_OFN61_n496
+ B2=FE_DBTN41_y3_w_9
XU1231 AOI22S $PINS O=n471 A1=FE_OFN354_FE_OFN94_n560 A2=Py_out_from_look[9]
+ B1=y3_w[9] B2=FE_OFN485_FE_DBTN71_n2
XU1232 AOI22S $PINS O=n470 A1=y1[9] A2=FE_OFN361_FE_OFN81_n501
+ B1=FE_OFN507_n500 B2=i2_w[9]
XU1233 ND2 $PINS O=FE_PHN1424_n1007 I1=n471 I2=n470
XU1234 MUX2 $PINS O=Py_in_to_look[9] S=FE_OFN510_n504 A=y3_w[9] B=y1[9]
XU1235 OAI22S $PINS O=n1040 A1=n619 A2=n498 B1=FE_OFN388_FE_OFN61_n496
+ B2=FE_PHN1199_n472
XU1236 AOI22S $PINS O=n474 A1=FE_OFN355_FE_OFN94_n560 A2=Py_out_from_look[8]
+ B1=y3_w[8] B2=FE_OFN486_FE_DBTN71_n2
XU1237 AOI22S $PINS O=n473 A1=FE_PHN750_y1_8 A2=FE_OFN362_FE_OFN81_n501
+ B1=FE_OFN506_n500 B2=i2_w[8]
XU1238 ND2 $PINS O=n1008 I1=n474 I2=n473
XU1239 MUX2 $PINS O=Py_in_to_look[8] S=FE_OFN511_n504 A=y3_w[8] B=y1[8]
XU1240 OAI22S $PINS O=n1041 A1=n613 A2=n498 B1=FE_OFN61_n496
+ B2=FE_DBTN40_y3_w_7
XU1241 AOI22S $PINS O=n477 A1=FE_OFN354_FE_OFN94_n560 A2=Py_out_from_look[7]
+ B1=y3_w[7] B2=FE_OFN485_FE_DBTN71_n2
XU1242 AOI22S $PINS O=n476 A1=FE_PHN1576_y1_7 A2=FE_OFN361_FE_OFN81_n501
+ B1=FE_OFN507_n500 B2=i2_w[7]
XU1243 ND2 $PINS O=n1009 I1=n477 I2=n476
XU1244 MUX2 $PINS O=Py_in_to_look[7] S=FE_OFN510_n504 A=y3_w[7] B=y1[7]
XU1245 OAI22S $PINS O=n1042 A1=n607 A2=n498 B1=FE_OFN61_n496
+ B2=FE_DBTN39_y3_w_6
XU1246 AOI22S $PINS O=n480 A1=FE_OFN355_FE_OFN94_n560 A2=Py_out_from_look[6]
+ B1=y3_w[6] B2=FE_OFN486_FE_DBTN71_n2
XU1247 AOI22S $PINS O=n479 A1=y1[6] A2=FE_OFN362_FE_OFN81_n501
+ B1=FE_OFN506_n500 B2=i2_w[6]
XU1248 ND2 $PINS O=n1010 I1=n480 I2=n479
XU1249 MUX2 $PINS O=Py_in_to_look[6] S=FE_OFN511_n504 A=y3_w[6] B=y1[6]
XU1250 OAI22S $PINS O=n1043 A1=n601 A2=n498 B1=FE_OFN61_n496
+ B2=FE_DBTN38_y3_w_5
XU1251 AOI22S $PINS O=n483 A1=FE_OFN354_FE_OFN94_n560 A2=Py_out_from_look[5]
+ B1=y3_w[5] B2=FE_OFN485_FE_DBTN71_n2
XU1252 AOI22S $PINS O=n482 A1=y1[5] A2=FE_OFN361_FE_OFN81_n501
+ B1=FE_OFN504_n500 B2=i2_w[5]
XU1253 ND2 $PINS O=n1011 I1=n483 I2=n482
XU1254 MUX2 $PINS O=Py_in_to_look[5] S=FE_OFN510_n504 A=y3_w[5] B=y1[5]
XU1255 OAI22S $PINS O=n1044 A1=n595 A2=n498 B1=FE_OFN61_n496 B2=n484
XU1256 AOI22S $PINS O=n486 A1=FE_OFN354_FE_OFN94_n560 A2=Py_out_from_look[4]
+ B1=y3_w[4] B2=FE_OFN485_FE_DBTN71_n2
XU1257 AOI22S $PINS O=n485 A1=y1[4] A2=FE_OFN361_FE_OFN81_n501
+ B1=FE_OFN507_n500 B2=i2_w[4]
XU1258 ND2 $PINS O=FE_PHN1343_n1012 I1=n486 I2=n485
XU1259 MUX2 $PINS O=Py_in_to_look[4] S=FE_OFN510_n504 A=y3_w[4] B=y1[4]
XU1260 OAI22S $PINS O=n1045 A1=n589 A2=n498 B1=FE_OFN61_n496
+ B2=FE_DBTN37_y3_w_3
XU1261 AOI22S $PINS O=n489 A1=FE_OFN354_FE_OFN94_n560 A2=Py_out_from_look[3]
+ B1=FE_PHN1300_y3_w_3 B2=FE_OFN485_FE_DBTN71_n2
XU1262 AOI22S $PINS O=n488 A1=FE_PHN1534_y1_3 A2=FE_OFN361_FE_OFN81_n501
+ B1=FE_OFN504_n500 B2=i2_w[3]
XU1263 ND2 $PINS O=n1013 I1=n489 I2=n488
XU1264 MUX2 $PINS O=Py_in_to_look[3] S=FE_OFN510_n504 A=FE_PHN1300_y3_w_3
+ B=y1[3]
XU1265 OAI22S $PINS O=n1046 A1=n583 A2=n498 B1=FE_OFN61_n496 B2=FE_PHN1179_n490
XU1266 AOI22S $PINS O=n492 A1=FE_OFN354_FE_OFN94_n560 A2=Py_out_from_look[2]
+ B1=y3_w[2] B2=FE_OFN485_FE_DBTN71_n2
XU1267 AOI22S $PINS O=n491 A1=FE_PHN757_y1_2 A2=FE_OFN361_FE_OFN81_n501
+ B1=FE_OFN504_n500 B2=i2_w[2]
XU1268 ND2 $PINS O=n1014 I1=n492 I2=n491
XU1269 MUX2 $PINS O=Py_in_to_look[2] S=FE_OFN510_n504 A=y3_w[2] B=y1[2]
XU1270 OAI22S $PINS O=n1047 A1=n574 A2=n498 B1=FE_OFN61_n496
+ B2=FE_DBTN36_y3_w_1
XU1271 AOI22S $PINS O=n495 A1=FE_OFN354_FE_OFN94_n560 A2=Py_out_from_look[1]
+ B1=y3_w[1] B2=FE_OFN485_FE_DBTN71_n2
XU1272 AOI22S $PINS O=n494 A1=y1[1] A2=FE_OFN361_FE_OFN81_n501
+ B1=FE_OFN504_n500 B2=i2_w[1]
XU1273 ND2 $PINS O=n1015 I1=n495 I2=n494
XU1274 MUX2 $PINS O=Py_in_to_look[1] S=FE_OFN510_n504 A=y3_w[1] B=y1[1]
XU1275 OAI22S $PINS O=n1191 A1=n554 A2=n498 B1=FE_DBTN35_y3_w_0
+ B2=FE_OFN61_n496
XU1276 AOI22S $PINS O=n503 A1=FE_OFN354_FE_OFN94_n560 A2=Py_out_from_look[0]
+ B1=y3_w[0] B2=FE_OFN485_FE_DBTN71_n2
XU1278 AOI22S $PINS O=n502 A1=y1[0] A2=FE_OFN361_FE_OFN81_n501
+ B1=FE_OFN504_n500 B2=i2_w[0]
XU1279 ND2 $PINS O=n1016 I1=n503 I2=n502
XU1280 MUX2 $PINS O=Py_in_to_look[0] S=FE_OFN511_n504 A=y3_w[0] B=y1[0]
XU1281 ND2 $PINS O=in_sig_w I1=n506 I2=n505
XU1282 OR3B2 $PINS O=n512 I1=n511 B1=n763 B2=n510
XU1283 AN4B1S $PINS O=n516 I1=n24 I2=n536 I3=n533 B1=n513
XU1284 ND2 $PINS O=operation_select[0] I1=n516 I2=n515
XU1285 AN3 $PINS O=n519 I1=n39 I2=n518 I3=n517
XU1286 AOI13HS $PINS O=GFAU_done_from_control A1=GFAU_done_to_control B1=n18
+ B2=n520 B3=n519
XU1287 ND2 $PINS O=operation_select[1] I1=n528 I2=n527
XU1288 OR3B2 $PINS O=n569 I1=n531 B1=n34 B2=n530
XU1289 AN4B1S $PINS O=n538 I1=n764 I2=n24 I3=n17 B1=n569
XU1290 OR2 $PINS O=n743 I1=n538 I2=n97
XU1291 OAI22S $PINS O=n1143 A1=n743 A2=n554 B1=FE_PHN1026_n769 B2=n742
XU1292 AN4B1S $PINS O=n550 I1=n555 I2=n558 I3=n548 B1=n547
XU1293 AN4B1S $PINS O=n552 I1=n46 I2=n551 I3=n550 B1=n549
XU1294 ND2 $PINS O=n745 I1=n41 I2=n553
XU1295 OAI22S $PINS O=n1079 A1=n745 A2=n554 B1=n41 B2=FE_PHN1124_n768
XU1296 MUX2 $PINS O=n1184 S=FE_OFN519_n1408 A=FE_PHN1025_a_0
+ B=transferred_a_w0[0]
XU1297 OR3B2 $PINS O=n562 I1=n561 B1=n60 B2=n560
XU1298 OAI222S $PINS O=FE_PHN1346_n920 A1=FE_OFN383_FE_OFN63_n1382 A2=n564
+ B1=FE_OFN515_n1380 B2=n772 C1=FE_OFN386_FE_OFN62_n1379 C2=FE_DBTN34_i1_w_0
XU1299 AN3 $PINS O=n566 I1=n28 I2=n766 I3=n26
XU1301 OR3B2 $PINS O=n572 I1=n571 B1=n570 B2=n763
XU1302 OAI22S $PINS O=n1142 A1=n743 A2=n574 B1=FE_PHN982_n779 B2=n742
XU1303 OAI22S $PINS O=n1078 A1=n745 A2=n574 B1=n41 B2=FE_PHN766_n778
XU1304 MUX2 $PINS O=n1183 S=FE_OFN519_n1408 A=FE_PHN1046_a_1
+ B=transferred_a_w0[1]
XU1305 OAI222S $PINS O=n919 A1=FE_OFN383_FE_OFN63_n1382 A2=n579
+ B1=FE_OFN515_n1380 B2=n782 C1=FE_OFN386_FE_OFN62_n1379 C2=FE_DBTN33_i1_w_1
XU1306 OA222 $PINS O=n581 A1=n762 A2=n782 B1=n750 B2=n778 C1=n30 C2=n580
XU1307 OAI22S $PINS O=n1141 A1=n743 A2=n583 B1=FE_PHN977_n789 B2=n742
XU1308 OAI22S $PINS O=n1077 A1=n745 A2=n583 B1=n41 B2=FE_PHN1087_n788
XU1309 MUX2 $PINS O=n1182 S=FE_OFN519_n1408 A=FE_PHN1084_a_2
+ B=transferred_a_w0[2]
XU1310 OAI222S $PINS O=n918 A1=FE_OFN383_FE_OFN63_n1382 A2=n585
+ B1=FE_OFN515_n1380 B2=n792 C1=FE_OFN386_FE_OFN62_n1379 C2=n584
XU1311 OA222 $PINS O=n587 A1=n762 A2=n792 B1=n750 B2=n788 C1=n30 C2=n586
XU1312 OAI22S $PINS O=n1140 A1=n743 A2=n589 B1=FE_PHN989_n799 B2=n742
XU1313 OAI22S $PINS O=n1076 A1=n745 A2=n589 B1=n41 B2=FE_PHN862_n798
XU1314 MUX2 $PINS O=n1181 S=FE_OFN519_n1408 A=FE_PHN1556_a_3
+ B=transferred_a_w0[3]
XU1315 OAI222S $PINS O=n917 A1=FE_OFN383_FE_OFN63_n1382 A2=n591
+ B1=FE_OFN515_n1380 B2=n802 C1=FE_OFN386_FE_OFN62_n1379 C2=FE_DBTN32_i1_w_3
XU1316 OA222 $PINS O=n593 A1=n762 A2=n802 B1=n750 B2=n798 C1=n30 C2=n592
XU1317 OAI22S $PINS O=n1139 A1=n743 A2=n595 B1=FE_PHN966_n809 B2=n742
XU1318 OAI22S $PINS O=n1075 A1=n745 A2=n595 B1=n41 B2=FE_PHN1126_n808
XU1319 MUX2 $PINS O=n1180 S=FE_OFN521_n1408 A=FE_PHN1080_a_4
+ B=transferred_a_w0[4]
XU1320 OAI222S $PINS O=n916 A1=FE_OFN383_FE_OFN63_n1382 A2=n597 B1=n1380
+ B2=n812 C1=FE_OFN386_FE_OFN62_n1379 C2=n596
XU1321 OA222 $PINS O=n599 A1=n762 A2=n812 B1=n750 B2=n808 C1=n30 C2=n598
XU1322 ND2 $PINS O=Py_mont[4] I1=n600 I2=n599
XU1323 OAI22S $PINS O=n1138 A1=n743 A2=n601 B1=FE_PHN993_n819 B2=n742
XU1324 OAI22S $PINS O=n1074 A1=n745 A2=n601 B1=n41 B2=FE_PHN1591_n818
XU1325 MUX2 $PINS O=n1179 S=FE_OFN520_n1408 A=FE_PHN945_a_5
+ B=transferred_a_w0[5]
XU1326 OAI222S $PINS O=FE_PHN1390_n915 A1=FE_OFN383_FE_OFN63_n1382 A2=n603
+ B1=FE_OFN515_n1380 B2=n822 C1=FE_OFN386_FE_OFN62_n1379 C2=FE_DBTN31_i1_w_5
XU1327 OA222 $PINS O=n605 A1=n762 A2=n822 B1=n750 B2=n818 C1=n30 C2=n604
XU1328 ND2P $PINS O=Py_mont[5] I1=n606 I2=n605
XU1329 OAI22S $PINS O=n1137 A1=FE_OFN621_n743 A2=n607 B1=FE_PHN976_n829
+ B2=FE_OFN512_n742
XU1330 OAI22S $PINS O=n1073 A1=FE_OFN622_n745 A2=n607 B1=FE_OFN503_n41
+ B2=FE_PHN1115_n828
XU1331 MUX2 $PINS O=n1178 S=FE_OFN520_n1408 A=FE_PHN1045_a_6
+ B=transferred_a_w0[6]
XU1332 OAI222S $PINS O=FE_PHN1381_n914 A1=FE_OFN382_FE_OFN63_n1382 A2=n609
+ B1=n1380 B2=n832 C1=n1379 C2=n608
XU1333 OA222 $PINS O=n611 A1=FE_OFN513_n762 A2=n832 B1=FE_OFN349_FE_OFN116_n572
+ B2=n828 C1=FE_OFN502_n30 C2=n610
XU1334 ND2 $PINS O=Py_mont[6] I1=n612 I2=n611
XU1335 OAI22S $PINS O=n1136 A1=n743 A2=n613 B1=FE_PHN963_n839 B2=n742
XU1336 OAI22S $PINS O=n1072 A1=FE_OFN622_n745 A2=n613 B1=n41 B2=FE_PHN1634_n838
XU1337 MUX2 $PINS O=n1177 S=FE_OFN520_n1408 A=FE_PHN1085_a_7
+ B=transferred_a_w0[7]
XU1338 OAI222S $PINS O=FE_PHN1385_n913 A1=FE_OFN382_FE_OFN63_n1382 A2=n615
+ B1=n1380 B2=n842 C1=FE_OFN386_FE_OFN62_n1379 C2=FE_DBTN30_i1_w_7
XU1339 OA222 $PINS O=n617 A1=n762 A2=n842 B1=n750 B2=n838 C1=n30 C2=n616
XU1340 ND2 $PINS O=Py_mont[7] I1=n618 I2=n617
XU1341 OAI22S $PINS O=n1135 A1=FE_OFN621_n743 A2=n619 B1=FE_PHN1475_n849
+ B2=FE_OFN512_n742
XU1342 OAI22S $PINS O=n1071 A1=FE_OFN622_n745 A2=n619 B1=FE_OFN503_n41
+ B2=FE_PHN1509_n848
XU1343 MUX2 $PINS O=n1176 S=FE_OFN520_n1408 A=FE_PHN1036_a_8
+ B=transferred_a_w0[8]
XU1344 OAI222S $PINS O=n912 A1=FE_OFN63_n1382 A2=n621 B1=FE_OFN514_n1380
+ B2=n852 C1=FE_OFN385_FE_OFN62_n1379 C2=n620
XU1345 OA222 $PINS O=n623 A1=FE_OFN513_n762 A2=n852 B1=FE_OFN349_FE_OFN116_n572
+ B2=n848 C1=FE_OFN502_n30 C2=n622
XU1346 ND2 $PINS O=Py_mont[8] I1=n624 I2=n623
XU1347 OAI22S $PINS O=n1134 A1=FE_OFN621_n743 A2=n625 B1=FE_PHN985_n859
+ B2=FE_OFN512_n742
XU1348 OAI22S $PINS O=n1070 A1=FE_OFN622_n745 A2=n625 B1=FE_OFN503_n41
+ B2=FE_PHN1637_n858
XU1349 MUX2 $PINS O=n1175 S=FE_OFN520_n1408 A=FE_PHN1105_a_9
+ B=transferred_a_w0[9]
XU1350 OAI222S $PINS O=FE_PHN1394_n911 A1=FE_OFN382_FE_OFN63_n1382 A2=n627
+ B1=n1380 B2=n862 C1=n1379 C2=FE_DBTN29_i1_w_9
XU1351 OA222 $PINS O=n629 A1=FE_OFN513_n762 A2=n862 B1=FE_OFN349_FE_OFN116_n572
+ B2=n858 C1=FE_OFN502_n30 C2=n628
XU1352 ND2 $PINS O=Py_mont[9] I1=n630 I2=n629
XU1353 OAI22S $PINS O=n1133 A1=FE_OFN621_n743 A2=n632 B1=FE_PHN965_n869
+ B2=FE_OFN512_n742
XU1354 OAI22S $PINS O=n1069 A1=FE_OFN622_n745 A2=n632 B1=FE_OFN503_n41
+ B2=FE_PHN1513_n868
XU1355 OAI222S $PINS O=n910 A1=FE_OFN63_n1382 A2=n634 B1=FE_OFN514_n1380
+ B2=n872 C1=FE_OFN385_FE_OFN62_n1379 C2=n633
XU1356 ND2 $PINS O=Py_mont[10] I1=n636 I2=n635
XU1357 OAI22S $PINS O=n1132 A1=FE_OFN621_n743 A2=n637 B1=FE_PHN969_n879 B2=n742
XU1358 OAI22S $PINS O=n1068 A1=FE_OFN622_n745 A2=n637 B1=FE_OFN503_n41
+ B2=FE_PHN1635_n878
XU1359 OAI222S $PINS O=FE_PHN1398_n909 A1=FE_OFN382_FE_OFN63_n1382 A2=n639
+ B1=n1380 B2=n882 C1=n1379 C2=FE_DBTN28_i1_w_11
XU1360 OA222 $PINS O=n641 A1=n749 A2=n881 B1=n748 B2=n877 C1=FE_OFN498_n16
+ C2=n879
XU1361 ND2 $PINS O=Py_mont[11] I1=n641 I2=n640
XU1362 OAI22S $PINS O=n1131 A1=FE_OFN621_n743 A2=n642 B1=FE_PHN1463_n1192
+ B2=FE_OFN512_n742
XU1363 OAI22S $PINS O=n1067 A1=FE_OFN622_n745 A2=n642 B1=FE_OFN503_n41
+ B2=FE_PHN1501_n888
XU1364 OAI222S $PINS O=n908 A1=FE_OFN63_n1382 A2=n644 B1=FE_OFN514_n1380
+ B2=n1195 C1=FE_OFN385_FE_OFN62_n1379 C2=n643
XU1365 ND2 $PINS O=Py_mont[12] I1=n647 I2=n646
XU1366 OAI22S $PINS O=n1130 A1=n743 A2=n648 B1=FE_PHN981_n1202
+ B2=FE_OFN512_n742
XU1367 OAI22S $PINS O=n1066 A1=FE_OFN622_n745 A2=n648 B1=n41 B2=FE_PHN856_n1201
XU1368 OAI222S $PINS O=FE_PHN1377_n907 A1=FE_OFN382_FE_OFN63_n1382 A2=n650
+ B1=n1380 B2=n1205 C1=n1379 C2=FE_DBTN27_i1_w_13
XU1369 OA222 $PINS O=n652 A1=n749 A2=n1204 B1=n748 B2=n1200 C1=n16 C2=n1202
XU1370 OA222 $PINS O=n651 A1=n762 A2=n1205 B1=n750 B2=n1201 C1=n1431 C2=n30
XU1371 ND2 $PINS O=Py_mont[13] I1=n652 I2=n651
XU1372 OAI22S $PINS O=n1129 A1=FE_OFN621_n743 A2=n653 B1=FE_PHN1479_n1212
+ B2=FE_OFN512_n742
XU1373 OAI22S $PINS O=n1065 A1=FE_OFN622_n745 A2=n653 B1=FE_OFN503_n41
+ B2=FE_PHN1039_n1211
XU1374 OAI222S $PINS O=n906 A1=FE_OFN63_n1382 A2=n655 B1=FE_OFN514_n1380
+ B2=n1215 C1=FE_OFN385_FE_OFN62_n1379 C2=n654
XU1375 OA222 $PINS O=n656 A1=FE_OFN513_n762 A2=n1215
+ B1=FE_OFN349_FE_OFN116_n572 B2=n1211 C1=n1430 C2=FE_OFN502_n30
XU1376 ND2 $PINS O=Py_mont[14] I1=n657 I2=n656
XU1377 OAI22S $PINS O=n1128 A1=n743 A2=n658 B1=FE_PHN1483_n1222 B2=n742
XU1378 OAI22S $PINS O=n1064 A1=n745 A2=n658 B1=n41 B2=FE_PHN1603_n1221
XU1379 OAI222S $PINS O=n905 A1=n1382 A2=n660 B1=n1380 B2=n1225 C1=n1379
+ C2=FE_DBTN26_i1_w_15
XU1380 OA222 $PINS O=n662 A1=n749 A2=n1224 B1=n748 B2=n1220 C1=n16 C2=n1222
XU1381 OA222 $PINS O=n661 A1=n762 A2=n1225 B1=n750 B2=n1221 C1=n1429 C2=n30
XU1382 ND2 $PINS O=Py_mont[15] I1=n662 I2=n661
XU1383 OAI22S $PINS O=n1127 A1=FE_OFN621_n743 A2=n663 B1=FE_PHN1000_n1232
+ B2=FE_OFN512_n742
XU1384 OAI22S $PINS O=n1063 A1=FE_OFN622_n745 A2=n663 B1=FE_OFN503_n41
+ B2=FE_PHN753_n1231
XU1385 OAI222S $PINS O=n904 A1=FE_OFN63_n1382 A2=n665 B1=FE_OFN514_n1380
+ B2=n1235 C1=FE_OFN385_FE_OFN62_n1379 C2=n664
XU1386 OA222 $PINS O=n666 A1=FE_OFN513_n762 A2=n1235
+ B1=FE_OFN349_FE_OFN116_n572 B2=n1231 C1=n1428 C2=FE_OFN502_n30
XU1387 ND2 $PINS O=Py_mont[16] I1=n667 I2=n666
XU1388 OAI22S $PINS O=n1126 A1=n743 A2=n669 B1=FE_PHN983_n1242 B2=n742
XU1389 OAI22S $PINS O=n1062 A1=FE_OFN622_n745 A2=n669 B1=n41
+ B2=FE_PHN1075_n1241
XU1390 OAI222S $PINS O=n903 A1=FE_OFN63_n1382 A2=n671 B1=n1380 B2=n1245
+ C1=n1379 C2=FE_DBTN25_i1_w_17
XU1391 OA222 $PINS O=n676 A1=n749 A2=n1244 B1=n748 B2=n1240 C1=n16 C2=n1242
XU1392 OA222 $PINS O=n672 A1=n762 A2=n1245 B1=n750 B2=n1241 C1=n1427 C2=n30
XU1393 ND2 $PINS O=Py_mont[17] I1=n676 I2=n672
XU1394 OAI22S $PINS O=n1125 A1=FE_OFN621_n743 A2=n677 B1=FE_PHN979_n1252
+ B2=FE_OFN512_n742
XU1395 OAI22S $PINS O=n1061 A1=FE_OFN622_n745 A2=n677 B1=FE_OFN503_n41
+ B2=FE_PHN829_n1251
XU1396 OAI222S $PINS O=n902 A1=FE_OFN63_n1382 A2=n679 B1=FE_OFN514_n1380
+ B2=n1255 C1=FE_OFN385_FE_OFN62_n1379 C2=n678
XU1397 OA222 $PINS O=n680 A1=FE_OFN513_n762 A2=n1255
+ B1=FE_OFN349_FE_OFN116_n572 B2=n1251 C1=n1426 C2=FE_OFN502_n30
XU1398 ND2 $PINS O=Py_mont[18] I1=n681 I2=n680
XU1399 OAI22S $PINS O=n1124 A1=n743 A2=n682 B1=FE_PHN980_n1262 B2=n742
XU1400 OAI22S $PINS O=n1060 A1=FE_OFN622_n745 A2=n682 B1=n41 B2=FE_PHN781_n1261
XU1401 OAI222S $PINS O=FE_PHN1395_n901 A1=FE_OFN63_n1382 A2=n684
+ B1=FE_OFN514_n1380 B2=n1265 C1=FE_OFN385_FE_OFN62_n1379 C2=FE_DBTN24_i1_w_19
XU1402 OA222 $PINS O=n686 A1=n749 A2=n1264 B1=n748 B2=n1260 C1=n16 C2=n1262
XU1403 OA222 $PINS O=n685 A1=n762 A2=n1265 B1=n750 B2=n1261 C1=n1425 C2=n30
XU1404 ND2 $PINS O=Py_mont[19] I1=n686 I2=n685
XU1405 OAI22S $PINS O=n1123 A1=FE_OFN621_n743 A2=n687 B1=FE_PHN1065_n1272
+ B2=FE_OFN512_n742
XU1406 OAI22S $PINS O=n1059 A1=FE_OFN622_n745 A2=n687 B1=FE_OFN503_n41
+ B2=FE_PHN866_n1271
XU1407 OAI222S $PINS O=n900 A1=FE_OFN63_n1382 A2=n689 B1=FE_OFN514_n1380
+ B2=n1275 C1=FE_OFN385_FE_OFN62_n1379 C2=n688
XU1408 OA222 $PINS O=n691 A1=FE_OFN346_FE_OFN322_n749 A2=n1274
+ B1=FE_OFN623_n748 B2=n1270 C1=FE_OFN498_n16 C2=n1272
XU1409 OA222 $PINS O=n690 A1=FE_OFN513_n762 A2=n1275
+ B1=FE_OFN349_FE_OFN116_n572 B2=n1271 C1=n1424 C2=FE_OFN502_n30
XU1410 ND2 $PINS O=Py_mont[20] I1=n691 I2=n690
XU1411 OAI22S $PINS O=n1122 A1=n743 A2=n692 B1=FE_PHN991_n1282 B2=n742
XU1412 OAI22S $PINS O=n1058 A1=n745 A2=n692 B1=n41 B2=FE_PHN1047_n1281
XU1413 OAI222S $PINS O=n899 A1=n1382 A2=n694 B1=n1380 B2=n1285 C1=n1379
+ C2=FE_DBTN23_i1_w_21
XU1414 OA222 $PINS O=n696 A1=n749 A2=n1284 B1=n748 B2=n1280 C1=n16 C2=n1282
XU1415 OA222 $PINS O=n695 A1=n762 A2=n1285 B1=n750 B2=n1281 C1=n1423 C2=n30
XU1416 ND2 $PINS O=Py_mont[21] I1=n696 I2=n695
XU1417 OAI22S $PINS O=n1121 A1=FE_OFN621_n743 A2=n697 B1=FE_PHN1033_n1292
+ B2=FE_OFN512_n742
XU1418 OAI22S $PINS O=n1057 A1=FE_OFN622_n745 A2=n697 B1=FE_OFN503_n41
+ B2=FE_PHN967_n1291
XU1419 OAI222S $PINS O=n898 A1=FE_OFN63_n1382 A2=n699 B1=FE_OFN514_n1380
+ B2=n1295 C1=FE_OFN385_FE_OFN62_n1379 C2=n698
XU1420 OA222 $PINS O=n700 A1=FE_OFN513_n762 A2=n1295
+ B1=FE_OFN349_FE_OFN116_n572 B2=n1291 C1=n1422 C2=FE_OFN502_n30
XU1421 ND2 $PINS O=Py_mont[22] I1=n701 I2=n700
XU1422 OAI22S $PINS O=n1120 A1=FE_OFN621_n743 A2=n702 B1=FE_PHN978_n1302
+ B2=FE_OFN512_n742
XU1423 OAI22S $PINS O=n1056 A1=n745 A2=n702 B1=FE_OFN503_n41 B2=FE_PHN968_n1301
XU1424 OAI222S $PINS O=n897 A1=FE_OFN63_n1382 A2=n704 B1=FE_OFN514_n1380
+ B2=n1305 C1=FE_OFN385_FE_OFN62_n1379 C2=FE_DBTN22_i1_w_23
XU1425 OA222 $PINS O=n705 A1=FE_OFN513_n762 A2=n1305
+ B1=FE_OFN349_FE_OFN116_n572 B2=n1301 C1=n1421 C2=FE_OFN502_n30
XU1426 ND2 $PINS O=Py_mont[23] I1=n706 I2=n705
XU1427 OAI22S $PINS O=n1119 A1=FE_OFN621_n743 A2=n707 B1=FE_PHN1563_n1312
+ B2=FE_OFN512_n742
XU1428 OAI22S $PINS O=n1055 A1=FE_OFN622_n745 A2=n707 B1=FE_OFN503_n41
+ B2=FE_PHN1058_n1311
XU1429 OAI222S $PINS O=n896 A1=FE_OFN63_n1382 A2=n709 B1=FE_OFN514_n1380
+ B2=n1315 C1=FE_OFN385_FE_OFN62_n1379 C2=n708
XU1430 OA222 $PINS O=n710 A1=FE_OFN513_n762 A2=n1315
+ B1=FE_OFN349_FE_OFN116_n572 B2=n1311 C1=n1420 C2=FE_OFN502_n30
XU1431 ND2 $PINS O=Py_mont[24] I1=n711 I2=n710
XU1432 OAI22S $PINS O=n1118 A1=FE_OFN621_n743 A2=n712 B1=FE_PHN1011_n1322
+ B2=FE_OFN512_n742
XU1433 OAI22S $PINS O=n1054 A1=n745 A2=n712 B1=FE_OFN503_n41 B2=FE_PHN928_n1321
XU1434 OAI222S $PINS O=n895 A1=FE_OFN63_n1382 A2=n714 B1=FE_OFN514_n1380
+ B2=n1325 C1=FE_OFN385_FE_OFN62_n1379 C2=FE_DBTN21_i1_w_25
XU1435 OA222 $PINS O=n715 A1=FE_OFN513_n762 A2=n1325
+ B1=FE_OFN349_FE_OFN116_n572 B2=n1321 C1=n1419 C2=FE_OFN502_n30
XU1436 ND2 $PINS O=Py_mont[25] I1=n716 I2=n715
XU1437 OAI22S $PINS O=n1117 A1=FE_OFN621_n743 A2=n717 B1=FE_PHN1517_n1332
+ B2=FE_OFN512_n742
XU1438 OAI22S $PINS O=n1053 A1=FE_OFN622_n745 A2=n717 B1=FE_OFN503_n41
+ B2=FE_PHN820_n1331
XU1439 OAI222S $PINS O=n894 A1=FE_OFN63_n1382 A2=n719 B1=FE_OFN514_n1380
+ B2=n1335 C1=FE_OFN385_FE_OFN62_n1379 C2=n718
XU1440 OA222 $PINS O=n720 A1=FE_OFN513_n762 A2=n1335
+ B1=FE_OFN349_FE_OFN116_n572 B2=n1331 C1=n1418 C2=FE_OFN502_n30
XU1441 ND2 $PINS O=Py_mont[26] I1=n721 I2=n720
XU1442 OAI22S $PINS O=n1116 A1=FE_OFN621_n743 A2=n722 B1=FE_PHN1041_n1342
+ B2=FE_OFN512_n742
XU1443 OAI22S $PINS O=n1052 A1=n745 A2=n722 B1=FE_OFN503_n41 B2=FE_PHN805_n1341
XU1444 OAI222S $PINS O=n893 A1=FE_OFN63_n1382 A2=n724 B1=FE_OFN514_n1380
+ B2=n1345 C1=FE_OFN385_FE_OFN62_n1379 C2=FE_DBTN20_i1_w_27
XU1445 OA222 $PINS O=n726 A1=FE_OFN322_n749 A2=n1344 B1=FE_OFN623_n748 B2=n1340
+ C1=FE_OFN498_n16 C2=n1342
XU1446 OA222 $PINS O=n725 A1=FE_OFN513_n762 A2=n1345
+ B1=FE_OFN349_FE_OFN116_n572 B2=n1341 C1=n1417 C2=FE_OFN502_n30
XU1447 ND2 $PINS O=Py_mont[27] I1=n726 I2=n725
XU1448 OAI22S $PINS O=n1115 A1=FE_OFN621_n743 A2=n727 B1=FE_PHN1006_n1352
+ B2=FE_OFN512_n742
XU1449 OAI22S $PINS O=n1051 A1=FE_OFN622_n745 A2=n727 B1=FE_OFN503_n41
+ B2=FE_PHN873_n1351
XU1450 OAI222S $PINS O=n892 A1=FE_OFN63_n1382 A2=n729 B1=FE_OFN514_n1380
+ B2=n1355 C1=FE_OFN385_FE_OFN62_n1379 C2=n728
XU1451 OA222 $PINS O=n731 A1=FE_OFN346_FE_OFN322_n749 A2=n1354
+ B1=FE_OFN623_n748 B2=n1350 C1=FE_OFN498_n16 C2=n1352
XU1452 OA222 $PINS O=n730 A1=FE_OFN513_n762 A2=n1355
+ B1=FE_OFN349_FE_OFN116_n572 B2=n1351 C1=n1416 C2=FE_OFN502_n30
XU1453 ND2 $PINS O=Py_mont[28] I1=n731 I2=n730
XU1454 OAI22S $PINS O=n1114 A1=FE_OFN621_n743 A2=n732 B1=FE_PHN1031_n1362
+ B2=FE_OFN512_n742
XU1455 OAI22S $PINS O=n1050 A1=n745 A2=n732 B1=FE_OFN503_n41 B2=FE_PHN882_n1361
XU1456 OAI222S $PINS O=FE_PHN1410_n891 A1=FE_OFN63_n1382 A2=n734
+ B1=FE_OFN514_n1380 B2=n1365 C1=FE_OFN385_FE_OFN62_n1379 C2=FE_DBTN19_i1_w_29
XU1457 OA222 $PINS O=n736 A1=FE_OFN322_n749 A2=n1364 B1=FE_OFN623_n748 B2=n1360
+ C1=FE_OFN498_n16 C2=n1362
XU1458 OA222 $PINS O=n735 A1=FE_OFN513_n762 A2=n1365
+ B1=FE_OFN349_FE_OFN116_n572 B2=n1361 C1=n1415 C2=FE_OFN502_n30
XU1459 ND2 $PINS O=Py_mont[29] I1=n736 I2=n735
XU1460 OAI22S $PINS O=n1113 A1=FE_OFN621_n743 A2=n737 B1=FE_PHN1042_n1372
+ B2=FE_OFN512_n742
XU1461 OAI22S $PINS O=n1049 A1=FE_OFN622_n745 A2=n737 B1=FE_OFN503_n41
+ B2=FE_PHN1014_n1371
XU1462 OAI222S $PINS O=n890 A1=FE_OFN63_n1382 A2=n739 B1=FE_OFN514_n1380
+ B2=n1375 C1=FE_OFN385_FE_OFN62_n1379 C2=n738
XU1463 OA222 $PINS O=n741 A1=FE_OFN346_FE_OFN322_n749 A2=n1374
+ B1=FE_OFN623_n748 B2=n1370 C1=FE_OFN498_n16 C2=n1372
XU1464 OA222 $PINS O=n740 A1=FE_OFN513_n762 A2=n1375
+ B1=FE_OFN349_FE_OFN116_n572 B2=n1371 C1=n1414 C2=FE_OFN502_n30
XU1465 ND2 $PINS O=Py_mont[30] I1=n741 I2=n740
XU1466 OAI22S $PINS O=n1112 A1=n744 A2=FE_OFN621_n743 B1=FE_PHN996_n1386
+ B2=FE_OFN512_n742
XU1467 OAI22S $PINS O=n1048 A1=FE_OFN622_n745 A2=n744 B1=FE_OFN503_n41
+ B2=FE_PHN949_n1385
XU1468 OAI222S $PINS O=n889 A1=FE_OFN63_n1382 A2=n747 B1=FE_OFN514_n1380
+ B2=n1389 C1=FE_OFN385_FE_OFN62_n1379 C2=n746
XU1469 OA222 $PINS O=n752 A1=FE_OFN346_FE_OFN322_n749 A2=n1388
+ B1=FE_OFN623_n748 B2=n1383 C1=FE_OFN498_n16 C2=n1386
XU1470 OA222 $PINS O=n751 A1=FE_OFN513_n762 A2=n1389
+ B1=FE_OFN349_FE_OFN116_n572 B2=n1385 C1=n1413 C2=FE_OFN502_n30
XU1471 ND2 $PINS O=Py_mont[31] I1=n752 I2=n751
XU1472 OAI222S $PINS O=n984 A1=FE_OFN383_FE_OFN63_n1382 A2=n754
+ B1=FE_OFN515_n1380 B2=n770 C1=FE_OFN386_FE_OFN62_n1379 C2=FE_DBTN18_i2_w_0
XU1473 OA222 $PINS O=n773 A1=n24 A2=n772 B1=n26 B2=n771 C1=n28 C2=n770
XU1474 OAI222S $PINS O=FE_PHN1409_n983 A1=FE_OFN383_FE_OFN63_n1382 A2=n776
+ B1=FE_OFN515_n1380 B2=n780 C1=FE_OFN386_FE_OFN62_n1379 C2=FE_DBTN17_i2_w_1
XU1475 OA222 $PINS O=n783 A1=n24 A2=n782 B1=n26 B2=n781 C1=n28 C2=n780
XU1476 OAI222S $PINS O=n982 A1=FE_OFN383_FE_OFN63_n1382 A2=n786
+ B1=FE_OFN515_n1380 B2=n790 C1=FE_OFN386_FE_OFN62_n1379 C2=n785
XU1477 OA222 $PINS O=n793 A1=n24 A2=n792 B1=n26 B2=n791 C1=n28 C2=n790
XU1478 OAI222S $PINS O=n981 A1=FE_OFN383_FE_OFN63_n1382 A2=n796
+ B1=FE_OFN515_n1380 B2=n800 C1=FE_OFN386_FE_OFN62_n1379 C2=FE_DBTN16_i2_w_3
XU1479 OA222 $PINS O=n803 A1=n24 A2=n802 B1=n26 B2=n801 C1=n28 C2=n800
XU1480 ND2 $PINS O=Px_mont[3] I1=n804 I2=n803
XU1481 OAI222S $PINS O=n980 A1=FE_OFN383_FE_OFN63_n1382 A2=n806
+ B1=FE_OFN515_n1380 B2=n810 C1=FE_OFN386_FE_OFN62_n1379 C2=n805
XU1482 OA222 $PINS O=n813 A1=n24 A2=n812 B1=n26 B2=n811 C1=n28 C2=n810
XU1483 ND2P $PINS O=Px_mont[4] I1=n814 I2=n813
XU1484 OAI222S $PINS O=n979 A1=FE_OFN383_FE_OFN63_n1382 A2=n816
+ B1=FE_OFN515_n1380 B2=n820 C1=FE_OFN386_FE_OFN62_n1379 C2=FE_DBTN15_i2_w_5
XU1485 OA222 $PINS O=n823 A1=n24 A2=n822 B1=n26 B2=n821 C1=n28 C2=n820
XU1486 ND2 $PINS O=Px_mont[5] I1=n824 I2=n823
XU1487 OAI222S $PINS O=n978 A1=FE_OFN384_FE_OFN63_n1382 A2=n826
+ B1=FE_OFN516_n1380 B2=n830 C1=FE_OFN387_FE_OFN62_n1379 C2=n825
XU1488 OA222 $PINS O=n833 A1=FE_OFN499_n24 A2=n832 B1=FE_OFN500_n26 B2=n831
+ C1=FE_OFN501_n28 C2=n830
XU1489 ND2 $PINS O=Px_mont[6] I1=n834 I2=n833
XU1490 OAI222S $PINS O=n977 A1=FE_OFN384_FE_OFN63_n1382 A2=n836
+ B1=FE_OFN515_n1380 B2=n840 C1=FE_OFN387_FE_OFN62_n1379 C2=FE_DBTN14_i2_w_7
XU1491 OA222 $PINS O=n843 A1=n24 A2=n842 B1=n26 B2=n841 C1=n28 C2=n840
XU1492 ND2 $PINS O=Px_mont[7] I1=n844 I2=n843
XU1493 OAI222S $PINS O=n976 A1=FE_OFN384_FE_OFN63_n1382 A2=n846
+ B1=FE_OFN516_n1380 B2=n850 C1=FE_OFN387_FE_OFN62_n1379 C2=n845
XU1494 OA222 $PINS O=n854 A1=FE_OFN118_n31 A2=n849 B1=FE_OFN347_FE_OFN316_n21
+ B2=n848 C1=FE_OFN653_n1384 C2=n847
XU1495 OA222 $PINS O=n853 A1=FE_OFN499_n24 A2=n852 B1=FE_OFN500_n26 B2=n851
+ C1=FE_OFN501_n28 C2=n850
XU1496 ND2 $PINS O=Px_mont[8] I1=n854 I2=n853
XU1497 OAI222S $PINS O=n975 A1=FE_OFN384_FE_OFN63_n1382 A2=n856
+ B1=FE_OFN515_n1380 B2=n860 C1=FE_OFN387_FE_OFN62_n1379 C2=FE_DBTN13_i2_w_9
XU1498 OA222 $PINS O=n863 A1=FE_OFN499_n24 A2=n862 B1=FE_OFN500_n26 B2=n861
+ C1=FE_OFN501_n28 C2=n860
XU1499 ND2 $PINS O=Px_mont[9] I1=n864 I2=n863
XU1500 OAI222S $PINS O=n974 A1=FE_OFN384_FE_OFN63_n1382 A2=n866
+ B1=FE_OFN516_n1380 B2=n870 C1=FE_OFN387_FE_OFN62_n1379 C2=n865
XU1501 OA222 $PINS O=n873 A1=FE_OFN499_n24 A2=n872 B1=FE_OFN500_n26 B2=n871
+ C1=FE_OFN501_n28 C2=n870
XU1502 ND2 $PINS O=Px_mont[10] I1=n874 I2=n873
XU1503 OAI222S $PINS O=n973 A1=FE_OFN384_FE_OFN63_n1382 A2=n876
+ B1=FE_OFN515_n1380 B2=n880 C1=FE_OFN387_FE_OFN62_n1379 C2=FE_DBTN12_i2_w_11
XU1504 OA222 $PINS O=n883 A1=FE_OFN499_n24 A2=n882 B1=FE_OFN500_n26 B2=n881
+ C1=FE_OFN501_n28 C2=n880
XU1505 ND2 $PINS O=Px_mont[11] I1=n884 I2=n883
XU1506 OAI222S $PINS O=n972 A1=FE_OFN384_FE_OFN63_n1382 A2=n886
+ B1=FE_OFN516_n1380 B2=n1193 C1=FE_OFN387_FE_OFN62_n1379 C2=n885
XU1507 OA222 $PINS O=n1196 A1=FE_OFN499_n24 A2=n1195 B1=FE_OFN500_n26 B2=n1194
+ C1=FE_OFN501_n28 C2=n1193
XU1508 ND2 $PINS O=Px_mont[12] I1=n1197 I2=n1196
XU1509 OAI222S $PINS O=n971 A1=FE_OFN384_FE_OFN63_n1382 A2=n1199
+ B1=FE_OFN515_n1380 B2=n1203 C1=FE_OFN387_FE_OFN62_n1379 C2=FE_DBTN11_i2_w_13
XU1510 OA222 $PINS O=n1206 A1=n24 A2=n1205 B1=n26 B2=n1204 C1=n28 C2=n1203
XU1511 ND2 $PINS O=Px_mont[13] I1=n1207 I2=n1206
XU1512 OAI222S $PINS O=n970 A1=FE_OFN384_FE_OFN63_n1382 A2=n1209
+ B1=FE_OFN516_n1380 B2=n1213 C1=FE_OFN387_FE_OFN62_n1379 C2=n1208
XU1513 OA222 $PINS O=n1216 A1=FE_OFN499_n24 A2=n1215 B1=FE_OFN500_n26 B2=n1214
+ C1=FE_OFN501_n28 C2=n1213
XU1514 ND2 $PINS O=Px_mont[14] I1=n1217 I2=n1216
XU1515 OAI222S $PINS O=n969 A1=FE_OFN383_FE_OFN63_n1382 A2=n1219
+ B1=FE_OFN515_n1380 B2=n1223 C1=FE_OFN386_FE_OFN62_n1379 C2=FE_DBTN10_i2_w_15
XU1516 OA222 $PINS O=n1226 A1=n24 A2=n1225 B1=n26 B2=n1224 C1=n28 C2=n1223
XU1517 ND2 $PINS O=Px_mont[15] I1=n1227 I2=n1226
XU1518 OAI222S $PINS O=n968 A1=FE_OFN384_FE_OFN63_n1382 A2=n1229
+ B1=FE_OFN516_n1380 B2=n1233 C1=FE_OFN387_FE_OFN62_n1379 C2=n1228
XU1519 OA222 $PINS O=n1236 A1=FE_OFN499_n24 A2=n1235 B1=FE_OFN500_n26 B2=n1234
+ C1=FE_OFN501_n28 C2=n1233
XU1520 ND2 $PINS O=Px_mont[16] I1=n1237 I2=n1236
XU1521 OAI222S $PINS O=n967 A1=FE_OFN383_FE_OFN63_n1382 A2=n1239
+ B1=FE_OFN515_n1380 B2=n1243 C1=FE_OFN386_FE_OFN62_n1379 C2=FE_DBTN9_i2_w_17
XU1522 OA222 $PINS O=n1246 A1=n24 A2=n1245 B1=n26 B2=n1244 C1=n28 C2=n1243
XU1523 ND2 $PINS O=Px_mont[17] I1=n1247 I2=n1246
XU1524 OAI222S $PINS O=n966 A1=FE_OFN384_FE_OFN63_n1382 A2=n1249
+ B1=FE_OFN516_n1380 B2=n1253 C1=FE_OFN387_FE_OFN62_n1379 C2=n1248
XU1525 OA222 $PINS O=n1256 A1=FE_OFN499_n24 A2=n1255 B1=FE_OFN500_n26 B2=n1254
+ C1=FE_OFN501_n28 C2=n1253
XU1526 ND2P $PINS O=Px_mont[18] I1=n1257 I2=n1256
XU1527 OAI222S $PINS O=n965 A1=FE_OFN384_FE_OFN63_n1382 A2=n1259
+ B1=FE_OFN515_n1380 B2=n1263 C1=FE_OFN387_FE_OFN62_n1379 C2=FE_DBTN8_i2_w_19
XU1528 OA222 $PINS O=n1266 A1=n24 A2=n1265 B1=n26 B2=n1264 C1=n28 C2=n1263
XU1529 OAI222S $PINS O=n964 A1=FE_OFN384_FE_OFN63_n1382 A2=n1269
+ B1=FE_OFN516_n1380 B2=n1273 C1=FE_OFN387_FE_OFN62_n1379 C2=n1268
XU1530 OA222 $PINS O=n1276 A1=FE_OFN499_n24 A2=n1275 B1=FE_OFN500_n26 B2=n1274
+ C1=FE_OFN501_n28 C2=n1273
XU1531 OAI222S $PINS O=FE_PHN1431_n963 A1=FE_OFN383_FE_OFN63_n1382 A2=n1279
+ B1=FE_OFN515_n1380 B2=n1283 C1=FE_OFN386_FE_OFN62_n1379 C2=FE_DBTN7_i2_w_21
XU1532 OA222 $PINS O=n1287 A1=n31 A2=n1282 B1=FE_OFN316_n21 B2=n1281 C1=n1384
+ C2=n1280
XU1533 OA222 $PINS O=n1286 A1=n24 A2=n1285 B1=n26 B2=n1284 C1=n28 C2=n1283
XU1534 OAI222S $PINS O=FE_PHN1430_n962 A1=FE_OFN384_FE_OFN63_n1382 A2=n1289
+ B1=FE_OFN516_n1380 B2=n1293 C1=FE_OFN387_FE_OFN62_n1379 C2=n1288
XU1535 OA222 $PINS O=n1296 A1=FE_OFN499_n24 A2=n1295 B1=FE_OFN500_n26 B2=n1294
+ C1=FE_OFN501_n28 C2=n1293
XU1536 OAI222S $PINS O=n961 A1=FE_OFN384_FE_OFN63_n1382 A2=n1299
+ B1=FE_OFN516_n1380 B2=n1303 C1=FE_OFN387_FE_OFN62_n1379 C2=FE_DBTN6_i2_w_23
XU1537 OA222 $PINS O=n1307 A1=FE_OFN118_n31 A2=n1302 B1=FE_OFN347_FE_OFN316_n21
+ B2=n1301 C1=FE_OFN653_n1384 C2=n1300
XU1538 OA222 $PINS O=n1306 A1=FE_OFN499_n24 A2=n1305 B1=FE_OFN500_n26 B2=n1304
+ C1=FE_OFN501_n28 C2=n1303
XU1539 OAI222S $PINS O=n960 A1=FE_OFN384_FE_OFN63_n1382 A2=n1309
+ B1=FE_OFN516_n1380 B2=n1313 C1=FE_OFN387_FE_OFN62_n1379 C2=n1308
XU1540 OA222 $PINS O=n1316 A1=FE_OFN499_n24 A2=n1315 B1=FE_OFN500_n26 B2=n1314
+ C1=FE_OFN501_n28 C2=n1313
XU1541 OAI222S $PINS O=n959 A1=FE_OFN383_FE_OFN63_n1382 A2=n1319
+ B1=FE_OFN516_n1380 B2=n1323 C1=FE_OFN386_FE_OFN62_n1379 C2=FE_DBTN5_i2_w_25
XU1542 OA222 $PINS O=n1327 A1=FE_OFN118_n31 A2=n1322 B1=FE_OFN347_FE_OFN316_n21
+ B2=n1321 C1=FE_OFN653_n1384 C2=n1320
XU1543 OA222 $PINS O=n1326 A1=FE_OFN499_n24 A2=n1325 B1=FE_OFN500_n26 B2=n1324
+ C1=FE_OFN501_n28 C2=n1323
XU1544 OAI222S $PINS O=n958 A1=FE_OFN384_FE_OFN63_n1382 A2=n1329
+ B1=FE_OFN516_n1380 B2=n1333 C1=FE_OFN387_FE_OFN62_n1379 C2=n1328
XU1545 OA222 $PINS O=n1336 A1=FE_OFN499_n24 A2=n1335 B1=FE_OFN500_n26 B2=n1334
+ C1=FE_OFN501_n28 C2=n1333
XU1546 OAI222S $PINS O=n957 A1=FE_OFN383_FE_OFN63_n1382 A2=n1339
+ B1=FE_OFN516_n1380 B2=n1343 C1=FE_OFN386_FE_OFN62_n1379 C2=FE_DBTN4_i2_w_27
XU1547 OA222 $PINS O=n1347 A1=FE_OFN118_n31 A2=n1342 B1=FE_OFN347_FE_OFN316_n21
+ B2=n1341 C1=FE_OFN653_n1384 C2=n1340
XU1548 OA222 $PINS O=n1346 A1=FE_OFN499_n24 A2=n1345 B1=FE_OFN500_n26 B2=n1344
+ C1=FE_OFN501_n28 C2=n1343
XU1549 ND2P $PINS O=Px_mont[27] I1=n1347 I2=n1346
XU1550 OAI222S $PINS O=n956 A1=FE_OFN384_FE_OFN63_n1382 A2=n1349
+ B1=FE_OFN516_n1380 B2=n1353 C1=FE_OFN387_FE_OFN62_n1379 C2=n1348
XU1551 OA222 $PINS O=n1357 A1=FE_OFN348_FE_OFN118_n31 A2=n1352
+ B1=FE_OFN347_FE_OFN316_n21 B2=n1351 C1=FE_OFN653_n1384 C2=n1350
XU1552 OA222 $PINS O=n1356 A1=FE_OFN499_n24 A2=n1355 B1=FE_OFN500_n26 B2=n1354
+ C1=FE_OFN501_n28 C2=n1353
XU1553 ND2P $PINS O=Px_mont[28] I1=n1357 I2=n1356
XU1554 OAI222S $PINS O=n955 A1=FE_OFN383_FE_OFN63_n1382 A2=n1359
+ B1=FE_OFN516_n1380 B2=n1363 C1=FE_OFN386_FE_OFN62_n1379 C2=FE_DBTN3_i2_w_29
XU1555 OA222 $PINS O=n1367 A1=FE_OFN118_n31 A2=n1362 B1=FE_OFN347_FE_OFN316_n21
+ B2=n1361 C1=FE_OFN653_n1384 C2=n1360
XU1556 OA222 $PINS O=n1366 A1=FE_OFN499_n24 A2=n1365 B1=FE_OFN500_n26 B2=n1364
+ C1=FE_OFN501_n28 C2=n1363
XU1557 ND2P $PINS O=Px_mont[29] I1=n1367 I2=n1366
XU1558 OAI222S $PINS O=n954 A1=FE_OFN384_FE_OFN63_n1382 A2=n1369
+ B1=FE_OFN516_n1380 B2=n1373 C1=FE_OFN387_FE_OFN62_n1379 C2=n1368
XU1559 OA222 $PINS O=n1377 A1=FE_OFN348_FE_OFN118_n31 A2=n1372
+ B1=FE_OFN347_FE_OFN316_n21 B2=n1371 C1=FE_OFN653_n1384 C2=n1370
XU1560 OA222 $PINS O=n1376 A1=FE_OFN499_n24 A2=n1375 B1=FE_OFN500_n26 B2=n1374
+ C1=FE_OFN501_n28 C2=n1373
XU1561 ND2P $PINS O=Px_mont[30] I1=n1377 I2=n1376
XU1562 OAI222S $PINS O=FE_PHN1425_n953 A1=FE_OFN384_FE_OFN63_n1382 A2=n1381
+ B1=FE_OFN516_n1380 B2=n1387 C1=FE_OFN387_FE_OFN62_n1379 C2=n1378
XU1563 OA222 $PINS O=n1391 A1=FE_OFN348_FE_OFN118_n31 A2=n1386
+ B1=FE_OFN347_FE_OFN316_n21 B2=n1385 C1=FE_OFN653_n1384 C2=n1383
XU1564 OA222 $PINS O=n1390 A1=FE_OFN499_n24 A2=n1389 B1=FE_OFN500_n26 B2=n1388
+ C1=FE_OFN501_n28 C2=n1387
XU1565 ND2P $PINS O=Px_mont[31] I1=n1391 I2=n1390
XU1566 OR3B2 $PINS O=n1394 I1=n1393 B1=n43 B2=n1392
XU1567 XOR2HS $PINS O=n1152 I1=FE_PHN1484_counter_0 I2=n1395
XU1568 ND2 $PINS O=n577 I1=FE_PHN1167_counter_0 I2=n1395
XU1569 OR3B2 $PINS O=n1397 I1=n1396 B1=key_counter[0] B2=key_counter[2]
XU1570 AN2 $PINS O=n1400 I1=n1398 I2=n1401
XU1571 OAI12HS $PINS O=n1403 A1=n1399 B1=n1401 B2=n1405
XU1572 MUX2 $PINS O=n1145 S=FE_PHN1132_key_counter_3 A=n1400 B=n1403
XU1573 ND2 $PINS O=n1402 I1=n1401 I2=n1407
XU1574 MUX2 $PINS O=n1406 S=FE_PHN1132_key_counter_3 A=n1407 B=n1402
XU1575 OAI22S $PINS O=n1144 A1=n1406 A2=n1405 B1=n1407 B2=n1404
.ENDS

.SUBCKT add_DW_cmp_1 A[32] A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24]
+ A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12] A[11]
+ A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[32] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] TC GE_LT GE_GT_EQ GE_LT_GT_LE EQ_NE
+ FE_OFN185_FE_OFN88_raw_prime_8 FE_OFN347_FE_OFN96_raw_prime_3
XU164 ND2S $PINS O=n7 I1=n3 I2=n9
XU165 ND2S $PINS O=n18 I1=A[30] I2=B[30]
XU166 ND2S $PINS O=n16 I1=A[31] I2=B[31]
XU167 ND2P $PINS O=GE_LT_GT_LE I1=n125 I2=n6
XU168 INV1S $PINS O=n6 I=A[32]
XU169 OAI12HS $PINS O=n125 A1=n8 B1=n1 B2=n7
XU191 AOI12HS $PINS O=n8 A1=n10 B1=n2 B2=n9
XU192 OAI12HS $PINS O=n2 A1=n38 B1=n52 B2=n37
XU193 OAI12HS $PINS O=n10 A1=n12 B1=n4 B2=n11
XU194 AOI12HS $PINS O=n38 A1=n40 B1=n39 B2=n46
XU195 NR2 $PINS O=n3 I1=n37 I2=n51
XU196 ND2 $PINS O=n51 I1=n59 I2=n53
XU197 NR2 $PINS O=n59 I1=n61 I2=n63
XU198 AOI12HS $PINS O=n1 A1=n66 B1=n95 B2=n65
XU199 OAI12HS $PINS O=n95 A1=n97 B1=n110 B2=n96
XU200 OAI12HS $PINS O=n66 A1=n68 B1=n82 B2=n67
XU201 NR2 $PINS O=n65 I1=n67 I2=n81
XU202 AOI12HS $PINS O=n110 A1=n112 B1=n117 B2=n111
XU203 OAI12HS $PINS O=n117 A1=n119 B1=n120 B2=n118
XU204 OAI12HS $PINS O=n112 A1=n114 B1=n113 B2=n116
XU205 NR2 $PINS O=n111 I1=n113 I2=n115
XU215 NR2 $PINS O=n9 I1=n11 I2=n5
XU216 ND2 $PINS O=n5 I1=n31 I2=n25
XU217 NR2 $PINS O=n31 I1=n33 I2=n35
XU218 NR2 $PINS O=n35 I1=B[24] I2=A[24]
XU219 NR2 $PINS O=n15 I1=B[31] I2=A[31]
XU220 NR2 $PINS O=n13 I1=n15 I2=n17
XU221 NR2 $PINS O=n17 I1=B[30] I2=A[30]
XU222 ND2 $PINS O=n11 I1=n19 I2=n13
XU223 NR2 $PINS O=n19 I1=n21 I2=n23
XU224 NR2 $PINS O=n23 I1=B[28] I2=A[28]
XU225 AOI12HS $PINS O=n12 A1=n14 B1=n13 B2=n20
XU226 OAI12HS $PINS O=n20 A1=n22 B1=n21 B2=n24
XU227 OAI12HS $PINS O=n14 A1=n16 B1=n15 B2=n18
XU228 ND2 $PINS O=n24 I1=A[28] I2=B[28]
XU229 NR2 $PINS O=n21 I1=B[29] I2=A[29]
XU230 NR2 $PINS O=n27 I1=B[27] I2=A[27]
XU231 NR2 $PINS O=n33 I1=B[25] I2=A[25]
XU232 NR2 $PINS O=n41 I1=B[23] I2=A[23]
XU233 NR2 $PINS O=n71 I1=B[15] I2=A[15]
XU234 NR2 $PINS O=n47 I1=B[21] I2=A[21]
XU235 NR2 $PINS O=n55 I1=B[19] I2=A[19]
XU236 NR2 $PINS O=n25 I1=n27 I2=n29
XU237 NR2 $PINS O=n29 I1=B[26] I2=A[26]
XU238 NR2 $PINS O=n39 I1=n41 I2=n43
XU239 NR2 $PINS O=n43 I1=B[22] I2=A[22]
XU240 NR2 $PINS O=n53 I1=n55 I2=n57
XU241 NR2 $PINS O=n57 I1=B[18] I2=A[18]
XU242 NR2 $PINS O=n69 I1=n71 I2=n73
XU243 NR2 $PINS O=n73 I1=B[14] I2=A[14]
XU244 ND2 $PINS O=n37 I1=n45 I2=n39
XU245 NR2 $PINS O=n45 I1=n47 I2=n49
XU246 NR2 $PINS O=n49 I1=B[20] I2=A[20]
XU247 ND2 $PINS O=n67 I1=n75 I2=n69
XU248 NR2 $PINS O=n75 I1=n77 I2=n79
XU249 NR2 $PINS O=n79 I1=B[12] I2=A[12]
XU250 OAI12HS $PINS O=n46 A1=n48 B1=n47 B2=n50
XU251 ND2 $PINS O=n50 I1=A[20] I2=B[20]
XU252 ND2 $PINS O=n48 I1=A[21] I2=B[21]
XU253 OAI12HS $PINS O=n40 A1=n42 B1=n41 B2=n44
XU254 ND2 $PINS O=n42 I1=A[23] I2=B[23]
XU255 ND2 $PINS O=n44 I1=A[22] I2=B[22]
XU256 AOI12HS $PINS O=n68 A1=n70 B1=n69 B2=n76
XU257 OAI12HS $PINS O=n76 A1=n78 B1=n77 B2=n80
XU258 OAI12HS $PINS O=n70 A1=n72 B1=n71 B2=n74
XU259 ND2 $PINS O=n80 I1=A[12] I2=B[12]
XU260 AOI12HS $PINS O=n4 A1=n26 B1=n25 B2=n32
XU261 OAI12HS $PINS O=n32 A1=n34 B1=n33 B2=n36
XU262 OAI12HS $PINS O=n26 A1=n28 B1=n27 B2=n30
XU263 ND2 $PINS O=n36 I1=A[24] I2=B[24]
XU264 AOI12HS $PINS O=n52 A1=n54 B1=n53 B2=n60
XU265 OAI12HS $PINS O=n60 A1=n62 B1=n61 B2=n64
XU266 OAI12HS $PINS O=n54 A1=n56 B1=n55 B2=n58
XU267 ND2 $PINS O=n64 I1=A[16] I2=B[16]
XU268 ND2 $PINS O=n30 I1=A[26] I2=B[26]
XU269 ND2 $PINS O=n74 I1=A[14] I2=B[14]
XU270 ND2 $PINS O=n22 I1=A[29] I2=B[29]
XU271 ND2 $PINS O=n28 I1=A[27] I2=B[27]
XU272 ND2 $PINS O=n56 I1=A[19] I2=B[19]
XU273 ND2 $PINS O=n72 I1=A[15] I2=B[15]
XU274 NR2 $PINS O=n61 I1=B[17] I2=A[17]
XU275 NR2 $PINS O=n77 I1=B[13] I2=A[13]
XU276 NR2 $PINS O=n85 I1=B[11] I2=A[11]
XU277 NR2 $PINS O=n106 I1=B[5] I2=A[5]
XU278 NR2 $PINS O=n91 I1=B[9] I2=A[9]
XU279 NR2 $PINS O=n100 I1=B[7] I2=A[7]
XU280 NR2 $PINS O=n113 I1=B[3] I2=A[3]
XU281 NR2 $PINS O=n83 I1=n85 I2=n87
XU282 NR2 $PINS O=n87 I1=B[10] I2=A[10]
XU283 NR2 $PINS O=n98 I1=n100 I2=n102
XU284 NR2 $PINS O=n102 I1=B[6] I2=A[6]
XU285 AOI12HS $PINS O=n97 A1=n99 B1=n98 B2=n105
XU286 OAI12HS $PINS O=n105 A1=n107 B1=n106 B2=n109
XU287 OAI12HS $PINS O=n99 A1=n101 B1=n100 B2=n103
XU288 ND2 $PINS O=n109 I1=A[4] I2=B[4]
XU289 AOI12HS $PINS O=n82 A1=n84 B1=n83 B2=n90
XU290 OAI12HS $PINS O=n90 A1=n92 B1=n91 B2=n94
XU291 OAI12HS $PINS O=n84 A1=n86 B1=n85 B2=n88
XU292 ND2 $PINS O=n94 I1=A[8] I2=B[8]
XU293 NR2 $PINS O=n118 I1=B[1] I2=A[1]
XU294 AN2 $PINS O=n120 I1=n124 I2=n123
XU295 ND2 $PINS O=n96 I1=n104 I2=n98
XU296 NR2 $PINS O=n104 I1=n106 I2=n108
XU297 NR2 $PINS O=n108 I1=B[4] I2=A[4]
XU298 ND2 $PINS O=n88 I1=A[10] I2=B[10]
XU299 ND2 $PINS O=n103 I1=A[6] I2=B[6]
XU300 ND2 $PINS O=n116 I1=A[2] I2=B[2]
XU301 ND2 $PINS O=n58 I1=A[18] I2=B[18]
XU302 NR2 $PINS O=n115 I1=B[2] I2=A[2]
XU303 NR2 $PINS O=n63 I1=B[16] I2=A[16]
XU304 ND2 $PINS O=n34 I1=A[25] I2=B[25]
XU305 ND2 $PINS O=n62 I1=A[17] I2=B[17]
XU306 ND2 $PINS O=n78 I1=A[13] I2=B[13]
XU307 ND2 $PINS O=n86 I1=A[11] I2=B[11]
XU308 ND2 $PINS O=n92 I1=A[9] I2=B[9]
XU309 ND2 $PINS O=n101 I1=A[7] I2=B[7]
XU310 ND2 $PINS O=n107 I1=A[5] I2=B[5]
XU311 ND2 $PINS O=n114 I1=A[3] I2=FE_OFN347_FE_OFN96_raw_prime_3
XU312 ND2 $PINS O=n119 I1=A[1] I2=B[1]
XU313 ND2 $PINS O=n81 I1=n89 I2=n83
XU314 NR2 $PINS O=n89 I1=n91 I2=n93
XU315 NR2 $PINS O=n93 I1=FE_OFN185_FE_OFN88_raw_prime_8 I2=A[8]
XU317 ND2 $PINS O=n124 I1=A[0] I2=B[0]
XU318 NR2 $PINS O=n123 I1=B[0] I2=A[0]
.ENDS

.SUBCKT add_DW01_add_2 A[32] A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24]
+ A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12] A[11]
+ A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[32] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] CI SUM[32] SUM[31] SUM[30] SUM[29] SUM[28] SUM[27] SUM[26]
+ SUM[25] SUM[24] SUM[23] SUM[22] SUM[21] SUM[20] SUM[19] SUM[18] SUM[17]
+ SUM[16] SUM[15] SUM[14] SUM[13] SUM[12] SUM[11] SUM[10] SUM[9] SUM[8] SUM[7]
+ SUM[6] SUM[5] SUM[4] SUM[3] SUM[2] SUM[1] SUM[0] CO
*.CONNECT SUM[32] n33
XU266 INV1S $PINS O=n336 I=n36
XU267 ND2 $PINS O=n337 I1=n1 I2=n336
XU268 ND2 $PINS O=n338 I1=n335 I2=n36
XU269 ND2 $PINS O=SUM[31] I1=n337 I2=n338
XU270 INV1S $PINS O=n335 I=n1
XU271 AOI12HS $PINS O=n36 A1=n38 B1=n41 B2=n344
XU272 OR2S $PINS O=n339 I1=A[23] I2=B[23]
XU273 OR2S $PINS O=n340 I1=A[22] I2=B[22]
XU274 OR2S $PINS O=n341 I1=A[28] I2=B[28]
XU275 OR2S $PINS O=n342 I1=A[24] I2=B[24]
XU276 OR2S $PINS O=n343 I1=A[26] I2=B[26]
XU277 OR2 $PINS O=n344 I1=A[30] I2=B[30]
XU278 AN2 $PINS O=SUM[0] I1=n358 I2=n197
XU279 ND2S $PINS O=n75 I1=n82 I2=n340
XU280 ND2S $PINS O=n93 I1=n103 I2=n95
XU281 XNR2HS $PINS O=SUM[15] I1=n17 I2=n346
XU282 AO12 $PINS O=n346 A1=n124 B1=n127 B2=n215
XU283 XNR2HS $PINS O=SUM[17] I1=n15 I2=n347
XU284 AO12S $PINS O=n347 A1=n109 B1=n112 B2=n213
XU285 XNR2HS $PINS O=SUM[11] I1=n21 I2=n348
XU286 AO12 $PINS O=n348 A1=n149 B1=n152 B2=n219
XU287 XNR2HS $PINS O=SUM[13] I1=n19 I2=n349
XU288 AO12S $PINS O=n349 A1=n136 B1=n140 B2=n217
XU289 XNR2HS $PINS O=SUM[22] I1=n10 I2=n350
XU290 AO12S $PINS O=n350 A1=n83 B1=n89 B2=n82
XU291 XNR2HS $PINS O=SUM[23] I1=n9 I2=n351
XU292 AO12S $PINS O=n351 A1=n74 B1=n112 B2=n73
XU293 XOR2HS $PINS O=SUM[19] I1=n13 I2=n352
XU294 OA12 $PINS O=n352 A1=n101 B1=n102 B2=n100
XU295 XOR2HS $PINS O=SUM[21] I1=n11 I2=n353
XU296 OA12S $PINS O=n353 A1=n88 B1=n90 B2=n87
XU297 ND2S $PINS O=n141 I1=n155 I2=n143
XU298 ND2S $PINS O=n31 I1=n228 I2=n195
XU299 ND2S $PINS O=n30 I1=n227 I2=n191
XU300 ND2S $PINS O=n28 I1=n225 I2=n182
XU301 XNR2HS $PINS O=SUM[5] I1=n27 I2=n354
XU302 AO12S $PINS O=n354 A1=n180 B1=n183 B2=n225
XU303 XOR2HS $PINS O=SUM[3] I1=n29 I2=n355
XU304 OA12S $PINS O=n355 A1=n191 B1=n192 B2=n190
XU305 XOR2HS $PINS O=SUM[9] I1=n23 I2=n356
XU306 OA12S $PINS O=n356 A1=n161 B1=n162 B2=n160
XU307 XOR2HS $PINS O=SUM[7] I1=n25 I2=n357
XU308 OA12S $PINS O=n357 A1=n172 B1=n173 B2=n171
XU309 ND2S $PINS O=n88 I1=B[20] I2=A[20]
XU310 ND2S $PINS O=n101 I1=B[18] I2=A[18]
XU311 ND2S $PINS O=n111 I1=B[16] I2=A[16]
XU312 ND2S $PINS O=n138 I1=B[12] I2=A[12]
XU313 ND2S $PINS O=n126 I1=B[14] I2=A[14]
XU314 ND2S $PINS O=n151 I1=B[10] I2=A[10]
XU315 ND2S $PINS O=n98 I1=B[19] I2=A[19]
XU316 ND2S $PINS O=n106 I1=B[17] I2=A[17]
XU317 ND2S $PINS O=n85 I1=B[21] I2=A[21]
XU318 ND2S $PINS O=n146 I1=B[11] I2=A[11]
XU319 ND2S $PINS O=n133 I1=B[13] I2=A[13]
XU320 ND2S $PINS O=n59 I1=B[25] I2=A[25]
XU321 ND2S $PINS O=n121 I1=B[15] I2=A[15]
XU322 ND2S $PINS O=n64 I1=B[24] I2=A[24]
XU323 ND2S $PINS O=n56 I1=B[26] I2=A[26]
XU324 ND2S $PINS O=n80 I1=B[22] I2=A[22]
XU325 ND2S $PINS O=n71 I1=B[23] I2=A[23]
XU326 ND2S $PINS O=n51 I1=B[27] I2=A[27]
XU327 ND2S $PINS O=n43 I1=B[29] I2=A[29]
XU328 ND2S $PINS O=n48 I1=B[28] I2=A[28]
XU329 ND2S $PINS O=n40 I1=B[30] I2=A[30]
XU330 ND2S $PINS O=n35 I1=B[31] I2=A[31]
XU331 ND2S $PINS O=n197 I1=B[0] I2=A[0]
XU332 ND2S $PINS O=n172 I1=B[6] I2=A[6]
XU333 ND2S $PINS O=n161 I1=B[8] I2=A[8]
XU334 OR2S $PINS O=n358 I1=A[0] I2=B[0]
XU335 ND2S $PINS O=n158 I1=B[9] I2=A[9]
XU336 ND2S $PINS O=n169 I1=B[7] I2=A[7]
XU337 NR2 $PINS O=n73 I1=n75 I2=n93
XU338 INV1S $PINS O=n89 I=n90
XU339 INV1S $PINS O=n139 I=n140
XU340 OAI12HS $PINS O=n127 A1=n129 B1=n139 B2=n128
XU341 INV1S $PINS O=n129 I=n131
XU342 INV1S $PINS O=n128 I=n130
XU343 AOI12HS $PINS O=n102 A1=n104 B1=n112 B2=n103
XU344 INV1S $PINS O=n112 I=n113
XU345 OAI12HS $PINS O=n140 A1=n142 B1=n162 B2=n141
XU346 AOI12HS $PINS O=n90 A1=n92 B1=n112 B2=n91
XU347 INV1S $PINS O=n92 I=n94
XU348 INV1S $PINS O=n91 I=n93
XU349 ND2 $PINS O=n1 I1=n198 I2=n35
XU350 INV1S $PINS O=n198 I=n34
XU351 OAI12HS $PINS O=n57 A1=n59 B1=n60 B2=n58
XU352 OAI12HS $PINS O=n49 A1=n51 B1=n52 B2=n50
XU353 OAI12HS $PINS O=n41 A1=n43 B1=n44 B2=n42
XU354 OAI12HS $PINS O=n65 A1=n67 B1=n113 B2=n66
XU355 AOI12HS $PINS O=n67 A1=n69 B1=n74 B2=n339
XU356 ND2 $PINS O=n66 I1=n73 I2=n339
XU357 INV1S $PINS O=n69 I=n71
XU358 INV1S $PINS O=n38 I=n40
XU359 AOI12HS $PINS O=n60 A1=n62 B1=n65 B2=n342
XU360 INV1S $PINS O=n62 I=n64
XU361 AOI12HS $PINS O=n52 A1=n54 B1=n57 B2=n343
XU362 INV1S $PINS O=n54 I=n56
XU363 AOI12HS $PINS O=n44 A1=n46 B1=n49 B2=n341
XU364 INV1S $PINS O=n46 I=n48
XU365 AOI12HS $PINS O=n142 A1=n144 B1=n143 B2=n156
XU366 OAI12HS $PINS O=n144 A1=n146 B1=n145 B2=n151
XU367 AOI12H $PINS O=n113 A1=n115 B1=n163 B2=n114
XU368 NR2 $PINS O=n114 I1=n116 I2=n141
XU369 OAI12HS $PINS O=n115 A1=n117 B1=n142 B2=n116
XU370 ND2 $PINS O=n116 I1=n130 I2=n118
XU371 XOR2HS $PINS O=SUM[12] I1=n20 I2=n139
XU372 ND2 $PINS O=n20 I1=n217 I2=n138
XU373 INV1S $PINS O=n217 I=n137
XU374 XOR2HS $PINS O=SUM[18] I1=n14 I2=n102
XU375 ND2 $PINS O=n14 I1=n211 I2=n101
XU376 INV1S $PINS O=n211 I=n100
XU377 XNR2HS $PINS O=SUM[14] I1=n18 I2=n127
XU378 ND2 $PINS O=n18 I1=n215 I2=n126
XU379 INV1S $PINS O=n215 I=n125
XU380 XNR2HS $PINS O=SUM[16] I1=n16 I2=n112
XU381 ND2 $PINS O=n16 I1=n213 I2=n111
XU382 INV1S $PINS O=n213 I=n110
XU383 XNR2HS $PINS O=SUM[20] I1=n12 I2=n89
XU384 ND2 $PINS O=n12 I1=n209 I2=n88
XU385 INV1S $PINS O=n209 I=n87
XU386 XNR2HS $PINS O=SUM[10] I1=n22 I2=n152
XU387 ND2 $PINS O=n22 I1=n219 I2=n151
XU388 INV1S $PINS O=n219 I=n150
XU389 XOR2HS $PINS O=SUM[29] I1=n3 I2=n44
XU390 ND2 $PINS O=n3 I1=n200 I2=n43
XU391 INV1S $PINS O=n200 I=n42
XU392 XOR2HS $PINS O=SUM[27] I1=n5 I2=n52
XU393 ND2 $PINS O=n5 I1=n202 I2=n51
XU394 INV1S $PINS O=n202 I=n50
XU395 XOR2HS $PINS O=SUM[25] I1=n7 I2=n60
XU396 ND2 $PINS O=n7 I1=n204 I2=n59
XU397 INV1S $PINS O=n204 I=n58
XU398 ND2 $PINS O=n15 I1=n212 I2=n106
XU399 INV1S $PINS O=n212 I=n105
XU400 ND2 $PINS O=n17 I1=n214 I2=n121
XU401 INV1S $PINS O=n214 I=n120
XU402 ND2 $PINS O=n19 I1=n216 I2=n133
XU403 INV1S $PINS O=n216 I=n132
XU404 ND2 $PINS O=n21 I1=n218 I2=n146
XU405 INV1S $PINS O=n218 I=n145
XU406 ND2 $PINS O=n10 I1=n340 I2=n80
XU407 XNR2HS $PINS O=SUM[30] I1=n2 I2=n41
XU408 ND2 $PINS O=n2 I1=n344 I2=n40
XU409 XNR2HS $PINS O=SUM[28] I1=n4 I2=n49
XU410 ND2 $PINS O=n4 I1=n341 I2=n48
XU411 ND2 $PINS O=n11 I1=n208 I2=n85
XU412 INV1S $PINS O=n208 I=n84
XU413 ND2 $PINS O=n13 I1=n210 I2=n98
XU414 INV1S $PINS O=n210 I=n97
XU415 XNR2HS $PINS O=SUM[26] I1=n6 I2=n57
XU416 ND2 $PINS O=n6 I1=n343 I2=n56
XU417 OAI12HS $PINS O=n131 A1=n133 B1=n132 B2=n138
XU418 OAI12HS $PINS O=n104 A1=n106 B1=n105 B2=n111
XU419 OAI12HS $PINS O=n83 A1=n85 B1=n84 B2=n88
XU420 OAI12HS $PINS O=n152 A1=n154 B1=n162 B2=n153
XU421 INV1S $PINS O=n154 I=n156
XU422 INV1S $PINS O=n153 I=n155
XU423 NR2 $PINS O=n103 I1=n110 I2=n105
XU424 NR2 $PINS O=n82 I1=n87 I2=n84
XU425 NR2 $PINS O=n118 I1=n125 I2=n120
XU426 NR2 $PINS O=n143 I1=n150 I2=n145
XU427 NR2 $PINS O=n95 I1=n100 I2=n97
XU428 AOI12HS $PINS O=n173 A1=n175 B1=n183 B2=n174
XU429 NR2 $PINS O=n130 I1=n137 I2=n132
XU430 OAI12HS $PINS O=n74 A1=n76 B1=n94 B2=n75
XU431 AOI12HS $PINS O=n76 A1=n78 B1=n83 B2=n340
XU432 INV1S $PINS O=n78 I=n80
XU433 AOI12HS $PINS O=n94 A1=n96 B1=n95 B2=n104
XU434 OAI12HS $PINS O=n96 A1=n98 B1=n97 B2=n101
XU435 INV1S $PINS O=n162 I=n163
XU436 ND2 $PINS O=n9 I1=n339 I2=n71
XU437 AOI12HS $PINS O=n117 A1=n119 B1=n118 B2=n131
XU438 OAI12HS $PINS O=n119 A1=n121 B1=n120 B2=n126
XU439 OAI12HS $PINS O=n33 A1=n35 B1=n36 B2=n34
XU440 INV1S $PINS O=n183 I=n184
XU441 INV1S $PINS O=n192 I=n193
XU442 INV1S $PINS O=n109 I=n111
XU443 INV1S $PINS O=n136 I=n138
XU444 INV1S $PINS O=n149 I=n151
XU445 XNR2HS $PINS O=SUM[24] I1=n8 I2=n65
XU446 ND2 $PINS O=n8 I1=n342 I2=n64
XU447 INV1S $PINS O=n124 I=n126
XU448 OAI12HS $PINS O=n156 A1=n158 B1=n157 B2=n161
XU449 OAI12HS $PINS O=n193 A1=n195 B1=n194 B2=n197
XU450 NR2 $PINS O=n174 I1=n181 I2=n176
XU451 NR2 $PINS O=n166 I1=n171 I2=n168
XU452 OAI12HS $PINS O=n163 A1=n165 B1=n184 B2=n164
XU453 AOI12HS $PINS O=n165 A1=n167 B1=n166 B2=n175
XU454 ND2 $PINS O=n164 I1=n174 I2=n166
XU455 OAI12HS $PINS O=n167 A1=n169 B1=n168 B2=n172
XU456 AOI12HS $PINS O=n184 A1=n186 B1=n185 B2=n193
XU457 OAI12HS $PINS O=n186 A1=n188 B1=n187 B2=n191
XU458 NR2 $PINS O=n185 I1=n190 I2=n187
XU459 NR2 $PINS O=n87 I1=A[20] I2=B[20]
XU460 NR2 $PINS O=n100 I1=A[18] I2=B[18]
XU461 NR2 $PINS O=n110 I1=A[16] I2=B[16]
XU462 NR2 $PINS O=n125 I1=A[14] I2=B[14]
XU463 NR2 $PINS O=n137 I1=A[12] I2=B[12]
XU464 NR2 $PINS O=n150 I1=A[10] I2=B[10]
XU465 NR2 $PINS O=n105 I1=A[17] I2=B[17]
XU466 NR2 $PINS O=n132 I1=A[13] I2=B[13]
XU467 NR2 $PINS O=n120 I1=A[15] I2=B[15]
XU468 NR2 $PINS O=n84 I1=A[21] I2=B[21]
XU469 NR2 $PINS O=n97 I1=A[19] I2=B[19]
XU470 NR2 $PINS O=n145 I1=A[11] I2=B[11]
XU471 NR2 $PINS O=n58 I1=A[25] I2=B[25]
XU472 XOR2HS $PINS O=SUM[1] I1=n197 I2=n31
XU473 INV1S $PINS O=n228 I=n194
XU474 XOR2HS $PINS O=SUM[2] I1=n30 I2=n192
XU475 INV1S $PINS O=n227 I=n190
XU476 XOR2HS $PINS O=SUM[6] I1=n26 I2=n173
XU477 ND2 $PINS O=n26 I1=n223 I2=n172
XU478 INV1S $PINS O=n223 I=n171
XU479 XOR2HS $PINS O=SUM[8] I1=n24 I2=n162
XU480 ND2 $PINS O=n24 I1=n221 I2=n161
XU481 INV1S $PINS O=n221 I=n160
XU482 XNR2HS $PINS O=SUM[4] I1=n28 I2=n183
XU483 INV1S $PINS O=n225 I=n181
XU484 ND2 $PINS O=n27 I1=n224 I2=n177
XU485 INV1S $PINS O=n224 I=n176
XU486 ND2 $PINS O=n23 I1=n220 I2=n158
XU487 INV1S $PINS O=n220 I=n157
XU488 ND2 $PINS O=n25 I1=n222 I2=n169
XU489 INV1S $PINS O=n222 I=n168
XU490 ND2 $PINS O=n29 I1=n226 I2=n188
XU491 INV1S $PINS O=n226 I=n187
XU492 OAI12HS $PINS O=n175 A1=n177 B1=n176 B2=n182
XU493 NR2 $PINS O=n155 I1=n160 I2=n157
XU494 INV1S $PINS O=n180 I=n182
XU495 NR2 $PINS O=n42 I1=A[29] I2=B[29]
XU496 NR2 $PINS O=n50 I1=A[27] I2=B[27]
XU497 NR2 $PINS O=n34 I1=A[31] I2=B[31]
XU498 NR2 $PINS O=n171 I1=A[6] I2=B[6]
XU499 NR2 $PINS O=n190 I1=A[2] I2=B[2]
XU500 NR2 $PINS O=n181 I1=A[4] I2=B[4]
XU501 NR2 $PINS O=n187 I1=A[3] I2=B[3]
XU502 NR2 $PINS O=n157 I1=A[9] I2=B[9]
XU503 NR2 $PINS O=n168 I1=A[7] I2=B[7]
XU504 NR2 $PINS O=n176 I1=A[5] I2=B[5]
XU505 NR2 $PINS O=n194 I1=A[1] I2=B[1]
XU506 NR2 $PINS O=n160 I1=A[8] I2=B[8]
XU507 ND2S $PINS O=n191 I1=B[2] I2=A[2]
XU508 ND2S $PINS O=n182 I1=B[4] I2=A[4]
XU509 ND2S $PINS O=n195 I1=B[1] I2=A[1]
XU510 ND2S $PINS O=n177 I1=B[5] I2=A[5]
XU511 ND2S $PINS O=n188 I1=B[3] I2=A[3]
.ENDS

.SUBCKT add_DW01_sub_2 A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24] A[23]
+ A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12] A[11] A[10]
+ A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30] B[29] B[28]
+ B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15]
+ B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1]
+ B[0] CI DIFF[31] DIFF[30] DIFF[29] DIFF[28] DIFF[27] DIFF[26] DIFF[25]
+ DIFF[24] DIFF[23] DIFF[22] DIFF[21] DIFF[20] DIFF[19] DIFF[18] DIFF[17]
+ DIFF[16] DIFF[15] DIFF[14] DIFF[13] DIFF[12] DIFF[11] DIFF[10] DIFF[9]
+ DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3] DIFF[2] DIFF[1] DIFF[0] CO
XU300 OR2 $PINS O=n367 I1=n258 I2=A[6]
XU301 OR2 $PINS O=n368 I1=n244 I2=A[20]
XU302 OR2 $PINS O=n369 I1=n246 I2=A[18]
XU303 OR2 $PINS O=n370 I1=n242 I2=A[22]
XU304 OR2 $PINS O=n371 I1=n251 I2=A[13]
XU305 OR2 $PINS O=n372 I1=n257 I2=A[7]
XU306 OR2 $PINS O=n373 I1=n255 I2=A[9]
XU307 OR2 $PINS O=n374 I1=n245 I2=A[19]
XU308 OR2 $PINS O=n375 I1=n249 I2=A[15]
XU309 OR2 $PINS O=n376 I1=n262 I2=A[2]
XU310 OR2 $PINS O=n377 I1=n239 I2=A[25]
XU311 OR2 $PINS O=n378 I1=n237 I2=A[27]
XU312 OR2 $PINS O=n379 I1=n235 I2=A[29]
XU313 OR2 $PINS O=n380 I1=n241 I2=A[23]
XU314 ND2S $PINS O=n154 I1=n373 I2=n163
XU315 ND2S $PINS O=n116 I1=n375 I2=n125
XU316 ND2S $PINS O=n81 I1=n374 I2=n368
XU317 ND2S $PINS O=n169 I1=n372 I2=n367
XU318 ND2S $PINS O=n131 I1=n138 I2=n371
XU319 ND2S $PINS O=n21 I1=n143 I2=n146
XU320 ND2S $PINS O=n18 I1=n125 I2=n128
XU321 ND2S $PINS O=n17 I1=n375 I2=n121
XU322 ND2S $PINS O=n13 I1=n374 I2=n91
XU323 ND2S $PINS O=n12 I1=n368 I2=n86
XU324 ND2S $PINS O=n146 I1=A[11] I2=n253
XU325 ND2S $PINS O=n141 I1=A[12] I2=n252
XU326 ND2S $PINS O=n108 I1=A[17] I2=n247
XU327 ND2S $PINS O=n128 I1=A[14] I2=n250
XU328 ND2S $PINS O=n121 I1=A[15] I2=n249
XU329 ND2S $PINS O=n91 I1=A[19] I2=n245
XU330 ND2S $PINS O=n86 I1=A[20] I2=n244
XU331 ND2S $PINS O=n179 I1=A[6] I2=n258
XU332 ND2S $PINS O=n101 I1=A[18] I2=n246
XU333 ND2S $PINS O=n72 I1=A[22] I2=n242
XU334 ND2S $PINS O=n36 I1=A[30] I2=n234
XU335 ND2S $PINS O=n33 I1=A[31] I2=n233
XU336 OR2S $PINS O=n381 I1=n233 I2=A[31]
XU337 INV1S $PINS O=n92 I=n93
XU338 INV1S $PINS O=n114 I=n115
XU339 AOI12HS $PINS O=n93 A1=n95 B1=n130 B2=n94
XU340 NR2 $PINS O=n94 I1=n96 I2=n116
XU341 OAI12HS $PINS O=n95 A1=n97 B1=n117 B2=n96
XU342 ND2 $PINS O=n96 I1=n105 I2=n369
XU343 OAI12HS $PINS O=n115 A1=n117 B1=n129 B2=n116
XU344 OAI12HS $PINS O=n160 A1=n166 B1=n167 B2=n165
XU345 OAI12HS $PINS O=n153 A1=n155 B1=n167 B2=n154
XU346 OAI12HS $PINS O=n122 A1=n128 B1=n129 B2=n127
XU347 OAI12HS $PINS O=n102 A1=n104 B1=n114 B2=n103
XU348 INV1S $PINS O=n104 I=n106
XU349 INV1S $PINS O=n103 I=n105
XU350 AOI12HS $PINS O=n73 A1=n75 B1=n92 B2=n74
XU351 AOI12HS $PINS O=n137 A1=n139 B1=n147 B2=n138
XU352 AOI12HS $PINS O=n175 A1=n177 B1=n180 B2=n367
XU353 AOI12HS $PINS O=n87 A1=n89 B1=n92 B2=n374
XU354 AOI12HS $PINS O=n78 A1=n80 B1=n92 B2=n79
XU355 INV1S $PINS O=n79 I=n81
XU356 INV1S $PINS O=n80 I=n82
XU357 INV1S $PINS O=n147 I=n148
XU358 INV1S $PINS O=n167 I=n168
XU359 INV1S $PINS O=n129 I=n130
XU360 INV1S $PINS O=n180 I=n181
XU361 INV1S $PINS O=n189 I=n190
XU362 OAI12HS $PINS O=n50 A1=n52 B1=n53 B2=n51
XU363 OAI12HS $PINS O=n42 A1=n44 B1=n45 B2=n43
XU364 OAI12HS $PINS O=n58 A1=n60 B1=n61 B2=n59
XU365 OAI12HS $PINS O=n66 A1=n68 B1=n93 B2=n67
XU366 AOI12HS $PINS O=n68 A1=n70 B1=n75 B2=n370
XU367 ND2 $PINS O=n67 I1=n74 I2=n370
XU368 INV1S $PINS O=n70 I=n72
XU369 OAI12HS $PINS O=n190 A1=n192 B1=n193 B2=n191
XU370 OAI12HS $PINS O=n106 A1=n108 B1=n107 B2=n113
XU371 OAI12HS $PINS O=n168 A1=n170 B1=n181 B2=n169
XU372 AOI12HS $PINS O=n170 A1=n172 B1=n372 B2=n177
XU373 INV1S $PINS O=n172 I=n174
XU374 OAI12HS $PINS O=n139 A1=n141 B1=n140 B2=n146
XU375 AOI12HS $PINS O=n61 A1=n63 B1=n66 B2=n380
XU376 INV1S $PINS O=n63 I=n65
XU377 AOI12HS $PINS O=n53 A1=n55 B1=n58 B2=n377
XU378 INV1S $PINS O=n55 I=n57
XU379 AOI12HS $PINS O=n45 A1=n47 B1=n50 B2=n378
XU380 INV1S $PINS O=n47 I=n49
XU381 AOI12HS $PINS O=n37 A1=n39 B1=n42 B2=n379
XU382 INV1S $PINS O=n39 I=n41
XU383 OAI12HS $PINS O=n75 A1=n77 B1=n82 B2=n76
XU384 OAI12HS $PINS O=n130 A1=n132 B1=n148 B2=n131
XU385 AOI12HS $PINS O=n132 A1=n134 B1=n139 B2=n371
XU386 INV1S $PINS O=n134 I=n136
XU387 AOI12HS $PINS O=n193 A1=n195 B1=n198 B2=n376
XU388 INV1S $PINS O=n195 I=n197
XU389 AOI12HS $PINS O=n181 A1=n183 B1=n182 B2=n190
XU390 NR2 $PINS O=n182 I1=n187 I2=n184
XU391 OAI12HS $PINS O=n183 A1=n185 B1=n184 B2=n188
XU392 AOI12HS $PINS O=n155 A1=n157 B1=n373 B2=n164
XU393 INV1S $PINS O=n157 I=n159
XU394 AOI12HS $PINS O=n117 A1=n119 B1=n375 B2=n126
XU395 INV1S $PINS O=n119 I=n121
XU396 AOI12HS $PINS O=n82 A1=n84 B1=n89 B2=n368
XU397 INV1S $PINS O=n84 I=n86
XU398 NR2 $PINS O=n138 I1=n140 I2=n145
XU399 NR2 $PINS O=n74 I1=n76 I2=n81
XU400 NR2 $PINS O=n105 I1=n112 I2=n107
XU401 OAI12HS $PINS O=n34 A1=n36 B1=n37 B2=n35
XU402 AOI12HS $PINS O=n148 A1=n150 B1=n149 B2=n168
XU403 NR2 $PINS O=n149 I1=n151 I2=n154
XU404 OAI12HS $PINS O=n150 A1=n152 B1=n155 B2=n151
XU405 AOI12HS $PINS O=n97 A1=n99 B1=n106 B2=n369
XU406 INV1S $PINS O=n99 I=n101
XU407 INV1S $PINS O=n164 I=n166
XU408 INV1S $PINS O=n126 I=n128
XU409 INV1S $PINS O=n177 I=n179
XU410 INV1S $PINS O=n89 I=n91
XU411 INV1S $PINS O=n163 I=n165
XU412 INV1S $PINS O=n125 I=n127
XU413 AOI12HS $PINS O=n109 A1=n111 B1=n115 B2=n110
XU414 INV1S $PINS O=n111 I=n113
XU415 INV1S $PINS O=n110 I=n112
XU416 AOI12HS $PINS O=n142 A1=n144 B1=n147 B2=n143
XU417 INV1S $PINS O=n144 I=n146
XU418 INV1S $PINS O=n143 I=n145
XU419 INV1S $PINS O=n212 I=n76
XU420 INV1S $PINS O=n221 I=n140
XU421 INV1S $PINS O=n216 I=n107
XU422 INV1S $PINS O=n207 I=n51
XU423 INV1S $PINS O=n205 I=n43
XU424 INV1S $PINS O=n203 I=n35
XU425 OAI12HS $PINS O=n186 A1=n188 B1=n189 B2=n187
XU426 INV1S $PINS O=n229 I=n187
XU427 INV1S $PINS O=n223 I=n151
XU428 INV1S $PINS O=n228 I=n184
XU429 INV1S $PINS O=n230 I=n191
XU430 INV1S $PINS O=n209 I=n59
XU431 INV1S $PINS O=n232 I=n199
XU432 XOR2HS $PINS O=DIFF[1] I1=n201 I2=n31
XU433 ND2 $PINS O=n31 I1=n232 I2=n200
XU434 XNR2HS $PINS O=DIFF[2] I1=n198 I2=n30
XU435 ND2 $PINS O=n30 I1=n376 I2=n197
XU436 XNR2HS $PINS O=DIFF[6] I1=n26 I2=n180
XU437 ND2 $PINS O=n26 I1=n367 I2=n179
XU438 XOR2HS $PINS O=DIFF[8] I1=n24 I2=n167
XU439 ND2 $PINS O=n24 I1=n163 I2=n166
XU440 XOR2HS $PINS O=DIFF[12] I1=n20 I2=n142
XU441 ND2 $PINS O=n20 I1=n221 I2=n141
XU442 XNR2HS $PINS O=DIFF[18] I1=n14 I2=n102
XU443 ND2 $PINS O=n14 I1=n369 I2=n101
XU444 XOR2HS $PINS O=DIFF[4] I1=n28 I2=n189
XU445 ND2 $PINS O=n28 I1=n229 I2=n188
XU446 XNR2HS $PINS O=DIFF[10] I1=n22 I2=n153
XU447 ND2 $PINS O=n22 I1=n223 I2=n152
XU448 XOR2HS $PINS O=DIFF[14] I1=n18 I2=n129
XU449 XOR2HS $PINS O=DIFF[16] I1=n16 I2=n114
XU450 ND2 $PINS O=n16 I1=n110 I2=n113
XU451 XOR2HS $PINS O=DIFF[20] I1=n12 I2=n87
XU452 XNR2HS $PINS O=DIFF[5] I1=n27 I2=n186
XU453 ND2 $PINS O=n27 I1=n228 I2=n185
XU454 XNR2HS $PINS O=DIFF[11] I1=n21 I2=n147
XU455 XOR2HS $PINS O=DIFF[13] I1=n19 I2=n137
XU456 ND2 $PINS O=n19 I1=n371 I2=n136
XU457 XNR2HS $PINS O=DIFF[15] I1=n17 I2=n122
XU458 XOR2HS $PINS O=DIFF[17] I1=n15 I2=n109
XU459 ND2 $PINS O=n15 I1=n216 I2=n108
XU460 XOR2HS $PINS O=DIFF[22] I1=n10 I2=n73
XU461 ND2 $PINS O=n10 I1=n370 I2=n72
XU462 XNR2HS $PINS O=DIFF[23] I1=n9 I2=n66
XU463 ND2 $PINS O=n9 I1=n380 I2=n65
XU464 XNR2HS $PINS O=DIFF[25] I1=n7 I2=n58
XU465 ND2 $PINS O=n7 I1=n377 I2=n57
XU466 XNR2HS $PINS O=DIFF[27] I1=n5 I2=n50
XU467 ND2 $PINS O=n5 I1=n378 I2=n49
XU468 XNR2HS $PINS O=DIFF[29] I1=n3 I2=n42
XU469 ND2 $PINS O=n3 I1=n379 I2=n41
XU470 XNR2HS $PINS O=DIFF[31] I1=n1 I2=n34
XU471 ND2 $PINS O=n1 I1=n381 I2=n33
XU472 XOR2HS $PINS O=DIFF[3] I1=n193 I2=n29
XU473 ND2 $PINS O=n29 I1=n230 I2=n192
XU474 XOR2HS $PINS O=DIFF[7] I1=n25 I2=n175
XU475 ND2 $PINS O=n25 I1=n372 I2=n174
XU476 XNR2HS $PINS O=DIFF[9] I1=n23 I2=n160
XU477 ND2 $PINS O=n23 I1=n373 I2=n159
XU478 XNR2HS $PINS O=DIFF[19] I1=n13 I2=n92
XU479 XOR2HS $PINS O=DIFF[21] I1=n11 I2=n78
XU480 ND2 $PINS O=n11 I1=n212 I2=n77
XU481 XOR2HS $PINS O=DIFF[24] I1=n8 I2=n61
XU482 ND2 $PINS O=n8 I1=n209 I2=n60
XU483 XOR2HS $PINS O=DIFF[26] I1=n6 I2=n53
XU484 ND2 $PINS O=n6 I1=n207 I2=n52
XU485 XOR2HS $PINS O=DIFF[28] I1=n4 I2=n45
XU486 ND2 $PINS O=n4 I1=n205 I2=n44
XU487 XOR2HS $PINS O=DIFF[30] I1=n2 I2=n37
XU488 ND2 $PINS O=n2 I1=n203 I2=n36
XU489 NR2 $PINS O=n76 I1=n243 I2=A[21]
XU490 NR2 $PINS O=n187 I1=n260 I2=A[4]
XU491 NR2 $PINS O=n151 I1=n254 I2=A[10]
XU492 NR2 $PINS O=n112 I1=n248 I2=A[16]
XU493 NR2 $PINS O=n140 I1=n252 I2=A[12]
XU494 NR2 $PINS O=n145 I1=n253 I2=A[11]
XU495 NR2 $PINS O=n107 I1=n247 I2=A[17]
XU496 NR2 $PINS O=n184 I1=n259 I2=A[5]
XU497 NR2 $PINS O=n191 I1=n261 I2=A[3]
XU498 NR2 $PINS O=n199 I1=n263 I2=A[1]
XU499 NR2 $PINS O=n165 I1=n256 I2=A[8]
XU500 NR2 $PINS O=n127 I1=n250 I2=A[14]
XU501 OAI12HS $PINS O=n198 A1=n200 B1=n199 B2=n201
XU502 ND2 $PINS O=n188 I1=A[4] I2=n260
XU503 ND2 $PINS O=n113 I1=A[16] I2=n248
XU504 ND2 $PINS O=n200 I1=A[1] I2=n263
XU505 ND2 $PINS O=n192 I1=A[3] I2=n261
XU506 ND2 $PINS O=n185 I1=A[5] I2=n259
XU507 ND2 $PINS O=n152 I1=A[10] I2=n254
XU508 ND2 $PINS O=n77 I1=A[21] I2=n243
XU509 ND2 $PINS O=n197 I1=A[2] I2=n262
XU510 ND2 $PINS O=n174 I1=A[7] I2=n257
XU511 ND2 $PINS O=n166 I1=A[8] I2=n256
XU512 ND2 $PINS O=n159 I1=A[9] I2=n255
XU513 ND2 $PINS O=n136 I1=A[13] I2=n251
XU514 ND2 $PINS O=n65 I1=A[23] I2=n241
XU515 NR2 $PINS O=n51 I1=n238 I2=A[26]
XU516 NR2 $PINS O=n43 I1=n236 I2=A[28]
XU517 NR2 $PINS O=n35 I1=n234 I2=A[30]
XU518 NR2 $PINS O=n59 I1=n240 I2=A[24]
XU519 ND2 $PINS O=n60 I1=A[24] I2=n240
XU520 ND2 $PINS O=n52 I1=A[26] I2=n238
XU521 ND2 $PINS O=n44 I1=A[28] I2=n236
XU522 ND2 $PINS O=n57 I1=A[25] I2=n239
XU523 ND2 $PINS O=n49 I1=A[27] I2=n237
XU524 ND2 $PINS O=n41 I1=A[29] I2=n235
XU525 XNR2HS $PINS O=DIFF[0] I1=n264 I2=A[0]
XU526 NR2 $PINS O=n201 I1=n264 I2=A[0]
XU527 INV1S $PINS O=n264 I=B[0]
XU528 INV1S $PINS O=n258 I=B[6]
XU529 INV1S $PINS O=n257 I=B[7]
XU530 INV1S $PINS O=n259 I=B[5]
XU531 INV1S $PINS O=n261 I=B[3]
XU532 INV1S $PINS O=n255 I=B[9]
XU533 INV1S $PINS O=n256 I=B[8]
XU534 INV1S $PINS O=n247 I=B[17]
XU535 INV1S $PINS O=n254 I=B[10]
XU536 INV1S $PINS O=n252 I=B[12]
XU537 INV1S $PINS O=n251 I=B[13]
XU538 INV1S $PINS O=n249 I=B[15]
XU539 INV1S $PINS O=n250 I=B[14]
XU540 INV1S $PINS O=n245 I=B[19]
XU541 INV1S $PINS O=n244 I=B[20]
XU542 INV1S $PINS O=n242 I=B[22]
XU543 INV1S $PINS O=n262 I=B[2]
XU544 INV1S $PINS O=n260 I=B[4]
XU545 INV1S $PINS O=n253 I=B[11]
XU546 INV1S $PINS O=n248 I=B[16]
XU547 INV1S $PINS O=n243 I=B[21]
XU548 INV1S $PINS O=n246 I=B[18]
XU549 INV1S $PINS O=n263 I=B[1]
XU550 INV1S $PINS O=n241 I=B[23]
XU551 INV1S $PINS O=n240 I=B[24]
XU552 INV1S $PINS O=n239 I=B[25]
XU553 INV1S $PINS O=n238 I=B[26]
XU554 INV1S $PINS O=n237 I=B[27]
XU555 INV1S $PINS O=n236 I=B[28]
XU556 INV1S $PINS O=n235 I=B[29]
XU557 INV1S $PINS O=n234 I=B[30]
XU558 INV1S $PINS O=n233 I=B[31]
.ENDS

.SUBCKT add i_rst add_in_0[31] add_in_0[30] add_in_0[29] add_in_0[28]
+ add_in_0[27] add_in_0[26] add_in_0[25] add_in_0[24] add_in_0[23] add_in_0[22]
+ add_in_0[21] add_in_0[20] add_in_0[19] add_in_0[18] add_in_0[17] add_in_0[16]
+ add_in_0[15] add_in_0[14] add_in_0[13] add_in_0[12] add_in_0[11] add_in_0[10]
+ add_in_0[9] add_in_0[8] add_in_0[7] add_in_0[6] add_in_0[5] add_in_0[4]
+ add_in_0[3] add_in_0[2] add_in_0[1] add_in_0[0] add_in_1[31] add_in_1[30]
+ add_in_1[29] add_in_1[28] add_in_1[27] add_in_1[26] add_in_1[25] add_in_1[24]
+ add_in_1[23] add_in_1[22] add_in_1[21] add_in_1[20] add_in_1[19] add_in_1[18]
+ add_in_1[17] add_in_1[16] add_in_1[15] add_in_1[14] add_in_1[13] add_in_1[12]
+ add_in_1[11] add_in_1[10] add_in_1[9] add_in_1[8] add_in_1[7] add_in_1[6]
+ add_in_1[5] add_in_1[4] add_in_1[3] add_in_1[2] add_in_1[1] add_in_1[0]
+ prime[31] prime[30] prime[29] prime[28] prime[27] prime[26] prime[25]
+ prime[24] prime[23] prime[22] prime[21] prime[20] prime[19] prime[18]
+ prime[17] prime[16] prime[15] prime[14] prime[13] prime[12] prime[11]
+ prime[10] prime[9] prime[8] prime[7] prime[6] prime[5] prime[4] prime[3]
+ prime[2] prime[1] prime[0] sel_add add_out[31] add_out[30] add_out[29]
+ add_out[28] add_out[27] add_out[26] add_out[25] add_out[24] add_out[23]
+ add_out[22] add_out[21] add_out[20] add_out[19] add_out[18] add_out[17]
+ add_out[16] add_out[15] add_out[14] add_out[13] add_out[12] add_out[11]
+ add_out[10] add_out[9] add_out[8] add_out[7] add_out[6] add_out[5] add_out[4]
+ add_out[3] add_out[2] add_out[1] add_out[0] done_add
+ FE_OFN15_FE_DBTN1_i_i_rst FE_OFN11_FE_DBTN1_i_i_rst
+ FE_OFN184_FE_OFN88_raw_prime_8 FE_OFN253_FE_OFN36_raw_prime_26
+ FE_OFN294_FE_OFN6_FE_DBTN1_i_i_rst FE_OFN297_FE_OFN5_FE_DBTN1_i_i_rst
+ FE_OFN346_FE_OFN96_raw_prime_3 i_clk_clone3 i_clk_clone2 i_clk_clone1 i_clk
XFE_OFC627_n77 BUF2CK $PINS O=FE_OFN651_n77 I=n77
XFE_OFC626_n77 BUF1 $PINS O=FE_OFN631_n77 I=n77
XFE_OFC256_n1 BUF1 $PINS O=FE_OFN314_n1 I=n1
XFE_OFC255_n1 BUF1 $PINS O=FE_OFN313_n1 I=n1
XFE_DBTC127_add_out_ext_0_0 INV1S $PINS O=FE_DBTN127_add_out_ext_0_0
+ I=add_out_ext_0[0]
XFE_DBTC126_add_out_ext_0_1 INV1S $PINS O=FE_DBTN126_add_out_ext_0_1
+ I=add_out_ext_0[1]
XFE_DBTC125_add_out_ext_0_2 INV1S $PINS O=FE_DBTN125_add_out_ext_0_2
+ I=add_out_ext_0[2]
XFE_DBTC124_add_out_ext_0_3 INV1S $PINS O=FE_DBTN124_add_out_ext_0_3
+ I=add_out_ext_0[3]
XFE_DBTC123_add_out_ext_0_4 INV1S $PINS O=FE_DBTN123_add_out_ext_0_4
+ I=add_out_ext_0[4]
XFE_DBTC122_add_out_ext_0_5 INV1S $PINS O=FE_DBTN122_add_out_ext_0_5
+ I=add_out_ext_0[5]
XFE_DBTC121_add_out_ext_0_6 INV1S $PINS O=FE_DBTN121_add_out_ext_0_6
+ I=add_out_ext_0[6]
XFE_DBTC120_add_out_ext_0_7 INV1S $PINS O=FE_DBTN120_add_out_ext_0_7
+ I=add_out_ext_0[7]
XFE_DBTC119_add_out_ext_0_8 INV1S $PINS O=FE_DBTN119_add_out_ext_0_8
+ I=add_out_ext_0[8]
XFE_DBTC118_add_out_ext_0_9 INV1S $PINS O=FE_DBTN118_add_out_ext_0_9
+ I=add_out_ext_0[9]
XFE_DBTC117_add_out_ext_0_10 INV1S $PINS O=FE_DBTN117_add_out_ext_0_10
+ I=add_out_ext_0[10]
XFE_DBTC116_add_out_ext_0_11 INV1S $PINS O=FE_DBTN116_add_out_ext_0_11
+ I=add_out_ext_0[11]
XFE_DBTC115_add_out_ext_0_12 INV1S $PINS O=FE_DBTN115_add_out_ext_0_12
+ I=add_out_ext_0[12]
XFE_DBTC114_add_out_ext_0_13 INV1S $PINS O=FE_DBTN114_add_out_ext_0_13
+ I=add_out_ext_0[13]
XFE_DBTC113_add_out_ext_0_14 INV1S $PINS O=FE_DBTN113_add_out_ext_0_14
+ I=add_out_ext_0[14]
XFE_DBTC112_add_out_ext_0_15 INV1S $PINS O=FE_DBTN112_add_out_ext_0_15
+ I=add_out_ext_0[15]
XFE_DBTC111_add_out_ext_0_16 INV1S $PINS O=FE_DBTN111_add_out_ext_0_16
+ I=add_out_ext_0[16]
XFE_DBTC110_add_out_ext_0_17 INV1S $PINS O=FE_DBTN110_add_out_ext_0_17
+ I=add_out_ext_0[17]
XFE_DBTC109_add_out_ext_0_18 INV1S $PINS O=FE_DBTN109_add_out_ext_0_18
+ I=add_out_ext_0[18]
XFE_DBTC108_add_out_ext_0_19 INV1S $PINS O=FE_DBTN108_add_out_ext_0_19
+ I=add_out_ext_0[19]
XFE_DBTC107_add_out_ext_0_20 INV1S $PINS O=FE_DBTN107_add_out_ext_0_20
+ I=add_out_ext_0[20]
XFE_DBTC106_add_out_ext_0_21 INV1S $PINS O=FE_DBTN106_add_out_ext_0_21
+ I=add_out_ext_0[21]
XFE_DBTC105_add_out_ext_0_22 INV1S $PINS O=FE_DBTN105_add_out_ext_0_22
+ I=add_out_ext_0[22]
XFE_DBTC104_add_out_ext_0_23 INV1S $PINS O=FE_DBTN104_add_out_ext_0_23
+ I=add_out_ext_0[23]
XFE_DBTC103_add_out_ext_0_24 INV1S $PINS O=FE_DBTN103_add_out_ext_0_24
+ I=add_out_ext_0[24]
XFE_DBTC102_add_out_ext_0_25 INV1S $PINS O=FE_DBTN102_add_out_ext_0_25
+ I=add_out_ext_0[25]
XFE_DBTC101_add_out_ext_0_26 INV1S $PINS O=FE_DBTN101_add_out_ext_0_26
+ I=add_out_ext_0[26]
XFE_DBTC100_add_out_ext_0_27 INV1S $PINS O=FE_DBTN100_add_out_ext_0_27
+ I=add_out_ext_0[27]
XFE_DBTC99_add_out_ext_0_28 INV1S $PINS O=FE_DBTN99_add_out_ext_0_28
+ I=add_out_ext_0[28]
XFE_DBTC98_add_out_ext_0_29 INV1S $PINS O=FE_DBTN98_add_out_ext_0_29
+ I=add_out_ext_0[29]
XFE_DBTC97_add_out_ext_0_30 INV1S $PINS O=FE_DBTN97_add_out_ext_0_30
+ I=add_out_ext_0[30]
XFE_DBTC96_add_out_ext_0_31 INV1S $PINS O=FE_DBTN96_add_out_ext_0_31
+ I=add_out_ext_0[31]
Xr303 add_DW_cmp_1 $PINS A[32]=add_out_ext_0[32]
+ A[31]=FE_DBTN96_add_out_ext_0_31 A[30]=FE_DBTN97_add_out_ext_0_30
+ A[29]=FE_DBTN98_add_out_ext_0_29 A[28]=FE_DBTN99_add_out_ext_0_28
+ A[27]=FE_DBTN100_add_out_ext_0_27 A[26]=FE_DBTN101_add_out_ext_0_26
+ A[25]=FE_DBTN102_add_out_ext_0_25 A[24]=FE_DBTN103_add_out_ext_0_24
+ A[23]=FE_DBTN104_add_out_ext_0_23 A[22]=FE_DBTN105_add_out_ext_0_22
+ A[21]=FE_DBTN106_add_out_ext_0_21 A[20]=FE_DBTN107_add_out_ext_0_20
+ A[19]=FE_DBTN108_add_out_ext_0_19 A[18]=FE_DBTN109_add_out_ext_0_18
+ A[17]=FE_DBTN110_add_out_ext_0_17 A[16]=FE_DBTN111_add_out_ext_0_16
+ A[15]=FE_DBTN112_add_out_ext_0_15 A[14]=FE_DBTN113_add_out_ext_0_14
+ A[13]=FE_DBTN114_add_out_ext_0_13 A[12]=FE_DBTN115_add_out_ext_0_12
+ A[11]=FE_DBTN116_add_out_ext_0_11 A[10]=FE_DBTN117_add_out_ext_0_10
+ A[9]=FE_DBTN118_add_out_ext_0_9 A[8]=FE_DBTN119_add_out_ext_0_8
+ A[7]=FE_DBTN120_add_out_ext_0_7 A[6]=FE_DBTN121_add_out_ext_0_6
+ A[5]=FE_DBTN122_add_out_ext_0_5 A[4]=FE_DBTN123_add_out_ext_0_4
+ A[3]=FE_DBTN124_add_out_ext_0_3 A[2]=FE_DBTN125_add_out_ext_0_2
+ A[1]=FE_DBTN126_add_out_ext_0_1 A[0]=FE_DBTN127_add_out_ext_0_0 B[32]=n4
+ B[31]=prime[31] B[30]=prime[30] B[29]=prime[29] B[28]=prime[28] B[27]=prime[27]
+ B[26]=FE_OFN253_FE_OFN36_raw_prime_26 B[25]=prime[25] B[24]=prime[24]
+ B[23]=prime[23] B[22]=prime[22] B[21]=prime[21] B[20]=prime[20] B[19]=prime[19]
+ B[18]=prime[18] B[17]=prime[17] B[16]=prime[16] B[15]=prime[15] B[14]=prime[14]
+ B[13]=prime[13] B[12]=prime[12] B[11]=prime[11] B[10]=prime[10] B[9]=prime[9]
+ B[8]=prime[8] B[7]=prime[7] B[6]=prime[6] B[5]=prime[5] B[4]=prime[4]
+ B[3]=prime[3] B[2]=prime[2] B[1]=prime[1] B[0]=prime[0] TC=n4 GE_LT=n4
+ GE_GT_EQ=n3 GE_LT_GT_LE=N9
+ FE_OFN185_FE_OFN88_raw_prime_8=FE_OFN184_FE_OFN88_raw_prime_8
+ FE_OFN347_FE_OFN96_raw_prime_3=FE_OFN346_FE_OFN96_raw_prime_3
Xadd_3104 add_DW01_add_2 $PINS A[32]=n4 A[31]=add_in_0[31] A[30]=add_in_0[30]
+ A[29]=add_in_0[29] A[28]=add_in_0[28] A[27]=add_in_0[27] A[26]=add_in_0[26]
+ A[25]=add_in_0[25] A[24]=add_in_0[24] A[23]=add_in_0[23] A[22]=add_in_0[22]
+ A[21]=add_in_0[21] A[20]=add_in_0[20] A[19]=add_in_0[19] A[18]=add_in_0[18]
+ A[17]=add_in_0[17] A[16]=add_in_0[16] A[15]=add_in_0[15] A[14]=add_in_0[14]
+ A[13]=add_in_0[13] A[12]=add_in_0[12] A[11]=add_in_0[11] A[10]=add_in_0[10]
+ A[9]=add_in_0[9] A[8]=add_in_0[8] A[7]=add_in_0[7] A[6]=add_in_0[6]
+ A[5]=add_in_0[5] A[4]=add_in_0[4] A[3]=add_in_0[3] A[2]=add_in_0[2]
+ A[1]=add_in_0[1] A[0]=add_in_0[0] B[32]=n4 B[31]=add_in_1[31]
+ B[30]=add_in_1[30] B[29]=add_in_1[29] B[28]=add_in_1[28] B[27]=add_in_1[27]
+ B[26]=add_in_1[26] B[25]=add_in_1[25] B[24]=add_in_1[24] B[23]=add_in_1[23]
+ B[22]=add_in_1[22] B[21]=add_in_1[21] B[20]=add_in_1[20] B[19]=add_in_1[19]
+ B[18]=add_in_1[18] B[17]=add_in_1[17] B[16]=add_in_1[16] B[15]=add_in_1[15]
+ B[14]=add_in_1[14] B[13]=add_in_1[13] B[12]=add_in_1[12] B[11]=add_in_1[11]
+ B[10]=add_in_1[10] B[9]=add_in_1[9] B[8]=add_in_1[8] B[7]=add_in_1[7]
+ B[6]=add_in_1[6] B[5]=add_in_1[5] B[4]=add_in_1[4] B[3]=add_in_1[3]
+ B[2]=add_in_1[2] B[1]=add_in_1[1] B[0]=add_in_1[0] CI=n4
+ SUM[32]=add_out_ext_0[32] SUM[31]=add_out_ext_0[31] SUM[30]=add_out_ext_0[30]
+ SUM[29]=add_out_ext_0[29] SUM[28]=add_out_ext_0[28] SUM[27]=add_out_ext_0[27]
+ SUM[26]=add_out_ext_0[26] SUM[25]=add_out_ext_0[25] SUM[24]=add_out_ext_0[24]
+ SUM[23]=add_out_ext_0[23] SUM[22]=add_out_ext_0[22] SUM[21]=add_out_ext_0[21]
+ SUM[20]=add_out_ext_0[20] SUM[19]=add_out_ext_0[19] SUM[18]=add_out_ext_0[18]
+ SUM[17]=add_out_ext_0[17] SUM[16]=add_out_ext_0[16] SUM[15]=add_out_ext_0[15]
+ SUM[14]=add_out_ext_0[14] SUM[13]=add_out_ext_0[13] SUM[12]=add_out_ext_0[12]
+ SUM[11]=add_out_ext_0[11] SUM[10]=add_out_ext_0[10] SUM[9]=add_out_ext_0[9]
+ SUM[8]=add_out_ext_0[8] SUM[7]=add_out_ext_0[7] SUM[6]=add_out_ext_0[6]
+ SUM[5]=add_out_ext_0[5] SUM[4]=add_out_ext_0[4] SUM[3]=add_out_ext_0[3]
+ SUM[2]=add_out_ext_0[2] SUM[1]=add_out_ext_0[1] SUM[0]=add_out_ext_0[0]
Xsub_3105 add_DW01_sub_2 $PINS A[31]=add_out_ext_0[31] A[30]=add_out_ext_0[30]
+ A[29]=add_out_ext_0[29] A[28]=add_out_ext_0[28] A[27]=add_out_ext_0[27]
+ A[26]=add_out_ext_0[26] A[25]=add_out_ext_0[25] A[24]=add_out_ext_0[24]
+ A[23]=add_out_ext_0[23] A[22]=add_out_ext_0[22] A[21]=add_out_ext_0[21]
+ A[20]=add_out_ext_0[20] A[19]=add_out_ext_0[19] A[18]=add_out_ext_0[18]
+ A[17]=add_out_ext_0[17] A[16]=add_out_ext_0[16] A[15]=add_out_ext_0[15]
+ A[14]=add_out_ext_0[14] A[13]=add_out_ext_0[13] A[12]=add_out_ext_0[12]
+ A[11]=add_out_ext_0[11] A[10]=add_out_ext_0[10] A[9]=add_out_ext_0[9]
+ A[8]=add_out_ext_0[8] A[7]=add_out_ext_0[7] A[6]=add_out_ext_0[6]
+ A[5]=add_out_ext_0[5] A[4]=add_out_ext_0[4] A[3]=add_out_ext_0[3]
+ A[2]=add_out_ext_0[2] A[1]=add_out_ext_0[1] A[0]=add_out_ext_0[0]
+ B[31]=prime[31] B[30]=prime[30] B[29]=prime[29] B[28]=prime[28] B[27]=prime[27]
+ B[26]=prime[26] B[25]=prime[25] B[24]=prime[24] B[23]=prime[23] B[22]=prime[22]
+ B[21]=prime[21] B[20]=prime[20] B[19]=prime[19] B[18]=prime[18] B[17]=prime[17]
+ B[16]=prime[16] B[15]=prime[15] B[14]=prime[14] B[13]=prime[13] B[12]=prime[12]
+ B[11]=prime[11] B[10]=prime[10] B[9]=prime[9]
+ B[8]=FE_OFN184_FE_OFN88_raw_prime_8 B[7]=prime[7] B[6]=prime[6] B[5]=prime[5]
+ B[4]=prime[4] B[3]=FE_OFN346_FE_OFN96_raw_prime_3 B[2]=prime[2] B[1]=prime[1]
+ B[0]=prime[0] CI=n4 DIFF[31]=add_out_ext_1[31] DIFF[30]=add_out_ext_1[30]
+ DIFF[29]=add_out_ext_1[29] DIFF[28]=add_out_ext_1[28]
+ DIFF[27]=add_out_ext_1[27] DIFF[26]=add_out_ext_1[26]
+ DIFF[25]=add_out_ext_1[25] DIFF[24]=add_out_ext_1[24]
+ DIFF[23]=add_out_ext_1[23] DIFF[22]=add_out_ext_1[22]
+ DIFF[21]=add_out_ext_1[21] DIFF[20]=add_out_ext_1[20]
+ DIFF[19]=add_out_ext_1[19] DIFF[18]=add_out_ext_1[18]
+ DIFF[17]=add_out_ext_1[17] DIFF[16]=add_out_ext_1[16]
+ DIFF[15]=add_out_ext_1[15] DIFF[14]=add_out_ext_1[14]
+ DIFF[13]=add_out_ext_1[13] DIFF[12]=add_out_ext_1[12]
+ DIFF[11]=add_out_ext_1[11] DIFF[10]=add_out_ext_1[10] DIFF[9]=add_out_ext_1[9]
+ DIFF[8]=add_out_ext_1[8] DIFF[7]=add_out_ext_1[7] DIFF[6]=add_out_ext_1[6]
+ DIFF[5]=add_out_ext_1[5] DIFF[4]=add_out_ext_1[4] DIFF[3]=add_out_ext_1[3]
+ DIFF[2]=add_out_ext_1[2] DIFF[1]=add_out_ext_1[1] DIFF[0]=add_out_ext_1[0]
Xadd_out_reg[31] QDFFRBN $PINS Q=add_out[31] D=add_out_n[31] CK=i_clk_clone3
+ RB=FE_OFN294_FE_OFN6_FE_DBTN1_i_i_rst
Xadd_out_reg[30] QDFFRBN $PINS Q=add_out[30] D=add_out_n[30] CK=i_clk_clone3
+ RB=FE_OFN294_FE_OFN6_FE_DBTN1_i_i_rst
Xadd_out_reg[29] QDFFRBN $PINS Q=add_out[29] D=add_out_n[29] CK=i_clk_clone2
+ RB=FE_OFN294_FE_OFN6_FE_DBTN1_i_i_rst
Xadd_out_reg[28] QDFFRBN $PINS Q=add_out[28] D=add_out_n[28] CK=i_clk_clone3
+ RB=FE_OFN294_FE_OFN6_FE_DBTN1_i_i_rst
Xadd_out_reg[27] QDFFRBN $PINS Q=add_out[27] D=add_out_n[27] CK=i_clk_clone3
+ RB=FE_OFN294_FE_OFN6_FE_DBTN1_i_i_rst
Xadd_out_reg[26] QDFFRBN $PINS Q=add_out[26] D=add_out_n[26] CK=i_clk_clone3
+ RB=FE_OFN294_FE_OFN6_FE_DBTN1_i_i_rst
Xadd_out_reg[25] QDFFRBN $PINS Q=add_out[25] D=add_out_n[25] CK=i_clk_clone3
+ RB=FE_OFN294_FE_OFN6_FE_DBTN1_i_i_rst
Xadd_out_reg[24] QDFFRBN $PINS Q=add_out[24] D=add_out_n[24] CK=i_clk_clone3
+ RB=FE_OFN294_FE_OFN6_FE_DBTN1_i_i_rst
Xadd_out_reg[23] QDFFRBN $PINS Q=add_out[23] D=add_out_n[23] CK=i_clk_clone3
+ RB=FE_OFN294_FE_OFN6_FE_DBTN1_i_i_rst
Xadd_out_reg[22] QDFFRBN $PINS Q=add_out[22] D=add_out_n[22] CK=i_clk_clone3
+ RB=FE_OFN294_FE_OFN6_FE_DBTN1_i_i_rst
Xadd_out_reg[21] QDFFRBN $PINS Q=add_out[21] D=add_out_n[21] CK=i_clk_clone2
+ RB=FE_OFN15_FE_DBTN1_i_i_rst
Xadd_out_reg[20] QDFFRBN $PINS Q=add_out[20] D=add_out_n[20] CK=i_clk
+ RB=FE_OFN15_FE_DBTN1_i_i_rst
Xadd_out_reg[19] QDFFRBN $PINS Q=add_out[19] D=add_out_n[19] CK=i_clk
+ RB=FE_OFN15_FE_DBTN1_i_i_rst
Xadd_out_reg[18] QDFFRBN $PINS Q=add_out[18] D=add_out_n[18] CK=i_clk
+ RB=FE_OFN15_FE_DBTN1_i_i_rst
Xadd_out_reg[17] QDFFRBN $PINS Q=add_out[17] D=add_out_n[17] CK=i_clk
+ RB=FE_OFN15_FE_DBTN1_i_i_rst
Xadd_out_reg[16] QDFFRBN $PINS Q=add_out[16] D=add_out_n[16] CK=i_clk
+ RB=FE_OFN15_FE_DBTN1_i_i_rst
Xadd_out_reg[15] QDFFRBN $PINS Q=add_out[15] D=add_out_n[15] CK=i_clk RB=i_rst
Xadd_out_reg[14] QDFFRBN $PINS Q=add_out[14] D=add_out_n[14] CK=i_clk RB=i_rst
Xadd_out_reg[13] QDFFRBN $PINS Q=add_out[13] D=add_out_n[13] CK=i_clk RB=i_rst
Xadd_out_reg[12] QDFFRBN $PINS Q=add_out[12] D=add_out_n[12] CK=i_clk RB=i_rst
Xadd_out_reg[11] QDFFRBN $PINS Q=add_out[11] D=add_out_n[11] CK=i_clk
+ RB=FE_OFN11_FE_DBTN1_i_i_rst
Xadd_out_reg[10] QDFFRBN $PINS Q=add_out[10] D=add_out_n[10] CK=i_clk
+ RB=FE_OFN11_FE_DBTN1_i_i_rst
Xadd_out_reg[8] QDFFRBN $PINS Q=add_out[8] D=add_out_n[8] CK=i_clk
+ RB=FE_OFN11_FE_DBTN1_i_i_rst
Xadd_out_reg[7] QDFFRBN $PINS Q=add_out[7] D=add_out_n[7] CK=i_clk
+ RB=FE_OFN11_FE_DBTN1_i_i_rst
Xadd_out_reg[6] QDFFRBN $PINS Q=add_out[6] D=add_out_n[6] CK=i_clk
+ RB=FE_OFN297_FE_OFN5_FE_DBTN1_i_i_rst
Xadd_out_reg[5] QDFFRBN $PINS Q=add_out[5] D=add_out_n[5] CK=i_clk
+ RB=FE_OFN297_FE_OFN5_FE_DBTN1_i_i_rst
Xadd_out_reg[4] QDFFRBN $PINS Q=add_out[4] D=add_out_n[4] CK=i_clk
+ RB=FE_OFN297_FE_OFN5_FE_DBTN1_i_i_rst
Xadd_out_reg[3] QDFFRBN $PINS Q=add_out[3] D=add_out_n[3] CK=i_clk
+ RB=FE_OFN297_FE_OFN5_FE_DBTN1_i_i_rst
Xadd_out_reg[2] QDFFRBN $PINS Q=add_out[2] D=add_out_n[2] CK=i_clk_clone1
+ RB=FE_OFN297_FE_OFN5_FE_DBTN1_i_i_rst
Xadd_out_reg[1] QDFFRBN $PINS Q=add_out[1] D=add_out_n[1] CK=i_clk_clone1
+ RB=FE_OFN297_FE_OFN5_FE_DBTN1_i_i_rst
Xadd_out_reg[0] QDFFRBN $PINS Q=add_out[0] D=add_out_n[0] CK=i_clk_clone1
+ RB=FE_OFN297_FE_OFN5_FE_DBTN1_i_i_rst
Xadd_out_reg[9] QDFFRBN $PINS Q=add_out[9] D=add_out_n[9] CK=i_clk
+ RB=FE_OFN11_FE_DBTN1_i_i_rst
Xstate_reg QDFFRBN $PINS Q=done_add D=n78 CK=i_clk RB=i_rst
XU10 MOAI1S $PINS O=add_out_n[1] A1=FE_OFN631_n77 A2=FE_DBTN126_add_out_ext_0_1
+ B1=add_out_ext_1[1] B2=FE_OFN313_n1
XU12 MOAI1S $PINS O=add_out_n[2] A1=FE_OFN631_n77 A2=FE_DBTN125_add_out_ext_0_2
+ B1=add_out_ext_1[2] B2=FE_OFN313_n1
XU14 MOAI1S $PINS O=add_out_n[6] A1=FE_OFN631_n77 A2=FE_DBTN121_add_out_ext_0_6
+ B1=add_out_ext_1[6] B2=FE_OFN313_n1
XU16 MOAI1S $PINS O=add_out_n[8] A1=FE_OFN631_n77 A2=FE_DBTN119_add_out_ext_0_8
+ B1=add_out_ext_1[8] B2=FE_OFN313_n1
XU18 MOAI1S $PINS O=add_out_n[12] A1=FE_OFN631_n77
+ A2=FE_DBTN115_add_out_ext_0_12 B1=add_out_ext_1[12] B2=FE_OFN313_n1
XU20 MOAI1S $PINS O=add_out_n[18] A1=FE_OFN651_n77
+ A2=FE_DBTN109_add_out_ext_0_18 B1=add_out_ext_1[18] B2=FE_OFN314_n1
XU22 MOAI1S $PINS O=add_out_n[4] A1=FE_OFN631_n77 A2=FE_DBTN123_add_out_ext_0_4
+ B1=add_out_ext_1[4] B2=FE_OFN313_n1
XU24 MOAI1S $PINS O=add_out_n[10] A1=FE_OFN631_n77
+ A2=FE_DBTN117_add_out_ext_0_10 B1=add_out_ext_1[10] B2=FE_OFN313_n1
XU26 MOAI1S $PINS O=add_out_n[14] A1=FE_OFN631_n77
+ A2=FE_DBTN113_add_out_ext_0_14 B1=add_out_ext_1[14] B2=FE_OFN313_n1
XU28 MOAI1S $PINS O=add_out_n[16] A1=n77 A2=FE_DBTN111_add_out_ext_0_16
+ B1=add_out_ext_1[16] B2=FE_OFN314_n1
XU30 MOAI1S $PINS O=add_out_n[20] A1=FE_OFN651_n77
+ A2=FE_DBTN107_add_out_ext_0_20 B1=add_out_ext_1[20] B2=FE_OFN314_n1
XU32 MOAI1S $PINS O=add_out_n[5] A1=FE_OFN631_n77 A2=FE_DBTN122_add_out_ext_0_5
+ B1=add_out_ext_1[5] B2=FE_OFN313_n1
XU34 MOAI1S $PINS O=add_out_n[11] A1=FE_OFN631_n77
+ A2=FE_DBTN116_add_out_ext_0_11 B1=add_out_ext_1[11] B2=FE_OFN313_n1
XU36 MOAI1S $PINS O=add_out_n[13] A1=FE_OFN631_n77
+ A2=FE_DBTN114_add_out_ext_0_13 B1=add_out_ext_1[13] B2=FE_OFN313_n1
XU38 MOAI1S $PINS O=add_out_n[15] A1=FE_OFN631_n77
+ A2=FE_DBTN112_add_out_ext_0_15 B1=add_out_ext_1[15] B2=FE_OFN313_n1
XU40 MOAI1S $PINS O=add_out_n[17] A1=n77 A2=FE_DBTN110_add_out_ext_0_17
+ B1=add_out_ext_1[17] B2=FE_OFN314_n1
XU42 MOAI1S $PINS O=add_out_n[22] A1=FE_OFN651_n77
+ A2=FE_DBTN105_add_out_ext_0_22 B1=add_out_ext_1[22] B2=FE_OFN314_n1
XU44 MOAI1S $PINS O=add_out_n[23] A1=FE_OFN651_n77
+ A2=FE_DBTN104_add_out_ext_0_23 B1=add_out_ext_1[23] B2=FE_OFN314_n1
XU46 MOAI1S $PINS O=add_out_n[25] A1=FE_OFN651_n77
+ A2=FE_DBTN102_add_out_ext_0_25 B1=add_out_ext_1[25] B2=FE_OFN314_n1
XU48 MOAI1S $PINS O=add_out_n[27] A1=FE_OFN651_n77
+ A2=FE_DBTN100_add_out_ext_0_27 B1=add_out_ext_1[27] B2=FE_OFN314_n1
XU50 MOAI1S $PINS O=add_out_n[29] A1=FE_OFN651_n77
+ A2=FE_DBTN98_add_out_ext_0_29 B1=add_out_ext_1[29] B2=FE_OFN314_n1
XU52 MOAI1S $PINS O=add_out_n[31] A1=FE_OFN651_n77
+ A2=FE_DBTN96_add_out_ext_0_31 B1=add_out_ext_1[31] B2=FE_OFN314_n1
XU54 MOAI1S $PINS O=add_out_n[3] A1=FE_OFN631_n77 A2=FE_DBTN124_add_out_ext_0_3
+ B1=add_out_ext_1[3] B2=FE_OFN313_n1
XU56 MOAI1S $PINS O=add_out_n[7] A1=FE_OFN631_n77 A2=FE_DBTN120_add_out_ext_0_7
+ B1=add_out_ext_1[7] B2=FE_OFN313_n1
XU58 MOAI1S $PINS O=add_out_n[9] A1=FE_OFN631_n77 A2=FE_DBTN118_add_out_ext_0_9
+ B1=add_out_ext_1[9] B2=FE_OFN313_n1
XU60 MOAI1S $PINS O=add_out_n[19] A1=FE_OFN651_n77
+ A2=FE_DBTN108_add_out_ext_0_19 B1=add_out_ext_1[19] B2=FE_OFN314_n1
XU62 MOAI1S $PINS O=add_out_n[21] A1=FE_OFN651_n77
+ A2=FE_DBTN106_add_out_ext_0_21 B1=add_out_ext_1[21] B2=FE_OFN314_n1
XU64 MOAI1S $PINS O=add_out_n[24] A1=FE_OFN651_n77
+ A2=FE_DBTN103_add_out_ext_0_24 B1=add_out_ext_1[24] B2=FE_OFN314_n1
XU66 MOAI1S $PINS O=add_out_n[26] A1=FE_OFN651_n77
+ A2=FE_DBTN101_add_out_ext_0_26 B1=add_out_ext_1[26] B2=FE_OFN314_n1
XU68 MOAI1S $PINS O=add_out_n[28] A1=FE_OFN651_n77
+ A2=FE_DBTN99_add_out_ext_0_28 B1=add_out_ext_1[28] B2=FE_OFN314_n1
XU70 MOAI1S $PINS O=add_out_n[30] A1=FE_OFN651_n77
+ A2=FE_DBTN97_add_out_ext_0_30 B1=add_out_ext_1[30] B2=FE_OFN314_n1
XU72 MOAI1 $PINS O=add_out_n[0] A1=FE_OFN631_n77 A2=FE_DBTN127_add_out_ext_0_0
+ B1=add_out_ext_1[0] B2=FE_OFN313_n1
XU75 INV1S $PINS O=n78 I=n44
XU77 MXL2HS $PINS OB=n1 S=N9 A=n11 B=n44
XU107 INV1S $PINS O=n11 I=done_add
XU112 ND2 $PINS O=n44 I1=sel_add I2=n11
XU113 MUX2 $PINS O=n77 S=N9 A=n44 B=n11
.ENDS

.SUBCKT sub_DW_cmp_0 A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24] A[23]
+ A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12] A[11] A[10]
+ A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30] B[29] B[28]
+ B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15]
+ B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1]
+ B[0] TC GE_LT GE_GT_EQ GE_LT_GT_LE EQ_NE FE_OFN331_Py_mont_0
+ FE_OFN112_Py_mont_4
XFE_RC_2414_0 AO12 $PINS O=n288 A1=n297 B1=n296 B2=n298
XU157 ND2S $PINS O=n340 I1=B[3] I2=n243
XU158 MAOI1S $PINS O=n317 A1=A[14] A2=n226 B1=B[15] B2=n233
XU159 OA12S $PINS O=n309 A1=n311 B1=A[8] B2=n263
XU160 ND2S $PINS O=n320 I1=B[15] I2=n233
XU161 ND2S $PINS O=n325 I1=B[11] I2=n230
XU162 OA12S $PINS O=n308 A1=n325 B1=A[10] B2=n248
XU163 OA12S $PINS O=n319 A1=n320 B1=A[14] B2=n250
XU164 MAOI1S $PINS O=n292 A1=A[30] A2=n227 B1=B[31] B2=n242
XU165 ND3S $PINS O=n282 I1=n283 I2=n251 I3=A[16]
XU166 ND3S $PINS O=n316 I1=n318 I2=n249 I3=A[12]
XU167 ND3S $PINS O=n291 I1=n293 I2=n258 I3=A[28]
XU168 ND2S $PINS O=n318 I1=B[13] I2=n232
XU169 ND2S $PINS O=n283 I1=B[17] I2=n234
XU170 ND2S $PINS O=n275 I1=B[21] I2=n237
XU171 ND2S $PINS O=n285 I1=B[19] I2=n236
XU172 OA12S $PINS O=n303 A1=n300 B1=A[24] B2=n256
XU173 OA112S $PINS O=n281 A1=n275 B1=n271 C1=A[20] C2=n254
XU174 OA12S $PINS O=n278 A1=n285 B1=A[18] B2=n252
XU175 OA112S $PINS O=n287 A1=n293 B1=n294 C1=A[28] C2=n258
XU176 OA12S $PINS O=n271 A1=n277 B1=A[22] B2=n255
XU177 OA12S $PINS O=n296 A1=n302 B1=A[26] B2=n257
XU178 OA12S $PINS O=n294 A1=n295 B1=A[30] B2=n260
XU179 ND2S $PINS O=n311 I1=B[9] I2=n247
XU180 ND2S $PINS O=n332 I1=B[7] I2=n246
XU181 INV1S $PINS O=n229 I=n310
XU182 INV1S $PINS O=n245 I=n328
XU183 INV1S $PINS O=n230 I=A[11]
XU184 INV1S $PINS O=n247 I=A[9]
XU185 INV1S $PINS O=n233 I=A[15]
XU186 INV1S $PINS O=n231 I=n312
XU187 INV1S $PINS O=n232 I=A[13]
XU188 INV1S $PINS O=n234 I=A[17]
XU189 INV1S $PINS O=n241 I=A[29]
XU190 INV1S $PINS O=n235 I=n279
XU191 INV1S $PINS O=n236 I=A[19]
XU192 INV1S $PINS O=n240 I=A[27]
XU193 INV1S $PINS O=n239 I=A[25]
XU194 INV1S $PINS O=n244 I=A[5]
XU195 INV1S $PINS O=n246 I=A[7]
XU196 INV1S $PINS O=n237 I=A[21]
XU197 INV1S $PINS O=n238 I=A[23]
XU198 INV1S $PINS O=n243 I=A[3]
XU199 INV1S $PINS O=n249 I=B[12]
XU200 INV1S $PINS O=n242 I=A[31]
XU201 INV1S $PINS O=n250 I=B[14]
XU202 INV1S $PINS O=n260 I=B[30]
XU203 INV1S $PINS O=n254 I=B[20]
XU204 INV1S $PINS O=n248 I=B[10]
XU205 INV1S $PINS O=n252 I=B[18]
XU206 INV1S $PINS O=n255 I=B[22]
XU207 INV1S $PINS O=n257 I=B[26]
XU208 INV1S $PINS O=n256 I=B[24]
XU209 AN2 $PINS O=n226 I1=n320 I2=n250
XU210 AN2 $PINS O=n227 I1=n295 I2=n260
XU211 INV1S $PINS O=n251 I=B[16]
XU212 INV1S $PINS O=n258 I=B[28]
XU213 INV1S $PINS O=n259 I=B[2]
XU214 INV1S $PINS O=n253 I=B[1]
XU215 INV1S $PINS O=n262 I=B[6]
XU217 INV1S $PINS O=n263 I=B[8]
XU218 MAOI1S $PINS O=n333 A1=A[2] A2=n228 B1=B[3] B2=n243
XU219 AN2 $PINS O=n228 I1=n340 I2=n259
XU220 MOAI1S $PINS O=GE_LT_GT_LE A1=n264 A2=n265 B1=n266 B2=n267
XU221 ND3 $PINS O=n267 I1=n268 I2=n269 I3=n270
XU222 OAI22S $PINS O=n269 A1=n271 A2=n272 B1=n272 B2=n273
XU223 MOAI1S $PINS O=n273 A1=B[21] A2=n237 B1=A[20] B2=n274
XU224 AN2 $PINS O=n274 I1=n275 I2=n254
XU225 MOAI1S $PINS O=n272 A1=B[23] A2=n238 B1=A[22] B2=n276
XU226 AN2 $PINS O=n276 I1=n277 I2=n255
XU227 OAI112HS $PINS O=n268 A1=n280 B1=n281 C1=n278 C2=n279
XU228 OAI112HS $PINS O=n280 A1=n282 B1=n235 C1=B[17] C2=n234
XU229 MOAI1S $PINS O=n279 A1=B[19] A2=n236 B1=A[18] B2=n284
XU230 AN2 $PINS O=n284 I1=n285 I2=n252
XU231 ND2 $PINS O=n266 I1=n270 I2=n286
XU232 AOI22S $PINS O=n270 A1=n287 A2=n288 B1=n289 B2=n290
XU233 OAI112HS $PINS O=n290 A1=n291 B1=n292 C1=B[29] C2=n241
XU234 OR2B1S $PINS O=n289 I1=n294 B1=n292
XU236 MOAI1S $PINS O=n298 A1=B[25] A2=n239 B1=A[24] B2=n299
XU237 AN2 $PINS O=n299 I1=n300 I2=n256
XU238 MOAI1S $PINS O=n297 A1=B[27] A2=n240 B1=A[26] B2=n301
XU239 AN2 $PINS O=n301 I1=n302 I2=n257
XU240 OR3B2 $PINS O=n265 I1=n286 B1=n281 B2=n278
XU241 ND2 $PINS O=n277 I1=B[23] I2=n238
XU242 ND3 $PINS O=n286 I1=n296 I2=n287 I3=n303
XU243 ND2 $PINS O=n300 I1=B[25] I2=n239
XU244 ND2 $PINS O=n295 I1=B[31] I2=n242
XU245 ND2 $PINS O=n293 I1=B[29] I2=n241
XU246 ND2 $PINS O=n302 I1=B[27] I2=n240
XU247 OAI112HS $PINS O=n264 A1=n283 B1=n304 C1=A[16] C2=n251
XU248 AOI13HS $PINS O=n304 A1=n307 B1=n305 B2=n306 B3=n229
XU249 AOI13HS $PINS O=n307 A1=n310 B1=n308 B2=n231 B3=n309
XU250 MOAI1S $PINS O=n310 A1=n312 A2=n313 B1=n314 B2=n315
XU251 OAI112HS $PINS O=n315 A1=n316 B1=n317 C1=B[13] C2=n232
XU252 OR2B1S $PINS O=n314 I1=n319 B1=n317
XU253 OAI22S $PINS O=n313 A1=n308 A2=n321 B1=n321 B2=n322
XU254 MOAI1S $PINS O=n322 A1=B[9] A2=n247 B1=A[8] B2=n323
XU255 AN2 $PINS O=n323 I1=n311 I2=n263
XU256 MOAI1S $PINS O=n321 A1=B[11] A2=n230 B1=A[10] B2=n324
XU257 AN2 $PINS O=n324 I1=n325 I2=n248
XU258 OAI112HS $PINS O=n312 A1=n318 B1=n319 C1=A[12] C2=n249
XU259 OAI22S $PINS O=n306 A1=n326 A2=n327 B1=n245 B2=n326
XU260 MOAI1S $PINS O=n327 A1=B[5] A2=n244 B1=A[4] B2=n329
XU261 AN2 $PINS O=n329 I1=n330 I2=FE_OFN112_Py_mont_4
XU262 MOAI1S $PINS O=n326 A1=B[7] A2=n246 B1=A[6] B2=n331
XU263 AN2 $PINS O=n331 I1=n332 I2=n262
XU264 AO112 $PINS O=n305 A1=n328 B1=n335 C1=n333 C2=n334
XU265 OAI112HS $PINS O=n335 A1=n330 B1=n336 C1=A[4] C2=FE_OFN112_Py_mont_4
XU266 ND2 $PINS O=n336 I1=n337 I2=n333
XU267 AOI22S $PINS O=n337 A1=A[1] A2=n253 B1=n338 B2=A[0]
XU268 NR2 $PINS O=n338 I1=FE_OFN331_Py_mont_0 I2=n339
XU269 NR2 $PINS O=n339 I1=A[1] I2=n253
XU270 ND2 $PINS O=n330 I1=B[5] I2=n244
XU271 OAI12HS $PINS O=n328 A1=n332 B1=A[6] B2=n262
XU272 OAI12HS $PINS O=n334 A1=n340 B1=A[2] B2=n259
.ENDS

.SUBCKT sub_DW01_sub_3 A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24] A[23]
+ A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12] A[11] A[10]
+ A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30] B[29] B[28]
+ B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15]
+ B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1]
+ B[0] CI DIFF[31] DIFF[30] DIFF[29] DIFF[28] DIFF[27] DIFF[26] DIFF[25]
+ DIFF[24] DIFF[23] DIFF[22] DIFF[21] DIFF[20] DIFF[19] DIFF[18] DIFF[17]
+ DIFF[16] DIFF[15] DIFF[14] DIFF[13] DIFF[12] DIFF[11] DIFF[10] DIFF[9]
+ DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3] DIFF[2] DIFF[1] DIFF[0] CO
XFE_RC_2344_0 AOI12H $PINS O=n74 A1=n76 B1=n79 B2=n337
XFE_RC_2305_0 AOI12H $PINS O=n114 A1=n116 B1=n119 B2=n333
XFE_RC_2269_0 AOI12H $PINS O=n66 A1=n68 B1=n71 B2=n339
XFE_OFC249_Py_mont_8 INV1S $PINS O=n215 I=B[8]
XFE_OFC230_Py_mont_6 INV1S $PINS O=n217 I=B[6]
XFE_OFC224_Py_mont_5 INV1S $PINS O=n218 I=B[5]
XU259 OR2 $PINS O=n330 I1=A[5] I2=n218
XU260 ND2 $PINS O=n141 I1=n218 I2=A[5]
XU261 AOI12HS $PINS O=n130 A1=n132 B1=n135 B2=n331
XU262 OAI12H $PINS O=n127 A1=n129 B1=n130 B2=n128
XU264 OAI12H $PINS O=n111 A1=n113 B1=n114 B2=n112
XU265 AOI12HS $PINS O=n98 A1=n100 B1=n103 B2=n334
XU266 OAI12H $PINS O=n95 A1=n97 B1=n98 B2=n96
XU267 AOI12HS $PINS O=n50 A1=n52 B1=n55 B2=n343
XU268 OAI12H $PINS O=n47 A1=n49 B1=n50 B2=n48
XU269 INV1S $PINS O=n221 I=B[2]
XU270 INV1S $PINS O=n220 I=B[3]
XU272 OR2 $PINS O=n326 I1=n106 I2=n104
XU273 ND2 $PINS O=n103 I1=n326 I2=n105
XU274 AOI12H $PINS O=n106 A1=n108 B1=n111 B2=n335
XU275 ND2 $PINS O=n105 I1=n210 I2=A[13]
XU276 OAI12H $PINS O=n55 A1=n57 B1=n58 B2=n56
XU277 AOI12H $PINS O=n58 A1=n60 B1=n63 B2=n342
XU278 OAI12H $PINS O=n87 A1=n89 B1=n90 B2=n88
XU279 AOI12H $PINS O=n90 A1=n92 B1=n95 B2=n336
XU281 AOI12H $PINS O=n122 A1=n124 B1=n127 B2=n332
XU282 AOI12HS $PINS O=n82 A1=n84 B1=n87 B2=n338
XU285 ND2S $PINS O=n30 I1=n190 I2=n155
XU286 ND2S $PINS O=n28 I1=n329 I2=n146
XU287 ND2S $PINS O=n27 I1=n330 I2=n141
XU288 ND2S $PINS O=n159 I1=n222 I2=A[1]
XU289 ND2S $PINS O=n152 I1=n220 I2=A[3]
XU290 ND2S $PINS O=n146 I1=B[4] I2=A[4]
XU291 ND2S $PINS O=n129 I1=n216 I2=A[7]
XU292 ND2S $PINS O=n121 I1=n214 I2=A[9]
XU293 ND2S $PINS O=n113 I1=n212 I2=A[11]
XU294 ND2S $PINS O=n110 I1=n211 I2=A[12]
XU295 ND2S $PINS O=n102 I1=n209 I2=A[14]
XU296 ND2S $PINS O=n134 I1=n217 I2=A[6]
XU297 ND2S $PINS O=n126 I1=n215 I2=A[8]
XU298 ND2S $PINS O=n118 I1=n213 I2=A[10]
XU299 OR2S $PINS O=n335 I1=A[12] I2=n211
XU300 OR2S $PINS O=n334 I1=A[14] I2=n209
XU301 OR2S $PINS O=n331 I1=A[6] I2=n217
XU302 OR2S $PINS O=n332 I1=A[8] I2=n215
XU303 OR2S $PINS O=n333 I1=A[10] I2=n213
XU304 ND2S $PINS O=n94 I1=n207 I2=A[16]
XU305 ND2S $PINS O=n78 I1=n203 I2=A[20]
XU306 ND2S $PINS O=n86 I1=n205 I2=A[18]
XU307 ND2S $PINS O=n97 I1=n208 I2=A[15]
XU308 ND2S $PINS O=n89 I1=n206 I2=A[17]
XU309 ND2S $PINS O=n81 I1=n204 I2=A[19]
XU310 OR2S $PINS O=n336 I1=A[16] I2=n207
XU311 OR2S $PINS O=n337 I1=A[20] I2=n203
XU312 OR2S $PINS O=n338 I1=A[18] I2=n205
XU313 ND2S $PINS O=n70 I1=n201 I2=A[22]
XU314 ND2S $PINS O=n62 I1=n199 I2=A[24]
XU315 ND2S $PINS O=n73 I1=n202 I2=A[21]
XU316 ND2S $PINS O=n65 I1=n200 I2=A[23]
XU317 ND2S $PINS O=n57 I1=n198 I2=A[25]
XU318 OR2S $PINS O=n339 I1=A[22] I2=n201
XU319 OR2S $PINS O=n342 I1=A[24] I2=n199
XU320 ND2S $PINS O=n46 I1=n195 I2=A[28]
XU321 ND2S $PINS O=n54 I1=n197 I2=A[26]
XU322 ND2S $PINS O=n49 I1=n196 I2=A[27]
XU323 ND2S $PINS O=n41 I1=n194 I2=A[29]
XU324 OR2S $PINS O=n343 I1=A[26] I2=n197
XU325 OR2S $PINS O=n341 I1=A[28] I2=n195
XU326 ND2S $PINS O=n38 I1=n193 I2=A[30]
XU327 OR2S $PINS O=n340 I1=A[30] I2=n193
XU328 ND2 $PINS O=n1 I1=n327 I2=n328
XU329 OR2S $PINS O=n327 I1=A[31] I2=n192
XU330 ND2 $PINS O=n328 I1=n192 I2=A[31]
XU331 XOR2HS $PINS O=DIFF[25] I1=n7 I2=n58
XU332 XOR2HS $PINS O=DIFF[29] I1=n3 I2=n42
XU333 XOR2HS $PINS O=DIFF[27] I1=n5 I2=n50
XU334 XNR2HS $PINS O=DIFF[30] I1=n2 I2=n39
XU335 XNR2HS $PINS O=DIFF[24] I1=n8 I2=n63
XU336 XNR2HS $PINS O=DIFF[26] I1=n6 I2=n55
XU337 XNR2HS $PINS O=DIFF[28] I1=n4 I2=n47
XU338 XOR2HS $PINS O=DIFF[19] I1=n13 I2=n82
XU339 XOR2HS $PINS O=DIFF[21] I1=n11 I2=n74
XU340 XOR2HS $PINS O=DIFF[23] I1=n9 I2=n66
XU341 XNR2HS $PINS O=DIFF[14] I1=n18 I2=n103
XU342 XOR2HS $PINS O=DIFF[15] I1=n17 I2=n98
XU343 XNR2HS $PINS O=DIFF[20] I1=n12 I2=n79
XU344 XOR2HS $PINS O=DIFF[17] I1=n15 I2=n90
XU345 XNR2HS $PINS O=DIFF[18] I1=n14 I2=n87
XU346 XNR2HS $PINS O=DIFF[16] I1=n16 I2=n95
XU347 XNR2HS $PINS O=DIFF[22] I1=n10 I2=n71
XU348 INV1S $PINS O=n156 I=n157
XU349 INV1S $PINS O=n147 I=n148
XU350 OAI12H $PINS O=n119 A1=n121 B1=n122 B2=n120
XU351 OAI12H $PINS O=n79 A1=n81 B1=n82 B2=n80
XU352 OAI12H $PINS O=n71 A1=n73 B1=n74 B2=n72
XU353 OAI12H $PINS O=n63 A1=n65 B1=n66 B2=n64
XU354 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU355 INV1S $PINS O=n144 I=n146
XU356 OAI12H $PINS O=n135 A1=n137 B1=n148 B2=n136
XU357 AOI12HS $PINS O=n137 A1=n139 B1=n330 B2=n144
XU358 ND2 $PINS O=n136 I1=n330 I2=n329
XU359 INV1S $PINS O=n139 I=n141
XU360 INV1S $PINS O=n100 I=n102
XU361 INV1S $PINS O=n108 I=n110
XU362 INV1S $PINS O=n92 I=n94
XU363 AOI12HS $PINS O=n42 A1=n44 B1=n47 B2=n341
XU364 INV1S $PINS O=n44 I=n46
XU365 INV1S $PINS O=n132 I=n134
XU366 INV1S $PINS O=n76 I=n78
XU367 INV1S $PINS O=n124 I=n126
XU368 INV1S $PINS O=n116 I=n118
XU369 INV1S $PINS O=n84 I=n86
XU370 INV1S $PINS O=n68 I=n70
XU371 INV1S $PINS O=n60 I=n62
XU372 INV1S $PINS O=n52 I=n54
XU373 OAI12HS $PINS O=n157 A1=n159 B1=n158 B2=n160
XU374 AOI12HS $PINS O=n34 A1=n36 B1=n39 B2=n340
XU375 INV1S $PINS O=n36 I=n38
XU376 AOI12HS $PINS O=n148 A1=n150 B1=n149 B2=n157
XU377 NR2 $PINS O=n149 I1=n154 I2=n151
XU378 OAI12HS $PINS O=n150 A1=n152 B1=n151 B2=n155
XU379 XOR2HS $PINS O=DIFF[31] I1=n1 I2=n34
XU380 XOR2HS $PINS O=DIFF[1] I1=n160 I2=n31
XU381 ND2 $PINS O=n31 I1=n191 I2=n159
XU382 XOR2HS $PINS O=DIFF[2] I1=n30 I2=n156
XU383 XOR2HS $PINS O=DIFF[5] I1=n27 I2=n142
XU384 XOR2HS $PINS O=DIFF[7] I1=n25 I2=n130
XU385 ND2 $PINS O=n25 I1=n185 I2=n129
XU386 XNR2HS $PINS O=DIFF[3] I1=n29 I2=n153
XU387 ND2 $PINS O=n29 I1=n189 I2=n152
XU388 XNR2HS $PINS O=DIFF[4] I1=n28 I2=n147
XU389 XNR2HS $PINS O=DIFF[8] I1=n24 I2=n127
XU390 ND2 $PINS O=n24 I1=n332 I2=n126
XU391 XNR2HS $PINS O=DIFF[6] I1=n26 I2=n135
XU392 ND2 $PINS O=n26 I1=n331 I2=n134
XU393 XOR2HS $PINS O=DIFF[9] I1=n23 I2=n122
XU394 ND2 $PINS O=n23 I1=n183 I2=n121
XU395 XNR2HS $PINS O=DIFF[10] I1=n22 I2=n119
XU396 ND2 $PINS O=n22 I1=n333 I2=n118
XU397 XOR2HS $PINS O=DIFF[13] I1=n19 I2=n106
XU398 ND2 $PINS O=n19 I1=n179 I2=n105
XU399 XOR2HS $PINS O=DIFF[11] I1=n21 I2=n114
XU400 ND2 $PINS O=n21 I1=n181 I2=n113
XU401 XNR2HS $PINS O=DIFF[12] I1=n20 I2=n111
XU402 ND2 $PINS O=n20 I1=n335 I2=n110
XU403 OAI12HS $PINS O=n153 A1=n155 B1=n156 B2=n154
XU404 AOI12HS $PINS O=n142 A1=n144 B1=n147 B2=n329
XU405 OR2B1S $PINS O=n17 I1=n96 B1=n97
XU406 OR2B1S $PINS O=n15 I1=n88 B1=n89
XU407 OR2B1S $PINS O=n13 I1=n80 B1=n81
XU408 OR2B1S $PINS O=n11 I1=n72 B1=n73
XU409 OR2B1S $PINS O=n9 I1=n64 B1=n65
XU410 OR2B1S $PINS O=n7 I1=n56 B1=n57
XU411 OR2B1S $PINS O=n5 I1=n48 B1=n49
XU412 OR2B1S $PINS O=n3 I1=n40 B1=n41
XU413 ND2 $PINS O=n18 I1=n334 I2=n102
XU414 ND2 $PINS O=n2 I1=n340 I2=n38
XU415 ND2 $PINS O=n16 I1=n336 I2=n94
XU416 ND2 $PINS O=n4 I1=n341 I2=n46
XU417 ND2 $PINS O=n12 I1=n337 I2=n78
XU418 ND2 $PINS O=n14 I1=n338 I2=n86
XU419 ND2 $PINS O=n10 I1=n339 I2=n70
XU420 ND2 $PINS O=n8 I1=n342 I2=n62
XU421 ND2 $PINS O=n6 I1=n343 I2=n54
XU422 INV1S $PINS O=n190 I=n154
XU423 INV1S $PINS O=n189 I=n151
XU424 INV1S $PINS O=n191 I=n158
XU425 INV1S $PINS O=n185 I=n128
XU426 INV1S $PINS O=n183 I=n120
XU427 INV1S $PINS O=n181 I=n112
XU428 INV1S $PINS O=n179 I=n104
XU429 ND2 $PINS O=n155 I1=n221 I2=A[2]
XU430 INV1S $PINS O=n213 I=B[10]
XU431 NR2 $PINS O=n154 I1=A[2] I2=n221
XU432 NR2 $PINS O=n160 I1=A[0] I2=B[0]
XU433 NR2 $PINS O=n151 I1=A[3] I2=n220
XU434 NR2 $PINS O=n158 I1=A[1] I2=n222
XU435 NR2 $PINS O=n128 I1=A[7] I2=n216
XU436 NR2 $PINS O=n120 I1=A[9] I2=n214
XU437 OR2 $PINS O=n329 I1=A[4] I2=B[4]
XU438 INV1S $PINS O=n210 I=B[13]
XU439 INV1S $PINS O=n208 I=B[15]
XU440 INV1S $PINS O=n212 I=B[11]
XU441 INV1S $PINS O=n211 I=B[12]
XU442 INV1S $PINS O=n209 I=B[14]
XU443 INV1S $PINS O=n207 I=B[16]
XU444 NR2 $PINS O=n112 I1=A[11] I2=n212
XU445 NR2 $PINS O=n104 I1=A[13] I2=n210
XU446 NR2 $PINS O=n96 I1=A[15] I2=n208
XU447 XNR2HS $PINS O=DIFF[0] I1=A[0] I2=B[0]
XU448 INV1S $PINS O=n206 I=B[17]
XU449 INV1S $PINS O=n204 I=B[19]
XU450 INV1S $PINS O=n202 I=B[21]
XU451 INV1S $PINS O=n205 I=B[18]
XU452 INV1S $PINS O=n203 I=B[20]
XU453 INV1S $PINS O=n201 I=B[22]
XU454 NR2 $PINS O=n88 I1=A[17] I2=n206
XU455 NR2 $PINS O=n80 I1=A[19] I2=n204
XU456 NR2 $PINS O=n72 I1=A[21] I2=n202
XU457 INV1S $PINS O=n194 I=B[29]
XU458 INV1S $PINS O=n200 I=B[23]
XU459 INV1S $PINS O=n198 I=B[25]
XU460 INV1S $PINS O=n196 I=B[27]
XU461 INV1S $PINS O=n199 I=B[24]
XU462 INV1S $PINS O=n197 I=B[26]
XU463 INV1S $PINS O=n195 I=B[28]
XU464 INV1S $PINS O=n193 I=B[30]
XU465 NR2 $PINS O=n64 I1=A[23] I2=n200
XU466 NR2 $PINS O=n56 I1=A[25] I2=n198
XU467 NR2 $PINS O=n48 I1=A[27] I2=n196
XU468 NR2 $PINS O=n40 I1=A[29] I2=n194
XU469 INV1S $PINS O=n192 I=B[31]
XU471 INV1S $PINS O=n216 I=B[7]
XU472 INV1S $PINS O=n214 I=B[9]
XU473 INV1S $PINS O=n222 I=B[1]
.ENDS

.SUBCKT sub_DW01_add_2 A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24] A[23]
+ A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12] A[11] A[10]
+ A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30] B[29] B[28]
+ B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15]
+ B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1]
+ B[0] CI SUM[31] SUM[30] SUM[29] SUM[28] SUM[27] SUM[26] SUM[25] SUM[24]
+ SUM[23] SUM[22] SUM[21] SUM[20] SUM[19] SUM[18] SUM[17] SUM[16] SUM[15]
+ SUM[14] SUM[13] SUM[12] SUM[11] SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5]
+ SUM[4] SUM[3] SUM[2] SUM[1] SUM[0] CO FE_OFN218_FE_OFN49_raw_prime_13
XFE_OFC208_n105 INV1S $PINS O=FE_OFN100_n105 I=n104
XFE_OFC207_n105 INV1S $PINS O=n104 I=n105
XU257 OR2S $PINS O=n324 I1=A[16] I2=B[16]
XU258 OR2 $PINS O=n325 I1=A[19] I2=B[19]
XU259 OR2 $PINS O=n326 I1=A[17] I2=B[17]
XU260 OR2S $PINS O=n327 I1=A[20] I2=B[20]
XU261 OR2S $PINS O=n328 I1=A[22] I2=B[22]
XU262 OR2S $PINS O=n329 I1=A[24] I2=B[24]
XU263 OR2S $PINS O=n330 I1=A[28] I2=B[28]
XU264 OR2S $PINS O=n331 I1=A[26] I2=B[26]
XU265 OR2 $PINS O=n332 I1=A[30] I2=B[30]
XU266 AN2 $PINS O=SUM[0] I1=n342 I2=n189
XU267 INV1S $PINS O=n154 I=n155
XU268 XNR2HS $PINS O=SUM[15] I1=n17 I2=n334
XU269 AO12 $PINS O=n334 A1=n116 B1=n119 B2=n207
XU270 XNR2HS $PINS O=SUM[13] I1=n19 I2=n335
XU271 AO12S $PINS O=n335 A1=n128 B1=n132 B2=n209
XU272 XNR2HS $PINS O=SUM[5] I1=n27 I2=n336
XU273 AO12 $PINS O=n336 A1=n172 B1=n175 B2=n217
XU274 XOR2HS $PINS O=SUM[9] I1=n23 I2=n337
XU275 OA12S $PINS O=n337 A1=n153 B1=n154 B2=n152
XU276 XOR2HS $PINS O=SUM[7] I1=n25 I2=n338
XU277 OA12S $PINS O=n338 A1=n164 B1=n165 B2=n163
XU278 XOR2HS $PINS O=SUM[3] I1=n29 I2=n339
XU279 OA12S $PINS O=n339 A1=n183 B1=n184 B2=n182
XU280 ND2S $PINS O=n183 I1=B[2] I2=A[2]
XU281 ND2S $PINS O=n189 I1=B[0] I2=A[0]
XU282 ND2S $PINS O=n164 I1=B[6] I2=A[6]
XU283 ND2S $PINS O=n153 I1=B[8] I2=A[8]
XU284 ND2S $PINS O=n130 I1=B[12] I2=A[12]
XU285 ND2S $PINS O=n118 I1=B[14] I2=A[14]
XU286 ND2S $PINS O=n174 I1=B[4] I2=A[4]
XU287 ND2S $PINS O=n143 I1=B[10] I2=A[10]
XU288 ND2S $PINS O=n187 I1=B[1] I2=A[1]
XU289 ND2S $PINS O=n89 I1=B[18] I2=A[18]
XU290 ND2S $PINS O=n125 I1=B[13] I2=FE_OFN218_FE_OFN49_raw_prime_13
XU291 ND2S $PINS O=n138 I1=B[11] I2=A[11]
XU292 ND2S $PINS O=n150 I1=B[9] I2=A[9]
XU293 ND2S $PINS O=n113 I1=B[15] I2=A[15]
XU294 ND2S $PINS O=n161 I1=B[7] I2=A[7]
XU295 ND2S $PINS O=n180 I1=B[3] I2=A[3]
XU296 ND2S $PINS O=n169 I1=B[5] I2=A[5]
XU297 ND2S $PINS O=n103 I1=B[16] I2=A[16]
XU298 ND2S $PINS O=n98 I1=B[17] I2=A[17]
XU299 XOR2HS $PINS O=SUM[31] I1=n340 I2=n341
XU300 XOR2HS $PINS O=n340 I1=A[31] I2=B[31]
XU301 AO12 $PINS O=n341 A1=n35 B1=n38 B2=n332
XU302 OR2S $PINS O=n342 I1=A[0] I2=B[0]
XU303 ND2S $PINS O=n72 I1=B[21] I2=A[21]
XU304 ND2S $PINS O=n77 I1=B[20] I2=A[20]
XU305 ND2S $PINS O=n69 I1=B[22] I2=A[22]
XU306 ND2S $PINS O=n84 I1=B[19] I2=A[19]
XU307 ND2S $PINS O=n64 I1=B[23] I2=A[23]
XU308 ND2S $PINS O=n56 I1=B[25] I2=A[25]
XU309 ND2S $PINS O=n48 I1=B[27] I2=A[27]
XU310 ND2S $PINS O=n45 I1=B[28] I2=A[28]
XU311 ND2S $PINS O=n61 I1=B[24] I2=A[24]
XU312 ND2S $PINS O=n53 I1=B[26] I2=A[26]
XU313 ND2S $PINS O=n40 I1=B[29] I2=A[29]
XU314 ND2S $PINS O=n37 I1=B[30] I2=A[30]
XU316 INV1S $PINS O=n131 I=n132
XU317 INV1S $PINS O=n91 I=n93
XU318 OAI12HS $PINS O=n144 A1=n146 B1=n154 B2=n145
XU319 INV1S $PINS O=n146 I=n148
XU320 INV1S $PINS O=n145 I=n147
XU321 OAI12HS $PINS O=n119 A1=n121 B1=n131 B2=n120
XU322 INV1S $PINS O=n121 I=n123
XU323 INV1S $PINS O=n120 I=n122
XU324 AOI12HS $PINS O=n165 A1=n167 B1=n175 B2=n166
XU325 OAI12HS $PINS O=n132 A1=n134 B1=n154 B2=n133
XU326 AOI12HS $PINS O=n105 A1=n107 B1=n155 B2=n106
XU327 OAI12HS $PINS O=n107 A1=n109 B1=n134 B2=n108
XU328 NR2 $PINS O=n106 I1=n108 I2=n133
XU329 AOI12HS $PINS O=n109 A1=n111 B1=n110 B2=n123
XU330 ND2 $PINS O=n108 I1=n122 I2=n110
XU331 ND2 $PINS O=n133 I1=n147 I2=n135
XU332 ND2 $PINS O=n93 I1=n324 I2=n326
XU333 INV1S $PINS O=n175 I=n176
XU334 INV1S $PINS O=n184 I=n185
XU335 INV1S $PINS O=n92 I=n94
XU336 OAI12HS $PINS O=n148 A1=n150 B1=n149 B2=n153
XU337 OAI12HS $PINS O=n123 A1=n125 B1=n124 B2=n130
XU338 OAI12HS $PINS O=n70 A1=n72 B1=n73 B2=n71
XU339 OAI12HS $PINS O=n62 A1=n64 B1=n65 B2=n63
XU340 OAI12HS $PINS O=n54 A1=n56 B1=n57 B2=n55
XU341 OAI12HS $PINS O=n46 A1=n48 B1=n49 B2=n47
XU342 OAI12HS $PINS O=n38 A1=n40 B1=n41 B2=n39
XU343 OAI12HS $PINS O=n167 A1=n169 B1=n168 B2=n174
XU344 OAI12HS $PINS O=n185 A1=n187 B1=n186 B2=n189
XU345 XOR2HS $PINS O=SUM[1] I1=n189 I2=n31
XU346 ND2 $PINS O=n31 I1=n220 I2=n187
XU347 INV1S $PINS O=n220 I=n186
XU348 OAI12HS $PINS O=n87 A1=n89 B1=n94 B2=n88
XU349 OAI12HS $PINS O=n78 A1=n80 B1=FE_OFN100_n105 B2=n79
XU350 AOI12HS $PINS O=n80 A1=n82 B1=n87 B2=n325
XU351 ND2 $PINS O=n79 I1=n86 I2=n325
XU352 INV1S $PINS O=n82 I=n84
XU353 NR2 $PINS O=n166 I1=n168 I2=n173
XU354 NR2 $PINS O=n110 I1=n112 I2=n117
XU355 NR2 $PINS O=n158 I1=n160 I2=n163
XU356 NR2 $PINS O=n135 I1=n137 I2=n142
XU357 NR2 $PINS O=n122 I1=n124 I2=n129
XU358 NR2 $PINS O=n147 I1=n149 I2=n152
XU359 AOI12HS $PINS O=n41 A1=n43 B1=n46 B2=n330
XU360 INV1S $PINS O=n43 I=n45
XU361 AOI12HS $PINS O=n73 A1=n75 B1=n78 B2=n327
XU362 INV1S $PINS O=n75 I=n77
XU363 AOI12HS $PINS O=n65 A1=n67 B1=n70 B2=n328
XU364 INV1S $PINS O=n67 I=n69
XU365 AOI12HS $PINS O=n57 A1=n59 B1=n62 B2=n329
XU366 INV1S $PINS O=n59 I=n61
XU367 AOI12HS $PINS O=n49 A1=n51 B1=n54 B2=n331
XU368 INV1S $PINS O=n51 I=n53
XU369 NR2 $PINS O=n86 I1=n88 I2=n93
XU370 OAI12HS $PINS O=n155 A1=n157 B1=n176 B2=n156
XU371 AOI12HS $PINS O=n157 A1=n159 B1=n158 B2=n167
XU372 ND2 $PINS O=n156 I1=n166 I2=n158
XU373 OAI12HS $PINS O=n159 A1=n161 B1=n160 B2=n164
XU374 ND2 $PINS O=n29 I1=n218 I2=n180
XU375 INV1S $PINS O=n218 I=n179
XU376 ND2 $PINS O=n25 I1=n214 I2=n161
XU377 INV1S $PINS O=n214 I=n160
XU378 ND2 $PINS O=n23 I1=n212 I2=n150
XU379 INV1S $PINS O=n212 I=n149
XU380 XOR2HS $PINS O=SUM[2] I1=n30 I2=n184
XU381 ND2 $PINS O=n30 I1=n219 I2=n183
XU382 INV1S $PINS O=n219 I=n182
XU383 XOR2HS $PINS O=SUM[12] I1=n20 I2=n131
XU384 ND2 $PINS O=n20 I1=n209 I2=n130
XU385 INV1S $PINS O=n209 I=n129
XU386 XOR2HS $PINS O=SUM[6] I1=n26 I2=n165
XU387 ND2 $PINS O=n26 I1=n215 I2=n164
XU388 INV1S $PINS O=n215 I=n163
XU389 XOR2HS $PINS O=SUM[8] I1=n24 I2=n154
XU390 ND2 $PINS O=n24 I1=n213 I2=n153
XU391 INV1S $PINS O=n213 I=n152
XU392 XNR2HS $PINS O=SUM[14] I1=n18 I2=n119
XU393 ND2 $PINS O=n18 I1=n207 I2=n118
XU394 INV1S $PINS O=n207 I=n117
XU395 XNR2HS $PINS O=SUM[4] I1=n28 I2=n175
XU396 ND2 $PINS O=n28 I1=n217 I2=n174
XU397 INV1S $PINS O=n217 I=n173
XU398 XNR2HS $PINS O=SUM[10] I1=n22 I2=n144
XU399 ND2 $PINS O=n22 I1=n140 I2=n143
XU400 AOI12HS $PINS O=n134 A1=n136 B1=n135 B2=n148
XU401 OAI12HS $PINS O=n136 A1=n138 B1=n137 B2=n143
XU402 XOR2HS $PINS O=SUM[18] I1=n14 I2=n90
XU403 ND2 $PINS O=n14 I1=n203 I2=n89
XU404 AOI12HS $PINS O=n90 A1=n92 B1=n104 B2=n91
XU405 INV1S $PINS O=n203 I=n88
XU406 ND2 $PINS O=n19 I1=n208 I2=n125
XU407 INV1S $PINS O=n208 I=n124
XU408 XOR2HS $PINS O=SUM[11] I1=n21 I2=n139
XU409 ND2 $PINS O=n21 I1=n210 I2=n138
XU410 AOI12HS $PINS O=n139 A1=n141 B1=n144 B2=n140
XU411 INV1S $PINS O=n210 I=n137
XU412 ND2 $PINS O=n17 I1=n206 I2=n113
XU413 INV1S $PINS O=n206 I=n112
XU414 XOR2HS $PINS O=SUM[21] I1=n11 I2=n73
XU415 ND2 $PINS O=n11 I1=n200 I2=n72
XU416 INV1S $PINS O=n200 I=n71
XU417 ND2 $PINS O=n27 I1=n216 I2=n169
XU418 INV1S $PINS O=n216 I=n168
XU419 XOR2HS $PINS O=SUM[23] I1=n9 I2=n65
XU420 ND2 $PINS O=n9 I1=n198 I2=n64
XU421 INV1S $PINS O=n198 I=n63
XU422 XOR2HS $PINS O=SUM[25] I1=n7 I2=n57
XU423 ND2 $PINS O=n7 I1=n196 I2=n56
XU424 INV1S $PINS O=n196 I=n55
XU425 XOR2HS $PINS O=SUM[27] I1=n5 I2=n49
XU426 ND2 $PINS O=n5 I1=n194 I2=n48
XU427 INV1S $PINS O=n194 I=n47
XU428 XOR2HS $PINS O=SUM[29] I1=n3 I2=n41
XU429 ND2 $PINS O=n3 I1=n192 I2=n40
XU430 INV1S $PINS O=n192 I=n39
XU431 XOR2HS $PINS O=SUM[17] I1=n15 I2=n99
XU432 ND2 $PINS O=n15 I1=n326 I2=n98
XU433 AOI12HS $PINS O=n99 A1=n101 B1=n104 B2=n324
XU434 XOR2HS $PINS O=SUM[19] I1=n13 I2=n85
XU435 ND2 $PINS O=n13 I1=n325 I2=n84
XU436 AOI12HS $PINS O=n85 A1=n87 B1=n104 B2=n86
XU437 XNR2HS $PINS O=SUM[30] I1=n2 I2=n38
XU438 ND2 $PINS O=n2 I1=n332 I2=n37
XU439 XNR2HS $PINS O=SUM[16] I1=n16 I2=n104
XU440 ND2 $PINS O=n16 I1=n324 I2=n103
XU441 XNR2HS $PINS O=SUM[28] I1=n4 I2=n46
XU442 ND2 $PINS O=n4 I1=n330 I2=n45
XU443 XNR2HS $PINS O=SUM[20] I1=n12 I2=n78
XU444 ND2 $PINS O=n12 I1=n327 I2=n77
XU445 XNR2HS $PINS O=SUM[22] I1=n10 I2=n70
XU446 ND2 $PINS O=n10 I1=n328 I2=n69
XU447 XNR2HS $PINS O=SUM[24] I1=n8 I2=n62
XU448 ND2 $PINS O=n8 I1=n329 I2=n61
XU449 XNR2HS $PINS O=SUM[26] I1=n6 I2=n54
XU450 ND2 $PINS O=n6 I1=n331 I2=n53
XU451 AOI12HS $PINS O=n176 A1=n178 B1=n177 B2=n185
XU452 OAI12HS $PINS O=n178 A1=n180 B1=n179 B2=n183
XU453 NR2 $PINS O=n177 I1=n179 I2=n182
XU454 AOI12HS $PINS O=n94 A1=n96 B1=n326 B2=n101
XU455 INV1S $PINS O=n96 I=n98
XU456 OAI12HS $PINS O=n111 A1=n113 B1=n112 B2=n118
XU457 INV1S $PINS O=n101 I=n103
XU458 INV1S $PINS O=n140 I=n142
XU459 INV1S $PINS O=n172 I=n174
XU460 INV1S $PINS O=n116 I=n118
XU461 INV1S $PINS O=n128 I=n130
XU462 INV1S $PINS O=n141 I=n143
XU463 INV1S $PINS O=n35 I=n37
XU464 NR2 $PINS O=n88 I1=A[18] I2=B[18]
XU465 NR2 $PINS O=n182 I1=A[2] I2=B[2]
XU466 NR2 $PINS O=n163 I1=A[6] I2=B[6]
XU467 NR2 $PINS O=n152 I1=A[8] I2=B[8]
XU468 NR2 $PINS O=n179 I1=A[3] I2=B[3]
XU469 NR2 $PINS O=n124 I1=A[13] I2=B[13]
XU470 NR2 $PINS O=n137 I1=A[11] I2=B[11]
XU471 NR2 $PINS O=n149 I1=A[9] I2=B[9]
XU472 NR2 $PINS O=n112 I1=A[15] I2=B[15]
XU473 NR2 $PINS O=n168 I1=A[5] I2=B[5]
XU474 NR2 $PINS O=n160 I1=A[7] I2=B[7]
XU475 NR2 $PINS O=n117 I1=A[14] I2=B[14]
XU476 NR2 $PINS O=n129 I1=A[12] I2=B[12]
XU477 NR2 $PINS O=n173 I1=A[4] I2=B[4]
XU478 NR2 $PINS O=n142 I1=A[10] I2=B[10]
XU479 NR2 $PINS O=n186 I1=A[1] I2=B[1]
XU480 NR2 $PINS O=n71 I1=A[21] I2=B[21]
XU481 NR2 $PINS O=n63 I1=A[23] I2=B[23]
XU482 NR2 $PINS O=n55 I1=A[25] I2=B[25]
XU483 NR2 $PINS O=n47 I1=A[27] I2=B[27]
XU484 NR2 $PINS O=n39 I1=A[29] I2=B[29]
.ENDS

.SUBCKT sub_DW01_sub_4 A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24] A[23]
+ A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12] A[11] A[10]
+ A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30] B[29] B[28]
+ B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15]
+ B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1]
+ B[0] CI DIFF[31] DIFF[30] DIFF[29] DIFF[28] DIFF[27] DIFF[26] DIFF[25]
+ DIFF[24] DIFF[23] DIFF[22] DIFF[21] DIFF[20] DIFF[19] DIFF[18] DIFF[17]
+ DIFF[16] DIFF[15] DIFF[14] DIFF[13] DIFF[12] DIFF[11] DIFF[10] DIFF[9]
+ DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3] DIFF[2] DIFF[1] DIFF[0] CO
+ FE_OFN331_Py_mont_0 FE_OFN114_Py_mont_4
XU308 OR2 $PINS O=n375 I1=n255 I2=A[17]
XU309 OR2 $PINS O=n376 I1=n253 I2=A[19]
XU310 OR2 $PINS O=n377 I1=n251 I2=A[21]
XU311 OR2 $PINS O=n378 I1=n248 I2=A[24]
XU312 OR2 $PINS O=n379 I1=n246 I2=A[26]
XU313 OR2 $PINS O=n380 I1=n244 I2=A[28]
XU314 OR2 $PINS O=n381 I1=n242 I2=A[30]
XU315 ND2S $PINS O=n87 I1=n122 I2=n89
XU316 ND2S $PINS O=n135 I1=n137 I2=n142
XU317 ND2S $PINS O=n17 I1=n226 I2=n125
XU318 ND2S $PINS O=n130 I1=A[14] I2=n258
XU319 ND2S $PINS O=n145 I1=A[12] I2=n260
XU320 NR2 $PINS O=n89 I1=n107 I2=n91
XU321 INV1S $PINS O=n85 I=n86
XU322 INV1S $PINS O=n120 I=n121
XU323 ND2 $PINS O=n72 I1=n377 I2=n81
XU324 ND2 $PINS O=n107 I1=n375 I2=n116
XU325 ND2 $PINS O=n91 I1=n376 I2=n100
XU326 ND2 $PINS O=n147 I1=n149 I2=n156
XU327 OAI12HS $PINS O=n86 A1=n88 B1=n87 B2=n132
XU328 AOI12HS $PINS O=n88 A1=n90 B1=n123 B2=n89
XU329 OAI12HS $PINS O=n90 A1=n92 B1=n108 B2=n91
XU330 OAI12HS $PINS O=n146 A1=n148 B1=n160 B2=n147
XU331 AOI12HS $PINS O=n104 A1=n106 B1=n120 B2=n105
XU332 INV1S $PINS O=n105 I=n107
XU333 INV1S $PINS O=n106 I=n108
XU334 AOI12HS $PINS O=n121 A1=n123 B1=n131 B2=n122
XU335 OAI12HS $PINS O=n153 A1=n159 B1=n160 B2=n158
XU336 OAI12HS $PINS O=n78 A1=n84 B1=n85 B2=n83
XU337 OAI12HS $PINS O=n71 A1=n73 B1=n85 B2=n72
XU338 OAI12HS $PINS O=n113 A1=n119 B1=n121 B2=n118
XU339 OAI12HS $PINS O=n97 A1=n103 B1=n104 B2=n102
XU340 AOI12HS $PINS O=n141 A1=n143 B1=n146 B2=n142
XU341 INV1S $PINS O=n131 I=n132
XU342 XOR2HS $PINS O=DIFF[25] I1=n7 I2=n58
XU343 ND2 $PINS O=n7 I1=n216 I2=n57
XU344 XOR2HS $PINS O=DIFF[29] I1=n3 I2=n42
XU345 ND2 $PINS O=n3 I1=n212 I2=n41
XU346 XOR2HS $PINS O=DIFF[27] I1=n5 I2=n50
XU347 ND2 $PINS O=n5 I1=n214 I2=n49
XU348 XNR2HS $PINS O=DIFF[30] I1=n2 I2=n39
XU349 ND2 $PINS O=n2 I1=n381 I2=n38
XU350 XNR2HS $PINS O=DIFF[24] I1=n8 I2=n63
XU351 ND2 $PINS O=n8 I1=n378 I2=n62
XU352 XNR2HS $PINS O=DIFF[26] I1=n6 I2=n55
XU353 ND2 $PINS O=n6 I1=n379 I2=n54
XU354 XNR2HS $PINS O=DIFF[28] I1=n4 I2=n47
XU355 ND2 $PINS O=n4 I1=n380 I2=n46
XU356 OAI12HS $PINS O=n47 A1=n49 B1=n50 B2=n48
XU357 OAI12HS $PINS O=n39 A1=n41 B1=n42 B2=n40
XU358 OAI12HS $PINS O=n55 A1=n57 B1=n58 B2=n56
XU359 OAI12HS $PINS O=n63 A1=n65 B1=n66 B2=n64
XU360 AOI12HS $PINS O=n66 A1=n68 B1=n86 B2=n67
XU361 NR2 $PINS O=n67 I1=n72 I2=n69
XU362 OAI12HS $PINS O=n68 A1=n70 B1=n69 B2=n73
XU363 AOI12HS $PINS O=n58 A1=n60 B1=n63 B2=n378
XU364 INV1S $PINS O=n60 I=n62
XU365 AOI12HS $PINS O=n50 A1=n52 B1=n55 B2=n379
XU366 INV1S $PINS O=n52 I=n54
XU367 AOI12HS $PINS O=n42 A1=n44 B1=n47 B2=n380
XU368 INV1S $PINS O=n44 I=n46
XU369 OAI12HS $PINS O=n123 A1=n125 B1=n124 B2=n130
XU370 AOI12HS $PINS O=n73 A1=n75 B1=n377 B2=n82
XU371 INV1S $PINS O=n75 I=n77
XU372 AOI12HS $PINS O=n148 A1=n150 B1=n149 B2=n157
XU373 INV1S $PINS O=n150 I=n152
XU374 AOI12HS $PINS O=n108 A1=n110 B1=n375 B2=n117
XU375 INV1S $PINS O=n110 I=n112
XU376 NR2 $PINS O=n122 I1=n129 I2=n124
XU377 AOI12HS $PINS O=n34 A1=n36 B1=n39 B2=n381
XU378 INV1S $PINS O=n36 I=n38
XU379 AOI12HS $PINS O=n132 A1=n134 B1=n133 B2=n161
XU380 NR2 $PINS O=n133 I1=n135 I2=n147
XU381 OAI12HS $PINS O=n134 A1=n136 B1=n148 B2=n135
XU382 XNR2HS $PINS O=DIFF[19] I1=n13 I2=n97
XU383 ND2 $PINS O=n13 I1=n376 I2=n96
XU384 XNR2HS $PINS O=DIFF[21] I1=n11 I2=n78
XU385 ND2 $PINS O=n11 I1=n377 I2=n77
XU386 XOR2HS $PINS O=DIFF[23] I1=n9 I2=n66
XU387 ND2 $PINS O=n9 I1=n218 I2=n65
XU388 AOI12HS $PINS O=n92 A1=n94 B1=n376 B2=n101
XU389 INV1S $PINS O=n94 I=n96
XU390 AOI12HS $PINS O=n136 A1=n138 B1=n137 B2=n143
XU391 INV1S $PINS O=n138 I=n140
XU392 INV1S $PINS O=n157 I=n159
XU393 INV1S $PINS O=n101 I=n103
XU394 INV1S $PINS O=n117 I=n119
XU395 INV1S $PINS O=n82 I=n84
XU396 INV1S $PINS O=n143 I=n145
XU397 INV1S $PINS O=n142 I=n144
XU398 INV1S $PINS O=n116 I=n118
XU399 INV1S $PINS O=n100 I=n102
XU400 INV1S $PINS O=n156 I=n158
XU401 INV1S $PINS O=n81 I=n83
XU402 INV1S $PINS O=n137 I=n139
XU403 INV1S $PINS O=n149 I=n151
XU404 XNR2HS $PINS O=DIFF[14] I1=n18 I2=n131
XU405 ND2 $PINS O=n18 I1=n127 I2=n130
XU406 XOR2HS $PINS O=DIFF[15] I1=n17 I2=n126
XU407 XOR2HS $PINS O=DIFF[20] I1=n12 I2=n85
XU408 ND2 $PINS O=n12 I1=n81 I2=n84
XU409 XNR2HS $PINS O=DIFF[17] I1=n15 I2=n113
XU410 ND2 $PINS O=n15 I1=n375 I2=n112
XU411 XOR2HS $PINS O=DIFF[18] I1=n14 I2=n104
XU412 ND2 $PINS O=n14 I1=n100 I2=n103
XU413 XNR2HS $PINS O=DIFF[16] I1=n16 I2=n120
XU414 ND2 $PINS O=n16 I1=n116 I2=n119
XU415 XNR2HS $PINS O=DIFF[22] I1=n10 I2=n71
XU416 ND2 $PINS O=n10 I1=n219 I2=n70
XU417 INV1S $PINS O=n212 I=n40
XU418 AOI12HS $PINS O=n168 A1=n170 B1=n178 B2=n169
XU419 AOI12HS $PINS O=n126 A1=n128 B1=n131 B2=n127
XU420 INV1S $PINS O=n128 I=n130
XU421 INV1S $PINS O=n127 I=n129
XU422 INV1S $PINS O=n178 I=n179
XU423 INV1S $PINS O=n160 I=n161
XU424 INV1S $PINS O=n226 I=n124
XU425 INV1S $PINS O=n219 I=n69
XU426 INV1S $PINS O=n218 I=n64
XU427 INV1S $PINS O=n216 I=n56
XU428 INV1S $PINS O=n214 I=n48
XU429 AOI12HS $PINS O=n195 A1=n197 B1=n200 B2=n196
XU430 INV1S $PINS O=n187 I=n188
XU431 INV1S $PINS O=n200 I=n201
XU432 OR2B1S $PINS O=n19 I1=n139 B1=n140
XU433 OR2B1S $PINS O=n21 I1=n151 B1=n152
XU434 OR2B1S $PINS O=n22 I1=n158 B1=n159
XU435 OR2B1S $PINS O=n20 I1=n144 B1=n145
XU436 XOR2HS $PINS O=DIFF[31] I1=n1 I2=n34
XU437 ND2 $PINS O=n1 I1=n382 I2=n33
XU438 NR2 $PINS O=n129 I1=n258 I2=A[14]
XU439 NR2 $PINS O=n124 I1=n257 I2=A[15]
XU440 NR2 $PINS O=n69 I1=n250 I2=A[22]
XU441 NR2 $PINS O=n40 I1=n243 I2=A[29]
XU442 NR2 $PINS O=n64 I1=n249 I2=A[23]
XU443 NR2 $PINS O=n56 I1=n247 I2=A[25]
XU444 NR2 $PINS O=n48 I1=n245 I2=A[27]
XU445 NR2 $PINS O=n139 I1=n259 I2=A[13]
XU446 NR2 $PINS O=n151 I1=n261 I2=A[11]
XU447 NR2 $PINS O=n118 I1=n256 I2=A[16]
XU448 NR2 $PINS O=n102 I1=n254 I2=A[18]
XU449 NR2 $PINS O=n144 I1=n260 I2=A[12]
XU450 NR2 $PINS O=n158 I1=n262 I2=A[10]
XU451 NR2 $PINS O=n83 I1=n252 I2=A[20]
XU452 OAI12HS $PINS O=n206 A1=n208 B1=n207 B2=n209
XU453 OAI12HS $PINS O=n170 A1=n172 B1=n177 B2=n171
XU454 AOI12HS $PINS O=n179 A1=n181 B1=n180 B2=n188
XU455 NR2 $PINS O=n180 I1=n185 I2=n182
XU456 OAI12HS $PINS O=n181 A1=n183 B1=n182 B2=n186
XU457 AOI12HS $PINS O=n201 A1=n203 B1=n206 B2=n202
XU458 INV1S $PINS O=n203 I=n205
XU459 INV1S $PINS O=n202 I=n204
XU460 NR2 $PINS O=n169 I1=n171 I2=n176
XU461 ND2 $PINS O=n41 I1=A[29] I2=n243
XU462 ND2 $PINS O=n125 I1=A[15] I2=n257
XU463 ND2 $PINS O=n65 I1=A[23] I2=n249
XU464 ND2 $PINS O=n57 I1=A[25] I2=n247
XU465 ND2 $PINS O=n49 I1=A[27] I2=n245
XU466 ND2 $PINS O=n70 I1=A[22] I2=n250
XU467 ND2 $PINS O=n140 I1=A[13] I2=n259
XU468 ND2 $PINS O=n112 I1=A[17] I2=n255
XU469 ND2 $PINS O=n152 I1=A[11] I2=n261
XU470 ND2 $PINS O=n96 I1=A[19] I2=n253
XU471 ND2 $PINS O=n77 I1=A[21] I2=n251
XU472 ND2 $PINS O=n159 I1=A[10] I2=n262
XU473 ND2 $PINS O=n119 I1=A[16] I2=n256
XU474 ND2 $PINS O=n103 I1=A[18] I2=n254
XU475 ND2 $PINS O=n84 I1=A[20] I2=n252
XU476 ND2 $PINS O=n62 I1=A[24] I2=n248
XU477 ND2 $PINS O=n54 I1=A[26] I2=n246
XU478 ND2 $PINS O=n46 I1=A[28] I2=n244
XU479 ND2 $PINS O=n38 I1=A[30] I2=n242
XU480 OAI12HS $PINS O=n161 A1=n163 B1=n162 B2=n179
XU481 AOI12HS $PINS O=n163 A1=n165 B1=n170 B2=n164
XU482 ND2 $PINS O=n162 I1=n169 I2=n164
XU483 INV1S $PINS O=n165 I=n167
XU484 OAI12HS $PINS O=n188 A1=n190 B1=n189 B2=n201
XU485 AOI12HS $PINS O=n190 A1=n192 B1=n191 B2=n197
XU486 ND2 $PINS O=n189 I1=n196 I2=n191
XU487 INV1S $PINS O=n192 I=n194
XU488 INV1S $PINS O=n197 I=n199
XU489 INV1S $PINS O=n164 I=n166
XU490 INV1S $PINS O=n196 I=n198
XU491 INV1S $PINS O=n191 I=n193
XU492 XOR2HS $PINS O=DIFF[1] I1=n209 I2=n31
XU493 XNR2HS $PINS O=DIFF[2] I1=n206 I2=n30
XU494 XOR2HS $PINS O=DIFF[5] I1=n27 I2=n187
XU495 XNR2HS $PINS O=DIFF[7] I1=n25 I2=n178
XU496 XNR2HS $PINS O=DIFF[3] I1=n200 I2=n29
XU497 XOR2HS $PINS O=DIFF[4] I1=n28 I2=n195
XU498 XOR2HS $PINS O=DIFF[8] I1=n24 I2=n173
XU499 XNR2HS $PINS O=DIFF[6] I1=n26 I2=n184
XU500 XOR2HS $PINS O=DIFF[9] I1=n23 I2=n168
XU501 XOR2HS $PINS O=DIFF[10] I1=n22 I2=n160
XU502 XOR2HS $PINS O=DIFF[13] I1=n19 I2=n141
XU503 XNR2HS $PINS O=DIFF[11] I1=n21 I2=n153
XU504 XNR2HS $PINS O=DIFF[12] I1=n20 I2=n146
XU505 AOI12HS $PINS O=n173 A1=n175 B1=n178 B2=n174
XU506 INV1S $PINS O=n175 I=n177
XU507 INV1S $PINS O=n174 I=n176
XU508 OAI12HS $PINS O=n184 A1=n186 B1=n187 B2=n185
XU509 OR2B1S $PINS O=n27 I1=n185 B1=n186
XU510 OR2B1S $PINS O=n24 I1=n171 B1=n172
XU511 OR2B1S $PINS O=n25 I1=n176 B1=n177
XU512 OR2B1S $PINS O=n26 I1=n182 B1=n183
XU513 OR2B1S $PINS O=n29 I1=n198 B1=n199
XU514 OR2B1S $PINS O=n23 I1=n166 B1=n167
XU515 OR2B1S $PINS O=n30 I1=n204 B1=n205
XU516 OR2B1S $PINS O=n28 I1=n193 B1=n194
XU517 OR2B1S $PINS O=n31 I1=n207 B1=n208
XU518 NR2 $PINS O=n185 I1=n267 I2=A[5]
XU519 NR2 $PINS O=n171 I1=n264 I2=A[8]
XU520 NR2 $PINS O=n176 I1=n265 I2=A[7]
XU521 NR2 $PINS O=n182 I1=n266 I2=A[6]
XU522 NR2 $PINS O=n198 I1=n269 I2=A[3]
XU523 NR2 $PINS O=n166 I1=n263 I2=A[9]
XU524 NR2 $PINS O=n193 I1=n268 I2=A[4]
XU525 NR2 $PINS O=n204 I1=n270 I2=A[2]
XU526 NR2 $PINS O=n207 I1=n271 I2=A[1]
XU527 ND2 $PINS O=n186 I1=A[5] I2=n267
XU528 ND2 $PINS O=n177 I1=A[7] I2=n265
XU529 NR2 $PINS O=n209 I1=n272 I2=A[0]
XU530 ND2 $PINS O=n172 I1=A[8] I2=n264
XU531 ND2 $PINS O=n183 I1=A[6] I2=n266
XU532 ND2 $PINS O=n208 I1=A[1] I2=n271
XU533 ND2 $PINS O=n199 I1=A[3] I2=n269
XU534 ND2 $PINS O=n167 I1=A[9] I2=n263
XU535 ND2 $PINS O=n194 I1=A[4] I2=n268
XU536 ND2 $PINS O=n205 I1=A[2] I2=n270
XU537 ND2 $PINS O=n33 I1=A[31] I2=n241
XU538 XNR2HS $PINS O=DIFF[0] I1=n272 I2=A[0]
XU539 OR2 $PINS O=n382 I1=n241 I2=A[31]
XU540 INV1S $PINS O=n255 I=B[17]
XU541 INV1S $PINS O=n259 I=B[13]
XU542 INV1S $PINS O=n257 I=B[15]
XU543 INV1S $PINS O=n253 I=B[19]
XU544 INV1S $PINS O=n261 I=B[11]
XU545 INV1S $PINS O=n251 I=B[21]
XU546 INV1S $PINS O=n256 I=B[16]
XU547 INV1S $PINS O=n254 I=B[18]
XU548 INV1S $PINS O=n260 I=B[12]
XU549 INV1S $PINS O=n262 I=B[10]
XU550 INV1S $PINS O=n252 I=B[20]
XU551 INV1S $PINS O=n258 I=B[14]
XU552 INV1S $PINS O=n250 I=B[22]
XU553 INV1S $PINS O=n249 I=B[23]
XU554 INV1S $PINS O=n247 I=B[25]
XU555 INV1S $PINS O=n245 I=B[27]
XU556 INV1S $PINS O=n248 I=B[24]
XU557 INV1S $PINS O=n246 I=B[26]
XU558 INV1S $PINS O=n244 I=B[28]
XU559 INV1S $PINS O=n243 I=B[29]
XU560 INV1S $PINS O=n242 I=B[30]
XU561 INV1S $PINS O=n241 I=B[31]
XU562 INV1S $PINS O=n272 I=FE_OFN331_Py_mont_0
XU563 INV1S $PINS O=n269 I=B[3]
XU564 INV1S $PINS O=n263 I=B[9]
XU565 INV1S $PINS O=n267 I=B[5]
XU566 INV1S $PINS O=n265 I=B[7]
XU567 INV1S $PINS O=n268 I=FE_OFN114_Py_mont_4
XU568 INV1S $PINS O=n270 I=B[2]
XU569 INV1S $PINS O=n264 I=B[8]
XU570 INV1S $PINS O=n266 I=B[6]
XU571 INV1S $PINS O=n271 I=B[1]
.ENDS

.SUBCKT sub i_rst sub_in_0[31] sub_in_0[30] sub_in_0[29] sub_in_0[28]
+ sub_in_0[27] sub_in_0[26] sub_in_0[25] sub_in_0[24] sub_in_0[23] sub_in_0[22]
+ sub_in_0[21] sub_in_0[20] sub_in_0[19] sub_in_0[18] sub_in_0[17] sub_in_0[16]
+ sub_in_0[15] sub_in_0[14] sub_in_0[13] sub_in_0[12] sub_in_0[11] sub_in_0[10]
+ sub_in_0[9] sub_in_0[8] sub_in_0[7] sub_in_0[6] sub_in_0[5] sub_in_0[4]
+ sub_in_0[3] sub_in_0[2] sub_in_0[1] sub_in_0[0] sub_in_1[31] sub_in_1[30]
+ sub_in_1[29] sub_in_1[28] sub_in_1[27] sub_in_1[26] sub_in_1[25] sub_in_1[24]
+ sub_in_1[23] sub_in_1[22] sub_in_1[21] sub_in_1[20] sub_in_1[19] sub_in_1[18]
+ sub_in_1[17] sub_in_1[16] sub_in_1[15] sub_in_1[14] sub_in_1[13] sub_in_1[12]
+ sub_in_1[11] sub_in_1[10] sub_in_1[9] sub_in_1[8] sub_in_1[7] sub_in_1[6]
+ sub_in_1[5] sub_in_1[4] sub_in_1[3] sub_in_1[2] sub_in_1[1] sub_in_1[0]
+ prime[31] prime[30] prime[29] prime[28] prime[27] prime[26] prime[25]
+ prime[24] prime[23] prime[22] prime[21] prime[20] prime[19] prime[18]
+ prime[17] prime[16] prime[15] prime[14] prime[13] prime[12] prime[11]
+ prime[10] prime[9] prime[8] prime[7] prime[6] prime[5] prime[4] prime[3]
+ prime[2] prime[1] prime[0] sel_sub sub_out[31] sub_out[30] sub_out[29]
+ sub_out[28] sub_out[27] sub_out[26] sub_out[25] sub_out[24] sub_out[23]
+ sub_out[22] sub_out[21] sub_out[20] sub_out[19] sub_out[18] sub_out[17]
+ sub_out[16] sub_out[15] sub_out[14] sub_out[13] sub_out[12] sub_out[11]
+ sub_out[10] sub_out[9] sub_out[8] sub_out[7] sub_out[6] sub_out[5] sub_out[4]
+ sub_out[3] sub_out[2] sub_out[1] sub_out[0] done_sub p1
+ FE_OFN18_FE_DBTN1_i_i_rst FE_OFN14_FE_DBTN1_i_i_rst FE_OFN10_FE_DBTN1_i_i_rst
+ FE_OFN155_Py_mont_4 FE_OFN331_Py_mont_0 FE_OFN114_Py_mont_4
+ FE_OFN217_FE_OFN49_raw_prime_13 FE_OFN293_FE_OFN7_FE_DBTN1_i_i_rst
+ FE_OFN295_FE_OFN6_FE_DBTN1_i_i_rst FE_OFN300_FE_OFN5_FE_DBTN1_i_i_rst
+ FE_OFN298_FE_OFN5_FE_DBTN1_i_i_rst i_clk_clone2 i_clk_clone1 i_clk
XFE_OFC523_n2 BUF1 $PINS O=FE_OFN556_n2 I=n2
XFE_OFC522_n1 BUF1 $PINS O=FE_OFN555_n1 I=n1
XFE_DBTC2_done_sub INV1S $PINS O=p1 I=done_sub
Xr317 sub_DW_cmp_0 $PINS A[31]=sub_in_0[31] A[30]=sub_in_0[30]
+ A[29]=sub_in_0[29] A[28]=sub_in_0[28] A[27]=sub_in_0[27] A[26]=sub_in_0[26]
+ A[25]=sub_in_0[25] A[24]=sub_in_0[24] A[23]=sub_in_0[23] A[22]=sub_in_0[22]
+ A[21]=sub_in_0[21] A[20]=sub_in_0[20] A[19]=sub_in_0[19] A[18]=sub_in_0[18]
+ A[17]=sub_in_0[17] A[16]=sub_in_0[16] A[15]=sub_in_0[15] A[14]=sub_in_0[14]
+ A[13]=sub_in_0[13] A[12]=sub_in_0[12] A[11]=sub_in_0[11] A[10]=sub_in_0[10]
+ A[9]=sub_in_0[9] A[8]=sub_in_0[8] A[7]=sub_in_0[7] A[6]=sub_in_0[6]
+ A[5]=sub_in_0[5] A[4]=sub_in_0[4] A[3]=sub_in_0[3] A[2]=sub_in_0[2]
+ A[1]=sub_in_0[1] A[0]=sub_in_0[0] B[31]=sub_in_1[31] B[30]=sub_in_1[30]
+ B[29]=sub_in_1[29] B[28]=sub_in_1[28] B[27]=sub_in_1[27] B[26]=sub_in_1[26]
+ B[25]=sub_in_1[25] B[24]=sub_in_1[24] B[23]=sub_in_1[23] B[22]=sub_in_1[22]
+ B[21]=sub_in_1[21] B[20]=sub_in_1[20] B[19]=sub_in_1[19] B[18]=sub_in_1[18]
+ B[17]=sub_in_1[17] B[16]=sub_in_1[16] B[15]=sub_in_1[15] B[14]=sub_in_1[14]
+ B[13]=sub_in_1[13] B[12]=sub_in_1[12] B[11]=sub_in_1[11] B[10]=sub_in_1[10]
+ B[9]=sub_in_1[9] B[8]=sub_in_1[8] B[7]=sub_in_1[7] B[6]=sub_in_1[6]
+ B[5]=sub_in_1[5] B[4]=sub_in_1[4] B[3]=sub_in_1[3] B[2]=sub_in_1[2]
+ B[1]=sub_in_1[1] B[0]=sub_in_1[0] TC=net25625 GE_LT=net25625 GE_GT_EQ=n3
+ GE_LT_GT_LE=N10 FE_OFN331_Py_mont_0=FE_OFN331_Py_mont_0
+ FE_OFN112_Py_mont_4=FE_OFN155_Py_mont_4
Xr318 sub_DW01_sub_3 $PINS A[31]=sub_in_0[31] A[30]=sub_in_0[30]
+ A[29]=sub_in_0[29] A[28]=sub_in_0[28] A[27]=sub_in_0[27] A[26]=sub_in_0[26]
+ A[25]=sub_in_0[25] A[24]=sub_in_0[24] A[23]=sub_in_0[23] A[22]=sub_in_0[22]
+ A[21]=sub_in_0[21] A[20]=sub_in_0[20] A[19]=sub_in_0[19] A[18]=sub_in_0[18]
+ A[17]=sub_in_0[17] A[16]=sub_in_0[16] A[15]=sub_in_0[15] A[14]=sub_in_0[14]
+ A[13]=sub_in_0[13] A[12]=sub_in_0[12] A[11]=sub_in_0[11] A[10]=sub_in_0[10]
+ A[9]=sub_in_0[9] A[8]=sub_in_0[8] A[7]=sub_in_0[7] A[6]=sub_in_0[6]
+ A[5]=sub_in_0[5] A[4]=sub_in_0[4] A[3]=sub_in_0[3] A[2]=sub_in_0[2]
+ A[1]=sub_in_0[1] A[0]=sub_in_0[0] B[31]=sub_in_1[31] B[30]=sub_in_1[30]
+ B[29]=sub_in_1[29] B[28]=sub_in_1[28] B[27]=sub_in_1[27] B[26]=sub_in_1[26]
+ B[25]=sub_in_1[25] B[24]=sub_in_1[24] B[23]=sub_in_1[23] B[22]=sub_in_1[22]
+ B[21]=sub_in_1[21] B[20]=sub_in_1[20] B[19]=sub_in_1[19] B[18]=sub_in_1[18]
+ B[17]=sub_in_1[17] B[16]=sub_in_1[16] B[15]=sub_in_1[15] B[14]=sub_in_1[14]
+ B[13]=sub_in_1[13] B[12]=sub_in_1[12] B[11]=sub_in_1[11] B[10]=sub_in_1[10]
+ B[9]=sub_in_1[9] B[8]=sub_in_1[8] B[7]=sub_in_1[7] B[6]=sub_in_1[6]
+ B[5]=sub_in_1[5] B[4]=FE_OFN155_Py_mont_4 B[3]=sub_in_1[3] B[2]=sub_in_1[2]
+ B[1]=sub_in_1[1] B[0]=sub_in_1[0] CI=net25625 DIFF[31]=N43 DIFF[30]=N42
+ DIFF[29]=N41 DIFF[28]=N40 DIFF[27]=N39 DIFF[26]=N38 DIFF[25]=N37 DIFF[24]=N36
+ DIFF[23]=N35 DIFF[22]=N34 DIFF[21]=N33 DIFF[20]=N32 DIFF[19]=N31 DIFF[18]=N30
+ DIFF[17]=N29 DIFF[16]=N28 DIFF[15]=N27 DIFF[14]=N26 DIFF[13]=N25 DIFF[12]=N24
+ DIFF[11]=N23 DIFF[10]=N22 DIFF[9]=N21 DIFF[8]=N20 DIFF[7]=N19 DIFF[6]=N18
+ DIFF[5]=N17 DIFF[4]=N16 DIFF[3]=N15 DIFF[2]=N14 DIFF[1]=N13 DIFF[0]=N12
Xadd_1_root_sub_0_root_sub_3176 sub_DW01_add_2 $PINS A[31]=prime[31]
+ A[30]=prime[30] A[29]=prime[29] A[28]=prime[28] A[27]=prime[27] A[26]=prime[26]
+ A[25]=prime[25] A[24]=prime[24] A[23]=prime[23] A[22]=prime[22] A[21]=prime[21]
+ A[20]=prime[20] A[19]=prime[19] A[18]=prime[18] A[17]=prime[17] A[16]=prime[16]
+ A[15]=prime[15] A[14]=prime[14] A[13]=prime[13] A[12]=prime[12] A[11]=prime[11]
+ A[10]=prime[10] A[9]=prime[9] A[8]=prime[8] A[7]=prime[7] A[6]=prime[6]
+ A[5]=prime[5] A[4]=prime[4] A[3]=prime[3] A[2]=prime[2] A[1]=prime[1]
+ A[0]=prime[0] B[31]=sub_in_0[31] B[30]=sub_in_0[30] B[29]=sub_in_0[29]
+ B[28]=sub_in_0[28] B[27]=sub_in_0[27] B[26]=sub_in_0[26] B[25]=sub_in_0[25]
+ B[24]=sub_in_0[24] B[23]=sub_in_0[23] B[22]=sub_in_0[22] B[21]=sub_in_0[21]
+ B[20]=sub_in_0[20] B[19]=sub_in_0[19] B[18]=sub_in_0[18] B[17]=sub_in_0[17]
+ B[16]=sub_in_0[16] B[15]=sub_in_0[15] B[14]=sub_in_0[14] B[13]=sub_in_0[13]
+ B[12]=sub_in_0[12] B[11]=sub_in_0[11] B[10]=sub_in_0[10] B[9]=sub_in_0[9]
+ B[8]=sub_in_0[8] B[7]=sub_in_0[7] B[6]=sub_in_0[6] B[5]=sub_in_0[5]
+ B[4]=sub_in_0[4] B[3]=sub_in_0[3] B[2]=sub_in_0[2] B[1]=sub_in_0[1]
+ B[0]=sub_in_0[0] CI=net25625 SUM[31]=restore_0[31] SUM[30]=restore_0[30]
+ SUM[29]=restore_0[29] SUM[28]=restore_0[28] SUM[27]=restore_0[27]
+ SUM[26]=restore_0[26] SUM[25]=restore_0[25] SUM[24]=restore_0[24]
+ SUM[23]=restore_0[23] SUM[22]=restore_0[22] SUM[21]=restore_0[21]
+ SUM[20]=restore_0[20] SUM[19]=restore_0[19] SUM[18]=restore_0[18]
+ SUM[17]=restore_0[17] SUM[16]=restore_0[16] SUM[15]=restore_0[15]
+ SUM[14]=restore_0[14] SUM[13]=restore_0[13] SUM[12]=restore_0[12]
+ SUM[11]=restore_0[11] SUM[10]=restore_0[10] SUM[9]=restore_0[9]
+ SUM[8]=restore_0[8] SUM[7]=restore_0[7] SUM[6]=restore_0[6] SUM[5]=restore_0[5]
+ SUM[4]=restore_0[4] SUM[3]=restore_0[3] SUM[2]=restore_0[2] SUM[1]=restore_0[1]
+ SUM[0]=restore_0[0]
+ FE_OFN218_FE_OFN49_raw_prime_13=FE_OFN217_FE_OFN49_raw_prime_13
Xsub_0_root_sub_0_root_sub_3176 sub_DW01_sub_4 $PINS A[31]=restore_0[31]
+ A[30]=restore_0[30] A[29]=restore_0[29] A[28]=restore_0[28] A[27]=restore_0[27]
+ A[26]=restore_0[26] A[25]=restore_0[25] A[24]=restore_0[24] A[23]=restore_0[23]
+ A[22]=restore_0[22] A[21]=restore_0[21] A[20]=restore_0[20] A[19]=restore_0[19]
+ A[18]=restore_0[18] A[17]=restore_0[17] A[16]=restore_0[16] A[15]=restore_0[15]
+ A[14]=restore_0[14] A[13]=restore_0[13] A[12]=restore_0[12] A[11]=restore_0[11]
+ A[10]=restore_0[10] A[9]=restore_0[9] A[8]=restore_0[8] A[7]=restore_0[7]
+ A[6]=restore_0[6] A[5]=restore_0[5] A[4]=restore_0[4] A[3]=restore_0[3]
+ A[2]=restore_0[2] A[1]=restore_0[1] A[0]=restore_0[0] B[31]=sub_in_1[31]
+ B[30]=sub_in_1[30] B[29]=sub_in_1[29] B[28]=sub_in_1[28] B[27]=sub_in_1[27]
+ B[26]=sub_in_1[26] B[25]=sub_in_1[25] B[24]=sub_in_1[24] B[23]=sub_in_1[23]
+ B[22]=sub_in_1[22] B[21]=sub_in_1[21] B[20]=sub_in_1[20] B[19]=sub_in_1[19]
+ B[18]=sub_in_1[18] B[17]=sub_in_1[17] B[16]=sub_in_1[16] B[15]=sub_in_1[15]
+ B[14]=sub_in_1[14] B[13]=sub_in_1[13] B[12]=sub_in_1[12] B[11]=sub_in_1[11]
+ B[10]=sub_in_1[10] B[9]=sub_in_1[9] B[8]=sub_in_1[8] B[7]=sub_in_1[7]
+ B[6]=sub_in_1[6] B[5]=sub_in_1[5] B[4]=FE_OFN155_Py_mont_4 B[3]=sub_in_1[3]
+ B[2]=sub_in_1[2] B[1]=sub_in_1[1] B[0]=sub_in_1[0] CI=net25625
+ DIFF[31]=restore_1[31] DIFF[30]=restore_1[30] DIFF[29]=restore_1[29]
+ DIFF[28]=restore_1[28] DIFF[27]=restore_1[27] DIFF[26]=restore_1[26]
+ DIFF[25]=restore_1[25] DIFF[24]=restore_1[24] DIFF[23]=restore_1[23]
+ DIFF[22]=restore_1[22] DIFF[21]=restore_1[21] DIFF[20]=restore_1[20]
+ DIFF[19]=restore_1[19] DIFF[18]=restore_1[18] DIFF[17]=restore_1[17]
+ DIFF[16]=restore_1[16] DIFF[15]=restore_1[15] DIFF[14]=restore_1[14]
+ DIFF[13]=restore_1[13] DIFF[12]=restore_1[12] DIFF[11]=restore_1[11]
+ DIFF[10]=restore_1[10] DIFF[9]=restore_1[9] DIFF[8]=restore_1[8]
+ DIFF[7]=restore_1[7] DIFF[6]=restore_1[6] DIFF[5]=restore_1[5]
+ DIFF[4]=restore_1[4] DIFF[3]=restore_1[3] DIFF[2]=restore_1[2]
+ DIFF[1]=restore_1[1] DIFF[0]=restore_1[0]
+ FE_OFN331_Py_mont_0=FE_OFN331_Py_mont_0 FE_OFN114_Py_mont_4=FE_OFN114_Py_mont_4
Xsub_out_reg[31] QDFFRBN $PINS Q=sub_out[31] D=sub_out_n[31] CK=i_clk_clone2
+ RB=FE_OFN295_FE_OFN6_FE_DBTN1_i_i_rst
Xsub_out_reg[30] QDFFRBN $PINS Q=sub_out[30] D=sub_out_n[30] CK=i_clk_clone2
+ RB=FE_OFN295_FE_OFN6_FE_DBTN1_i_i_rst
Xsub_out_reg[29] QDFFRBN $PINS Q=sub_out[29] D=sub_out_n[29] CK=i_clk_clone2
+ RB=FE_OFN295_FE_OFN6_FE_DBTN1_i_i_rst
Xsub_out_reg[28] QDFFRBN $PINS Q=sub_out[28] D=sub_out_n[28] CK=i_clk_clone2
+ RB=FE_OFN295_FE_OFN6_FE_DBTN1_i_i_rst
Xsub_out_reg[27] QDFFRBN $PINS Q=sub_out[27] D=sub_out_n[27] CK=i_clk_clone2
+ RB=FE_OFN295_FE_OFN6_FE_DBTN1_i_i_rst
Xsub_out_reg[26] QDFFRBN $PINS Q=sub_out[26] D=sub_out_n[26] CK=i_clk_clone2
+ RB=FE_OFN295_FE_OFN6_FE_DBTN1_i_i_rst
Xsub_out_reg[25] QDFFRBN $PINS Q=sub_out[25] D=sub_out_n[25] CK=i_clk_clone2
+ RB=FE_OFN295_FE_OFN6_FE_DBTN1_i_i_rst
Xsub_out_reg[24] QDFFRBN $PINS Q=sub_out[24] D=sub_out_n[24] CK=i_clk_clone2
+ RB=FE_OFN295_FE_OFN6_FE_DBTN1_i_i_rst
Xsub_out_reg[23] QDFFRBN $PINS Q=sub_out[23] D=sub_out_n[23] CK=i_clk_clone2
+ RB=FE_OFN295_FE_OFN6_FE_DBTN1_i_i_rst
Xsub_out_reg[22] QDFFRBN $PINS Q=sub_out[22] D=sub_out_n[22] CK=i_clk_clone2
+ RB=FE_OFN295_FE_OFN6_FE_DBTN1_i_i_rst
Xsub_out_reg[21] QDFFRBN $PINS Q=sub_out[21] D=sub_out_n[21] CK=i_clk_clone2
+ RB=FE_OFN14_FE_DBTN1_i_i_rst
Xsub_out_reg[20] QDFFRBN $PINS Q=sub_out[20] D=sub_out_n[20] CK=i_clk_clone2
+ RB=FE_OFN14_FE_DBTN1_i_i_rst
Xsub_out_reg[19] QDFFRBN $PINS Q=sub_out[19] D=sub_out_n[19] CK=i_clk
+ RB=FE_OFN14_FE_DBTN1_i_i_rst
Xsub_out_reg[18] QDFFRBN $PINS Q=sub_out[18] D=sub_out_n[18] CK=i_clk
+ RB=FE_OFN14_FE_DBTN1_i_i_rst
Xsub_out_reg[17] QDFFRBN $PINS Q=sub_out[17] D=sub_out_n[17] CK=i_clk
+ RB=FE_OFN14_FE_DBTN1_i_i_rst
Xsub_out_reg[16] QDFFRBN $PINS Q=sub_out[16] D=sub_out_n[16] CK=i_clk
+ RB=FE_OFN14_FE_DBTN1_i_i_rst
Xsub_out_reg[15] QDFFRBN $PINS Q=sub_out[15] D=sub_out_n[15] CK=i_clk
+ RB=FE_OFN14_FE_DBTN1_i_i_rst
Xsub_out_reg[14] QDFFRBN $PINS Q=sub_out[14] D=sub_out_n[14] CK=i_clk RB=i_rst
Xsub_out_reg[13] QDFFRBN $PINS Q=sub_out[13] D=sub_out_n[13] CK=i_clk
+ RB=FE_OFN293_FE_OFN7_FE_DBTN1_i_i_rst
Xsub_out_reg[12] QDFFRBN $PINS Q=sub_out[12] D=sub_out_n[12] CK=i_clk
+ RB=FE_OFN293_FE_OFN7_FE_DBTN1_i_i_rst
Xsub_out_reg[11] QDFFRBN $PINS Q=sub_out[11] D=sub_out_n[11] CK=i_clk
+ RB=FE_OFN18_FE_DBTN1_i_i_rst
Xsub_out_reg[10] QDFFRBN $PINS Q=sub_out[10] D=sub_out_n[10] CK=i_clk
+ RB=FE_OFN10_FE_DBTN1_i_i_rst
Xsub_out_reg[9] QDFFRBN $PINS Q=sub_out[9] D=sub_out_n[9] CK=i_clk
+ RB=FE_OFN10_FE_DBTN1_i_i_rst
Xsub_out_reg[8] QDFFRBN $PINS Q=sub_out[8] D=sub_out_n[8] CK=i_clk
+ RB=FE_OFN10_FE_DBTN1_i_i_rst
Xsub_out_reg[7] QDFFRBN $PINS Q=sub_out[7] D=sub_out_n[7] CK=i_clk
+ RB=FE_OFN10_FE_DBTN1_i_i_rst
Xsub_out_reg[6] QDFFRBN $PINS Q=sub_out[6] D=sub_out_n[6] CK=i_clk
+ RB=FE_OFN10_FE_DBTN1_i_i_rst
Xsub_out_reg[5] QDFFRBN $PINS Q=sub_out[5] D=sub_out_n[5] CK=i_clk
+ RB=FE_OFN10_FE_DBTN1_i_i_rst
Xsub_out_reg[4] QDFFRBN $PINS Q=sub_out[4] D=sub_out_n[4] CK=i_clk
+ RB=FE_OFN10_FE_DBTN1_i_i_rst
Xsub_out_reg[3] QDFFRBN $PINS Q=sub_out[3] D=sub_out_n[3] CK=i_clk
+ RB=FE_OFN298_FE_OFN5_FE_DBTN1_i_i_rst
Xsub_out_reg[2] QDFFRBN $PINS Q=sub_out[2] D=sub_out_n[2] CK=i_clk_clone1
+ RB=FE_OFN298_FE_OFN5_FE_DBTN1_i_i_rst
Xsub_out_reg[1] QDFFRBN $PINS Q=sub_out[1] D=sub_out_n[1] CK=i_clk_clone1
+ RB=FE_OFN298_FE_OFN5_FE_DBTN1_i_i_rst
Xsub_out_reg[0] QDFFRBN $PINS Q=sub_out[0] D=sub_out_n[0] CK=i_clk_clone1
+ RB=FE_OFN298_FE_OFN5_FE_DBTN1_i_i_rst
Xstate_reg QDFFRBN $PINS Q=done_sub D=state_n CK=i_clk_clone1
+ RB=FE_OFN300_FE_OFN5_FE_DBTN1_i_i_rst
XU5 AN2 $PINS O=n1 I1=N10 I2=n9
XU6 AN2B1S $PINS O=n2 I1=n9 B1=N10
XU7 INV1S $PINS O=n7 I=sel_sub
XU13 AN2 $PINS O=state_n I1=sel_sub I2=p1
XU14 ND2 $PINS O=n9 I1=p1 I2=n7
XU15 AO22 $PINS O=sub_out_n[0] A1=restore_1[0] A2=n2 B1=N12 B2=n1
XU16 AO22 $PINS O=sub_out_n[1] A1=restore_1[1] A2=n2 B1=N13 B2=n1
XU17 AO22 $PINS O=sub_out_n[2] A1=restore_1[2] A2=n2 B1=N14 B2=n1
XU18 AO22 $PINS O=sub_out_n[3] A1=restore_1[3] A2=n2 B1=N15 B2=n1
XU19 AO22 $PINS O=sub_out_n[4] A1=restore_1[4] A2=n2 B1=N16 B2=n1
XU20 AO22 $PINS O=sub_out_n[5] A1=restore_1[5] A2=n2 B1=N17 B2=n1
XU21 AO22 $PINS O=sub_out_n[6] A1=restore_1[6] A2=n2 B1=N18 B2=n1
XU22 AO22 $PINS O=sub_out_n[7] A1=restore_1[7] A2=n2 B1=N19 B2=n1
XU23 AO22 $PINS O=sub_out_n[8] A1=restore_1[8] A2=n2 B1=N20 B2=n1
XU24 AO22 $PINS O=sub_out_n[9] A1=restore_1[9] A2=n2 B1=N21 B2=n1
XU25 AO22 $PINS O=sub_out_n[10] A1=restore_1[10] A2=n2 B1=N22 B2=n1
XU26 AO22 $PINS O=sub_out_n[11] A1=restore_1[11] A2=n2 B1=N23 B2=n1
XU27 AO22 $PINS O=sub_out_n[12] A1=restore_1[12] A2=FE_OFN556_n2 B1=N24
+ B2=FE_OFN555_n1
XU28 AO22 $PINS O=sub_out_n[13] A1=restore_1[13] A2=FE_OFN556_n2 B1=N25
+ B2=FE_OFN555_n1
XU29 AO22 $PINS O=sub_out_n[14] A1=restore_1[14] A2=FE_OFN556_n2 B1=N26
+ B2=FE_OFN555_n1
XU30 AO22 $PINS O=sub_out_n[15] A1=restore_1[15] A2=FE_OFN556_n2 B1=N27
+ B2=FE_OFN555_n1
XU31 AO22 $PINS O=sub_out_n[16] A1=restore_1[16] A2=FE_OFN556_n2 B1=N28
+ B2=FE_OFN555_n1
XU32 AO22 $PINS O=sub_out_n[17] A1=restore_1[17] A2=FE_OFN556_n2 B1=N29
+ B2=FE_OFN555_n1
XU33 AO22 $PINS O=sub_out_n[18] A1=restore_1[18] A2=FE_OFN556_n2 B1=N30
+ B2=FE_OFN555_n1
XU34 AO22 $PINS O=sub_out_n[19] A1=restore_1[19] A2=FE_OFN556_n2 B1=N31
+ B2=FE_OFN555_n1
XU35 AO22 $PINS O=sub_out_n[20] A1=restore_1[20] A2=FE_OFN556_n2 B1=N32
+ B2=FE_OFN555_n1
XU36 AO22 $PINS O=sub_out_n[21] A1=restore_1[21] A2=FE_OFN556_n2 B1=N33
+ B2=FE_OFN555_n1
XU37 AO22 $PINS O=sub_out_n[22] A1=restore_1[22] A2=FE_OFN556_n2 B1=N34
+ B2=FE_OFN555_n1
XU38 AO22 $PINS O=sub_out_n[23] A1=restore_1[23] A2=FE_OFN556_n2 B1=N35
+ B2=FE_OFN555_n1
XU39 AO22 $PINS O=sub_out_n[24] A1=restore_1[24] A2=FE_OFN556_n2 B1=N36
+ B2=FE_OFN555_n1
XU40 AO22 $PINS O=sub_out_n[25] A1=restore_1[25] A2=FE_OFN556_n2 B1=N37
+ B2=FE_OFN555_n1
XU41 AO22 $PINS O=sub_out_n[26] A1=restore_1[26] A2=FE_OFN556_n2 B1=N38
+ B2=FE_OFN555_n1
XU42 AO22 $PINS O=sub_out_n[27] A1=restore_1[27] A2=FE_OFN556_n2 B1=N39
+ B2=FE_OFN555_n1
XU43 AO22 $PINS O=sub_out_n[28] A1=restore_1[28] A2=FE_OFN556_n2 B1=N40
+ B2=FE_OFN555_n1
XU44 AO22 $PINS O=sub_out_n[29] A1=restore_1[29] A2=FE_OFN556_n2 B1=N41
+ B2=FE_OFN555_n1
XU45 AO22 $PINS O=sub_out_n[30] A1=restore_1[30] A2=FE_OFN556_n2 B1=N42
+ B2=FE_OFN555_n1
XU46 AO22 $PINS O=sub_out_n[31] A1=restore_1[31] A2=FE_OFN556_n2 B1=N43
+ B2=FE_OFN555_n1
.ENDS

.SUBCKT mult_DW01_sub_0 A[32] A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24]
+ A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12] A[11]
+ A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[32] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] CI DIFF[32] DIFF[31] DIFF[30] DIFF[29] DIFF[28] DIFF[27]
+ DIFF[26] DIFF[25] DIFF[24] DIFF[23] DIFF[22] DIFF[21] DIFF[20] DIFF[19]
+ DIFF[18] DIFF[17] DIFF[16] DIFF[15] DIFF[14] DIFF[13] DIFF[12] DIFF[11]
+ DIFF[10] DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3] DIFF[2]
+ DIFF[1] DIFF[0] CO FE_OFN170_mult_out_0 FE_OCPN175_FE_OFN338_n310
XFE_OCPC661_carry_7 BUF1 $PINS O=FE_OCPN665_carry_7 I=carry[7]
XFE_OCPC660_carry_7 INV2CK $PINS O=FE_RN_735_0 I=carry[7]
XFE_OCPC430_carry_22 BUF1S $PINS O=FE_OCPN430_carry_22 I=carry[22]
XFE_OCPC428_carry_18 BUF1S $PINS O=FE_OCPN428_carry_18 I=carry[18]
XFE_OCPC386_carry_12 BUF1S $PINS O=FE_OCPN386_carry_12 I=carry[12]
XFE_OCPC351_carry_8 BUF1S $PINS O=FE_OCPN351_carry_8 I=carry[8]
XFE_OCPC191_carry_19 BUF1S $PINS O=FE_OCPN191_carry_19 I=carry[19]
XFE_RC_2063_0 ND2S $PINS O=FE_RN_1401_0 I1=A[27] I2=n70
XFE_RC_2062_0 AN2S $PINS O=FE_RN_1402_0 I1=FE_RN_1405_0 I2=FE_RN_1401_0
XFE_RC_2061_0 XNR2HS $PINS O=FE_RN_1403_0 I1=n70 I2=A[27]
XFE_RC_2060_0 MXL2HS $PINS OB=DIFF[27] S=carry[27] A=FE_RN_1403_0
+ B=FE_RN_1402_0
XFE_RC_2058_0 OR2S $PINS O=FE_RN_1405_0 I1=n70 I2=A[27]
XFE_RC_2057_0 ND2 $PINS O=FE_RN_1406_0 I1=FE_RN_1405_0 I2=carry[27]
XFE_RC_2056_0 ND2P $PINS O=carry[28] I1=FE_RN_1406_0 I2=FE_RN_1401_0
XFE_RC_1805_0 AN2 $PINS O=FE_RN_1207_0 I1=A[4] I2=n47
XFE_RC_1804_0 AN2B1S $PINS O=FE_RN_1208_0 I1=FE_RN_1211_0 B1=FE_RN_1207_0
XFE_RC_1803_0 XNR2HS $PINS O=FE_RN_1209_0 I1=n47 I2=A[4]
XFE_RC_1802_0 MXL2HS $PINS OB=DIFF[4] S=carry[4] A=FE_RN_1209_0 B=FE_RN_1208_0
XFE_RC_1801_0 ND2S $PINS O=FE_RN_1210_0 I1=A[4] I2=n47
XFE_RC_1800_0 OR2 $PINS O=FE_RN_1211_0 I1=n47 I2=A[4]
XFE_RC_1799_0 ND2 $PINS O=FE_RN_1212_0 I1=FE_RN_1211_0 I2=carry[4]
XFE_RC_1798_0 ND2P $PINS O=carry[5] I1=FE_RN_1212_0 I2=FE_RN_1210_0
XFE_RC_1615_0 ND2 $PINS O=FE_RN_1067_0 I1=A[5] I2=n48
XFE_RC_1614_0 AN2 $PINS O=FE_RN_1068_0 I1=FE_RN_1071_0 I2=FE_RN_1067_0
XFE_RC_1613_0 XNR2HS $PINS O=FE_RN_1069_0 I1=n48 I2=A[5]
XFE_RC_1612_0 MXL2HS $PINS OB=DIFF[5] S=carry[5] A=FE_RN_1069_0 B=FE_RN_1068_0
XFE_RC_1610_0 OR2 $PINS O=FE_RN_1071_0 I1=n48 I2=A[5]
XFE_RC_1609_0 ND2 $PINS O=FE_RN_1072_0 I1=FE_RN_1071_0 I2=carry[5]
XFE_RC_1608_0 ND2P $PINS O=carry[6] I1=FE_RN_1072_0 I2=FE_RN_1067_0
XFE_RC_1546_0 MOAI1 $PINS O=carry[7] A1=FE_RN_885_0 A2=FE_RN_882_0 B1=n49
+ B2=A[6]
XFE_RC_1369_0 INV1S $PINS O=FE_RN_882_0 I=FE_RN_886_0
XFE_RC_1368_0 AOI12HS $PINS O=FE_RN_883_0 A1=FE_RN_882_0 B1=A[6] B2=n49
XFE_RC_1367_0 XNR2HS $PINS O=FE_RN_884_0 I1=n49 I2=A[6]
XFE_RC_1366_0 MXL2HS $PINS OB=DIFF[6] S=carry[6] A=FE_RN_884_0 B=FE_RN_883_0
XFE_RC_1365_0 INV1S $PINS O=FE_RN_885_0 I=carry[6]
XFE_RC_1364_0 OR2 $PINS O=FE_RN_886_0 I1=n49 I2=A[6]
XFE_RC_1295_0 MOAI1 $PINS O=carry[8] A1=FE_RN_735_0 A2=FE_RN_732_0 B1=n50
+ B2=A[7]
XFE_RC_1202_0 INV1S $PINS O=FE_RN_768_0 I=n35
XFE_RC_1201_0 ND3P $PINS O=carry[31] I1=n41 I2=n40 I3=FE_RN_768_0
XFE_RC_1156_0 INV1S $PINS O=FE_RN_732_0 I=FE_RN_736_0
XFE_RC_1155_0 AOI12HS $PINS O=FE_RN_733_0 A1=FE_RN_732_0 B1=A[7] B2=n50
XFE_RC_1154_0 XNR2HS $PINS O=FE_RN_734_0 I1=n50 I2=A[7]
XFE_RC_1153_0 MXL2HS $PINS OB=DIFF[7] S=FE_OCPN665_carry_7 A=FE_RN_734_0
+ B=FE_RN_733_0
XFE_RC_1151_0 OR2 $PINS O=FE_RN_736_0 I1=n50 I2=A[7]
XFE_RC_1076_0 OR2 $PINS O=FE_RN_680_0 I1=FE_RN_569_0 I2=FE_RN_568_0
XFE_RC_1075_0 ND2P $PINS O=carry[14] I1=FE_RN_574_0 I2=FE_RN_680_0
XFE_RC_935_0 INV1S $PINS O=FE_RN_566_0 I=FE_RN_573_0
XFE_RC_934_0 AOI12HS $PINS O=FE_RN_567_0 A1=FE_RN_566_0 B1=A[13] B2=n56
XFE_RC_933_0 INV1S $PINS O=FE_RN_568_0 I=n56
XFE_RC_932_0 INV1S $PINS O=FE_RN_569_0 I=A[13]
XFE_RC_931_0 AOI22S $PINS O=FE_RN_570_0 A1=FE_RN_569_0 A2=n56 B1=A[13]
+ B2=FE_RN_568_0
XFE_RC_930_0 MXL2HS $PINS OB=DIFF[13] S=carry[13] A=FE_RN_570_0 B=FE_RN_567_0
XFE_RC_927_0 OR2S $PINS O=FE_RN_573_0 I1=n56 I2=A[13]
XFE_RC_926_0 ND2 $PINS O=FE_RN_574_0 I1=FE_RN_573_0 I2=carry[13]
XFE_RC_808_0 ND3 $PINS O=carry[19] I1=n33 I2=n34 I3=n32
XFE_RC_782_0 ND2S $PINS O=FE_RN_455_0 I1=A[14] I2=n57
XFE_RC_781_0 AN2 $PINS O=FE_RN_456_0 I1=FE_RN_459_0 I2=FE_RN_455_0
XFE_RC_780_0 XNR2HS $PINS O=FE_RN_457_0 I1=n57 I2=A[14]
XFE_RC_779_0 MXL2HS $PINS OB=DIFF[14] S=carry[14] A=FE_RN_457_0 B=FE_RN_456_0
XFE_RC_777_0 OR2S $PINS O=FE_RN_459_0 I1=n57 I2=A[14]
XFE_RC_776_0 ND2 $PINS O=FE_RN_460_0 I1=FE_RN_459_0 I2=carry[14]
XFE_RC_775_0 ND2P $PINS O=carry[15] I1=FE_RN_460_0 I2=FE_RN_455_0
XFE_RC_559_0 ND2 $PINS O=FE_RN_298_0 I1=A[15] I2=n58
XFE_RC_558_0 AN2 $PINS O=FE_RN_299_0 I1=FE_RN_302_0 I2=FE_RN_298_0
XFE_RC_557_0 XNR2HS $PINS O=FE_RN_300_0 I1=n58 I2=A[15]
XFE_RC_556_0 MXL2HS $PINS OB=DIFF[15] S=carry[15] A=FE_RN_300_0 B=FE_RN_299_0
XFE_RC_554_0 OR2S $PINS O=FE_RN_302_0 I1=n58 I2=A[15]
XFE_RC_553_0 ND2 $PINS O=FE_RN_303_0 I1=FE_RN_302_0 I2=carry[15]
XFE_RC_552_0 ND2P $PINS O=carry[16] I1=FE_RN_303_0 I2=FE_RN_298_0
XFE_RC_430_0 XNR2HS $PINS O=FE_RN_206_0 I1=n62 I2=A[19]
XFE_RC_429_0 ND2 $PINS O=FE_RN_207_0 I1=A[19] I2=n62
XFE_RC_428_0 ND2S $PINS O=FE_RN_208_0 I1=FE_RN_211_0 I2=FE_RN_207_0
XFE_RC_427_0 ND2 $PINS O=FE_RN_209_0 I1=FE_OCPN191_carry_19 I2=FE_RN_208_0
XFE_RC_426_0 OAI12HS $PINS O=DIFF[19] A1=FE_RN_209_0 B1=FE_OCPN191_carry_19
+ B2=FE_RN_206_0
XFE_RC_424_0 OR2S $PINS O=FE_RN_211_0 I1=n62 I2=A[19]
XFE_RC_423_0 ND2 $PINS O=FE_RN_212_0 I1=FE_RN_211_0 I2=carry[19]
XFE_RC_422_0 ND2P $PINS O=carry[20] I1=FE_RN_212_0 I2=FE_RN_207_0
XFE_RC_412_0 MOAI1 $PINS O=carry[9] A1=FE_RN_79_0 A2=FE_RN_76_0 B1=n51 B2=A[8]
XFE_RC_252_0 ND3P $PINS O=carry[22] I1=n15 I2=n16 I3=n14
XFE_RC_215_0 INV1S $PINS O=FE_RN_76_0 I=FE_RN_80_0
XFE_RC_214_0 AOI12HS $PINS O=FE_RN_77_0 A1=FE_RN_76_0 B1=A[8] B2=n51
XFE_RC_213_0 XNR2HS $PINS O=FE_RN_78_0 I1=n51 I2=A[8]
XFE_RC_212_0 MXL2HS $PINS OB=DIFF[8] S=FE_OCPN351_carry_8 A=FE_RN_78_0
+ B=FE_RN_77_0
XFE_RC_211_0 INV1S $PINS O=FE_RN_79_0 I=carry[8]
XFE_RC_210_0 OR2 $PINS O=FE_RN_80_0 I1=n51 I2=A[8]
XFE_RC_142_0 INV1S $PINS O=FE_RN_44_0 I=n21
XFE_RC_141_0 MXL2HS $PINS OB=DIFF[32] S=carry[32] A=FE_RN_44_0 B=n21
XFE_RC_124_0 ND3 $PINS O=carry[23] I1=n19 I2=n20 I3=n18
XFE_RC_120_0 ND3P $PINS O=carry[13] I1=n12 I2=n13 I3=n11
XFE_RC_116_0 XOR3 $PINS O=DIFF[9] I1=A[9] I2=n52 I3=carry[9]
XFE_RC_115_0 MAO222 $PINS O=carry[10] A1=A[9] B1=n52 C1=carry[9]
XFE_RC_104_0 ND3P $PINS O=carry[12] I1=n9 I2=n8 I3=n7
XFE_OFC299_mult_out_0 INV1S $PINS O=FE_OFN335_mult_out_0 I=A[0]
XFE_OFC286_raw_prime_3 INV1S $PINS O=n46 I=B[3]
XFE_OFC213_raw_prime_5 INV1S $PINS O=n48 I=B[5]
XFE_OFC162_raw_prime_7 INV1S $PINS O=n50 I=B[7]
XFE_OFC153_raw_prime_6 INV1S $PINS O=n49 I=B[6]
XFE_OFC122_raw_prime_8 INV1S $PINS O=n51 I=B[8]
XFE_OFC106_n312 INV1S $PINS O=n44 I=B[1]
XFE_OFC90_raw_prime_4 INV1S $PINS O=n47 I=B[4]
XU2_31 FA1 $PINS S=DIFF[31] CO=carry[32] A=A[31] B=n74 CI=carry[31]
XU2_26 FA1 $PINS S=DIFF[26] CO=carry[27] A=A[26] B=n69 CI=carry[26]
XU2_25 FA1 $PINS S=DIFF[25] CO=carry[26] A=A[25] B=n68 CI=carry[25]
XU2_24 FA1 $PINS S=DIFF[24] CO=carry[25] A=A[24] B=n67 CI=carry[24]
XU2_23 FA1 $PINS S=DIFF[23] CO=carry[24] A=A[23] B=n66 CI=carry[23]
XU2_3 FA1 $PINS S=DIFF[3] CO=carry[4] A=A[3] B=n46 CI=carry[3]
XU2_2 FA1 $PINS S=DIFF[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU2_1 FA1 $PINS S=DIFF[1] CO=carry[2] A=A[1] B=n44 CI=carry[1]
XU2 XOR3 $PINS O=DIFF[21] I1=A[21] I2=n64 I3=carry[21]
XU3 XOR3 $PINS O=DIFF[10] I1=n53 I2=A[10] I3=carry[10]
XU4 ND2 $PINS O=n1 I1=carry[10] I2=n53
XU5 ND2 $PINS O=n2 I1=carry[10] I2=A[10]
XU6 ND2 $PINS O=n3 I1=n53 I2=A[10]
XU7 ND3P $PINS O=carry[11] I1=n1 I2=n2 I3=n3
XU8 ND3P $PINS O=carry[21] I1=n4 I2=n5 I3=n6
XU9 INV1S $PINS O=n59 I=B[16]
XU10 ND3P $PINS O=carry[29] I1=n23 I2=n22 I3=n24
XU12 ND2 $PINS O=n7 I1=A[11] I2=n54
XU13 ND2 $PINS O=n28 I1=A[17] I2=n60
XU14 ND2 $PINS O=n14 I1=A[21] I2=n64
XU15 INV1S $PINS O=n71 I=B[28]
XU16 ND2 $PINS O=n36 I1=A[29] I2=n72
XU17 INV1S $PINS O=n21 I=A[32]
XU18 ND2 $PINS O=carry[1] I1=B[0] I2=FE_OFN335_mult_out_0
XU21 XOR3 $PINS O=DIFF[11] I1=A[11] I2=n54 I3=carry[11]
XU22 XOR3 $PINS O=DIFF[17] I1=A[17] I2=n60 I3=carry[17]
XU23 XOR3 $PINS O=DIFF[16] I1=n59 I2=A[16] I3=carry[16]
XU24 XOR3 $PINS O=DIFF[29] I1=A[29] I2=n72 I3=carry[29]
XU25 XOR3 $PINS O=DIFF[28] I1=n71 I2=A[28] I3=carry[28]
XU26 XOR3 $PINS O=DIFF[20] I1=n63 I2=A[20] I3=carry[20]
XU27 ND2 $PINS O=n4 I1=carry[20] I2=n63
XU28 ND2 $PINS O=n5 I1=carry[20] I2=A[20]
XU29 ND2 $PINS O=n6 I1=n63 I2=A[20]
XU30 INV1S $PINS O=n43 I=FE_OCPN175_FE_OFN338_n310
XU31 ND2 $PINS O=n8 I1=A[11] I2=carry[11]
XU32 ND2 $PINS O=n9 I1=n54 I2=carry[11]
XU34 XOR2HS $PINS O=n10 I1=A[12] I2=n55
XU35 XOR2HS $PINS O=DIFF[12] I1=n10 I2=FE_OCPN386_carry_12
XU36 ND2S $PINS O=n11 I1=A[12] I2=n55
XU37 ND2 $PINS O=n12 I1=A[12] I2=carry[12]
XU38 ND2 $PINS O=n13 I1=n55 I2=carry[12]
XU40 ND2 $PINS O=n15 I1=A[21] I2=carry[21]
XU41 ND2 $PINS O=n16 I1=n64 I2=carry[21]
XU43 XOR2HS $PINS O=n17 I1=A[22] I2=n65
XU44 XOR2HS $PINS O=DIFF[22] I1=n17 I2=FE_OCPN430_carry_22
XU45 ND2S $PINS O=n18 I1=A[22] I2=n65
XU46 ND2 $PINS O=n19 I1=A[22] I2=carry[22]
XU47 ND2 $PINS O=n20 I1=n65 I2=carry[22]
XU50 ND2 $PINS O=n37 I1=A[29] I2=carry[29]
XU51 ND2 $PINS O=n22 I1=carry[28] I2=n71
XU52 ND2 $PINS O=n23 I1=carry[28] I2=A[28]
XU53 ND2S $PINS O=n24 I1=n71 I2=A[28]
XU54 ND2 $PINS O=n25 I1=carry[16] I2=n59
XU55 ND2 $PINS O=n26 I1=carry[16] I2=A[16]
XU56 ND2S $PINS O=n27 I1=n59 I2=A[16]
XU57 ND3P $PINS O=carry[17] I1=n25 I2=n26 I3=n27
XU59 ND2 $PINS O=n29 I1=carry[17] I2=A[17]
XU60 ND2 $PINS O=n30 I1=carry[17] I2=n60
XU61 ND3P $PINS O=carry[18] I1=n30 I2=n29 I3=n28
XU62 XOR2HS $PINS O=n31 I1=A[18] I2=n61
XU63 XOR2HS $PINS O=DIFF[18] I1=n31 I2=FE_OCPN428_carry_18
XU64 ND2S $PINS O=n32 I1=A[18] I2=n61
XU65 ND2 $PINS O=n33 I1=A[18] I2=carry[18]
XU66 ND2 $PINS O=n34 I1=n61 I2=carry[18]
XU68 AN2 $PINS O=n35 I1=A[30] I2=n73
XU69 ND2 $PINS O=n38 I1=carry[29] I2=n72
XU70 ND3P $PINS O=carry[30] I1=n38 I2=n37 I3=n36
XU71 XOR2HS $PINS O=n39 I1=A[30] I2=n73
XU72 XOR2HS $PINS O=DIFF[30] I1=n39 I2=carry[30]
XU73 ND2 $PINS O=n40 I1=A[30] I2=carry[30]
XU74 ND2 $PINS O=n41 I1=n73 I2=carry[30]
XU75 INV1S $PINS O=n74 I=B[31]
XU76 INV1S $PINS O=n56 I=B[13]
XU77 INV1S $PINS O=n64 I=B[21]
XU78 INV1S $PINS O=n72 I=B[29]
XU81 INV1S $PINS O=n58 I=B[15]
XU82 INV1S $PINS O=n66 I=B[23]
XU83 INV1S $PINS O=n52 I=B[9]
XU84 INV1S $PINS O=n54 I=B[11]
XU85 INV1S $PINS O=n60 I=B[17]
XU86 INV1S $PINS O=n62 I=B[19]
XU87 INV1S $PINS O=n68 I=B[25]
XU88 INV1S $PINS O=n70 I=B[27]
XU92 INV1S $PINS O=n53 I=B[10]
XU93 INV1S $PINS O=n55 I=B[12]
XU94 INV1S $PINS O=n57 I=B[14]
XU95 INV1S $PINS O=n61 I=B[18]
XU96 INV1S $PINS O=n63 I=B[20]
XU97 INV1S $PINS O=n65 I=B[22]
XU98 INV1S $PINS O=n67 I=B[24]
XU99 INV1S $PINS O=n69 I=B[26]
XU100 INV1S $PINS O=n73 I=B[30]
XU101 XNR2HS $PINS O=DIFF[0] I1=n43 I2=FE_OFN170_mult_out_0
.ENDS

.SUBCKT mult_DW_cmp_0 A[32] A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24]
+ A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12] A[11]
+ A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[32] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] TC GE_LT GE_GT_EQ GE_LT_GT_LE EQ_NE
XFE_RC_2409_0 AO12 $PINS O=n305 A1=n313 B1=n301 B2=n314
XU163 INV1S $PINS O=n256 I=n280
XU164 INV1S $PINS O=n238 I=B[2]
XU165 INV1S $PINS O=n241 I=B[6]
XU166 INV1S $PINS O=n245 I=B[13]
XU167 INV1S $PINS O=n253 I=B[29]
XU168 INV1S $PINS O=n243 I=B[9]
XU169 INV1S $PINS O=n252 I=B[27]
XU170 INV1S $PINS O=n251 I=B[25]
XU171 INV1S $PINS O=n248 I=B[19]
XU172 INV1S $PINS O=n244 I=B[11]
XU173 INV1S $PINS O=n247 I=B[17]
XU174 INV1S $PINS O=n246 I=B[15]
XU175 INV1S $PINS O=n239 I=B[3]
XU176 INV1S $PINS O=n250 I=B[23]
XU177 INV1S $PINS O=n242 I=B[7]
XU178 INV1S $PINS O=n254 I=B[31]
XU179 INV1S $PINS O=n269 I=n290
XU180 INV1S $PINS O=n249 I=B[21]
XU181 INV1S $PINS O=n240 I=B[5]
XU182 INV1S $PINS O=n255 I=A[0]
XU183 INV1S $PINS O=n237 I=B[1]
XU184 MAOI1 $PINS O=n309 A1=B[14] A2=n234 B1=A[15] B2=n246
XU185 AN2 $PINS O=n234 I1=n312 I2=n265
XU186 MAOI1 $PINS O=n341 A1=B[30] A2=n235 B1=A[31] B2=n254
XU187 AN2 $PINS O=n235 I1=n344 I2=n257
XU188 MAOI1 $PINS O=n328 A1=B[22] A2=n236 B1=A[23] B2=n250
XU189 AN2 $PINS O=n236 I1=n331 I2=n261
XU190 INV1S $PINS O=n267 I=A[10]
XU191 INV1S $PINS O=n259 I=A[26]
XU192 INV1S $PINS O=n262 I=A[20]
XU193 INV1S $PINS O=n258 I=A[28]
XU194 INV1S $PINS O=n272 I=A[2]
XU195 INV1S $PINS O=n270 I=A[6]
XU196 INV1S $PINS O=n271 I=A[4]
XU197 INV1S $PINS O=n266 I=A[12]
XU198 INV1S $PINS O=n265 I=A[14]
XU199 INV1S $PINS O=n261 I=A[22]
XU200 INV1S $PINS O=n257 I=A[30]
XU201 INV1S $PINS O=n268 I=A[8]
XU202 INV1S $PINS O=n260 I=A[24]
XU203 INV1S $PINS O=n263 I=A[18]
XU204 INV1S $PINS O=n264 I=A[16]
XU205 AO12 $PINS O=GE_LT_GT_LE A1=A[32] B1=n273 B2=n274
XU206 ND3 $PINS O=n274 I1=n275 I2=n276 I3=n277
XU207 AN3B2S $PINS O=n277 I1=n278 B1=n279 B2=n280
XU208 OA12 $PINS O=n276 A1=n281 B1=B[16] B2=n264
XU209 AOI22S $PINS O=n275 A1=n282 A2=n283 B1=n284 B2=n282
XU210 AOI13HS $PINS O=n284 A1=n287 B1=n269 B2=n285 B3=n286
XU211 AOI22S $PINS O=n287 A1=n288 A2=n289 B1=n289 B2=n290
XU212 OA22 $PINS O=n289 A1=A[7] A2=n242 B1=n241 B2=n291
XU213 ND2 $PINS O=n291 I1=n292 I2=n270
XU214 AOI13HS $PINS O=n288 A1=n294 B1=n293 B2=n271 B3=B[4]
XU215 NR2 $PINS O=n294 I1=A[5] I2=n240
XU216 OA112 $PINS O=n286 A1=n293 B1=n295 C1=B[4] C2=n271
XU217 ND2 $PINS O=n295 I1=n296 I2=n297
XU218 OAI12HS $PINS O=n297 A1=n298 B1=B[2] B2=n272
XU219 ND2 $PINS O=n293 I1=A[5] I2=n240
XU220 OAI112HS $PINS O=n285 A1=n299 B1=n296 C1=A[1] C2=n237
XU221 OA22 $PINS O=n296 A1=A[3] A2=n239 B1=n238 B2=n300
XU222 ND2 $PINS O=n300 I1=n298 I2=n272
XU223 ND2 $PINS O=n298 I1=A[3] I2=n239
XU224 MOAI1S $PINS O=n299 A1=B[0] A2=n255 B1=n237 B2=A[1]
XU225 OAI12HS $PINS O=n290 A1=n292 B1=B[6] B2=n270
XU226 ND2 $PINS O=n292 I1=A[7] I2=n242
XU227 ND3 $PINS O=n283 I1=n301 I2=n302 I3=n303
XU228 OA12 $PINS O=n303 A1=n304 B1=B[8] B2=n268
XU229 AOI22S $PINS O=n282 A1=n302 A2=n305 B1=n306 B2=n307
XU230 OAI112HS $PINS O=n307 A1=n308 B1=n309 C1=A[13] C2=n245
XU231 ND3 $PINS O=n308 I1=n310 I2=n266 I3=B[12]
XU232 OR2B1S $PINS O=n306 I1=n311 B1=n309
XU234 MOAI1S $PINS O=n314 A1=A[9] A2=n243 B1=B[8] B2=n315
XU235 AN2 $PINS O=n315 I1=n304 I2=n268
XU236 ND2 $PINS O=n304 I1=A[9] I2=n243
XU237 MOAI1S $PINS O=n313 A1=A[11] A2=n244 B1=B[10] B2=n316
XU238 AN2 $PINS O=n316 I1=n317 I2=n267
XU239 OA12 $PINS O=n301 A1=n317 B1=B[10] B2=n267
XU240 ND2 $PINS O=n317 I1=A[11] I2=n244
XU241 OA112 $PINS O=n302 A1=n310 B1=n311 C1=B[12] C2=n266
XU242 OA12 $PINS O=n311 A1=n312 B1=B[14] B2=n265
XU243 ND2 $PINS O=n312 I1=A[15] I2=n246
XU244 ND2 $PINS O=n310 I1=A[13] I2=n245
XU245 OAI22S $PINS O=n273 A1=n318 A2=n319 B1=n256 B2=n318
XU246 OR3B2 $PINS O=n280 I1=n320 B1=n321 B2=n322
XU247 OA12 $PINS O=n322 A1=n323 B1=B[24] B2=n260
XU248 MOAI1S $PINS O=n319 A1=n279 A2=n324 B1=n325 B2=n326
XU249 OAI112HS $PINS O=n326 A1=n327 B1=n328 C1=A[21] C2=n249
XU250 ND3 $PINS O=n327 I1=n329 I2=n262 I3=B[20]
XU251 OR2B1S $PINS O=n325 I1=n330 B1=n328
XU252 OAI22S $PINS O=n324 A1=n278 A2=n332 B1=n332 B2=n333
XU253 MOAI1S $PINS O=n333 A1=A[17] A2=n247 B1=B[16] B2=n334
XU254 AN2 $PINS O=n334 I1=n281 I2=n264
XU255 ND2 $PINS O=n281 I1=A[17] I2=n247
XU256 MOAI1S $PINS O=n332 A1=A[19] A2=n248 B1=B[18] B2=n335
XU257 AN2 $PINS O=n335 I1=n336 I2=n263
XU258 OA12 $PINS O=n278 A1=n336 B1=B[18] B2=n263
XU259 ND2 $PINS O=n336 I1=A[19] I2=n248
XU260 OAI112HS $PINS O=n279 A1=n329 B1=n330 C1=B[20] C2=n262
XU261 OA12 $PINS O=n330 A1=n331 B1=B[22] B2=n261
XU262 ND2 $PINS O=n331 I1=A[23] I2=n250
XU263 ND2 $PINS O=n329 I1=A[21] I2=n249
XU264 MOAI1S $PINS O=n318 A1=n320 A2=n337 B1=n338 B2=n339
XU265 OAI112HS $PINS O=n339 A1=n340 B1=n341 C1=A[29] C2=n253
XU266 ND3 $PINS O=n340 I1=n342 I2=n258 I3=B[28]
XU267 OR2B1S $PINS O=n338 I1=n343 B1=n341
XU268 OAI22S $PINS O=n337 A1=n321 A2=n345 B1=n345 B2=n346
XU269 MOAI1S $PINS O=n346 A1=A[25] A2=n251 B1=B[24] B2=n347
XU270 AN2 $PINS O=n347 I1=n323 I2=n260
XU271 ND2 $PINS O=n323 I1=A[25] I2=n251
XU272 MOAI1S $PINS O=n345 A1=A[27] A2=n252 B1=B[26] B2=n348
XU273 AN2 $PINS O=n348 I1=n349 I2=n259
XU274 OA12 $PINS O=n321 A1=n349 B1=B[26] B2=n259
XU275 ND2 $PINS O=n349 I1=A[27] I2=n252
XU276 OAI112HS $PINS O=n320 A1=n342 B1=n343 C1=B[28] C2=n258
XU277 OA12 $PINS O=n343 A1=n344 B1=B[30] B2=n257
XU278 ND2 $PINS O=n344 I1=A[31] I2=n254
XU279 ND2 $PINS O=n342 I1=A[29] I2=n253
.ENDS

.SUBCKT mult_DW01_inc_0 A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0]
+ SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2] SUM[1] SUM[0]
+ p1
*.CONNECT SUM[0] p1
XU1_1_9 HA1 $PINS S=SUM[9] C=carry[10] A=A[9] B=carry[9]
XU1_1_8 HA1 $PINS S=SUM[8] C=carry[9] A=A[8] B=carry[8]
XU1_1_7 HA1 $PINS S=SUM[7] C=carry[8] A=A[7] B=carry[7]
XU1_1_6 HA1 $PINS S=SUM[6] C=carry[7] A=A[6] B=carry[6]
XU1_1_5 HA1 $PINS S=SUM[5] C=carry[6] A=A[5] B=carry[5]
XU1_1_4 HA1 $PINS S=SUM[4] C=carry[5] A=A[4] B=carry[4]
XU1_1_3 HA1 $PINS S=SUM[3] C=carry[4] A=A[3] B=carry[3]
XU1_1_2 HA1 $PINS S=SUM[2] C=carry[3] A=A[2] B=carry[2]
XU1_1_1 HA1 $PINS S=SUM[1] C=carry[2] A=A[1] B=A[0]
XU1 XOR2HS $PINS O=SUM[10] I1=carry[10] I2=A[10]
.ENDS

.SUBCKT mult_DW_mult_uns_1 a[31] a[30] a[29] a[28] a[27] a[26] a[25] a[24]
+ a[23] a[22] a[21] a[20] a[19] a[18] a[17] a[16] a[15] a[14] a[13] a[12] a[11]
+ a[10] a[9] a[8] a[7] a[6] a[5] a[4] a[3] a[2] a[1] a[0] b product[32]
+ product[31] product[30] product[29] product[28] product[27] product[26]
+ product[25] product[24] product[23] product[22] product[21] product[20]
+ product[19] product[18] product[17] product[16] product[15] product[14]
+ product[13] product[12] product[11] product[10] product[9] product[8]
+ product[7] product[6] product[5] product[4] product[3] product[2] product[1]
+ product[0]
XFE_OFC257_n35 BUF2 $PINS O=FE_OFN315_n35 I=n35
XFE_OFC82_N16 BUF2 $PINS O=FE_OFN83_N16 I=FE_OFN315_n35
XFE_OFC81_N16 INV4 $PINS O=n35 I=b
XU73 AN2B1S $PINS O=product[13] I1=a[13] B1=FE_OFN315_n35
XU74 AN2B1S $PINS O=product[17] I1=a[17] B1=FE_OFN315_n35
XU75 AN2B1S $PINS O=product[15] I1=a[15] B1=FE_OFN315_n35
XU76 AN2B1S $PINS O=product[11] I1=a[11] B1=FE_OFN315_n35
XU77 AN2B1S $PINS O=product[19] I1=a[19] B1=FE_OFN83_N16
XU78 AN2B1S $PINS O=product[21] I1=a[21] B1=FE_OFN83_N16
XU79 AN2B1S $PINS O=product[23] I1=a[23] B1=FE_OFN83_N16
XU80 AN2B1S $PINS O=product[25] I1=a[25] B1=FE_OFN83_N16
XU81 AN2B1S $PINS O=product[10] I1=a[10] B1=FE_OFN315_n35
XU82 AN2B1S $PINS O=product[16] I1=a[16] B1=FE_OFN315_n35
XU83 AN2B1S $PINS O=product[20] I1=a[20] B1=FE_OFN83_N16
XU84 AN2B1S $PINS O=product[22] I1=a[22] B1=FE_OFN83_N16
XU85 AN2B1S $PINS O=product[12] I1=a[12] B1=FE_OFN315_n35
XU86 AN2B1S $PINS O=product[14] I1=a[14] B1=FE_OFN315_n35
XU87 AN2B1S $PINS O=product[18] I1=a[18] B1=FE_OFN83_N16
XU88 AN2B1S $PINS O=product[26] I1=a[26] B1=FE_OFN83_N16
XU89 AN2B1S $PINS O=product[24] I1=a[24] B1=FE_OFN83_N16
XU90 AN2B1S $PINS O=product[29] I1=a[29] B1=FE_OFN83_N16
XU91 AN2B1S $PINS O=product[27] I1=a[27] B1=FE_OFN83_N16
XU92 AN2B1S $PINS O=product[28] I1=a[28] B1=FE_OFN83_N16
XU93 AN2B1S $PINS O=product[30] I1=a[30] B1=FE_OFN83_N16
XU94 AN2B1S $PINS O=product[31] I1=a[31] B1=FE_OFN83_N16
XU95 AN2B1S $PINS O=product[3] I1=a[3] B1=n35
XU96 AN2B1S $PINS O=product[5] I1=a[5] B1=n35
XU97 AN2B1S $PINS O=product[7] I1=a[7] B1=n35
XU98 AN2B1S $PINS O=product[9] I1=a[9] B1=n35
XU99 AN2B1S $PINS O=product[1] I1=a[1] B1=n35
XU100 AN2B1S $PINS O=product[4] I1=a[4] B1=n35
XU101 AN2B1S $PINS O=product[2] I1=a[2] B1=n35
XU102 AN2B1S $PINS O=product[6] I1=a[6] B1=n35
XU103 AN2B1S $PINS O=product[8] I1=a[8] B1=n35
XU104 AN2B1S $PINS O=product[0] I1=a[0] B1=n35
.ENDS

.SUBCKT mult_DW01_add_4 A[33] A[32] A[31] A[30] A[29] A[28] A[27] A[26] A[25]
+ A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12]
+ A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[33] B[32]
+ B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19]
+ B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6]
+ B[5] B[4] B[3] B[2] B[1] B[0] CI SUM[33] SUM[32] SUM[31] SUM[30] SUM[29]
+ SUM[28] SUM[27] SUM[26] SUM[25] SUM[24] SUM[23] SUM[22] SUM[21] SUM[20]
+ SUM[19] SUM[18] SUM[17] SUM[16] SUM[15] SUM[14] SUM[13] SUM[12] SUM[11]
+ SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2] SUM[1] SUM[0]
+ CO
*.CONNECT SUM[33] n33
XFE_OFC640_n169 INV2CK $PINS O=n168 I=n169
XFE_OFC84_n125 INV1S $PINS O=FE_OFN84_n125 I=n124
XFE_OFC83_n125 INV2 $PINS O=n124 I=n125
XU2 HA1 $PINS S=SUM[32] C=n33 A=A[32] B=n34
XU273 INV1S $PINS O=n101 I=n102
XU274 INV1S $PINS O=n74 I=n75
XU275 OR2 $PINS O=n344 I1=A[26] I2=B[26]
XU276 OR2 $PINS O=n345 I1=A[28] I2=B[28]
XU277 OR2 $PINS O=n346 I1=A[30] I2=B[30]
XU278 OR2 $PINS O=n347 I1=A[0] I2=B[0]
XU279 AOI12HS $PINS O=n125 A1=n127 B1=n169 B2=n126
XU280 ND2S $PINS O=n144 I1=B[12] I2=A[12]
XU281 OA12 $PINS O=n353 A1=n144 B1=n145 B2=n143
XU282 AO12 $PINS O=n352 A1=n68 B1=n74 B2=n67
XU283 ND2S $PINS O=n203 I1=B[0] I2=A[0]
XU284 XNR2HS $PINS O=SUM[5] I1=n27 I2=n356
XU285 XNR2HS $PINS O=SUM[26] I1=n6 I2=n352
XU286 ND2S $PINS O=n147 I1=n161 I2=n149
XU287 ND2S $PINS O=n105 I1=n115 I2=n107
XU288 XNR2HS $PINS O=SUM[21] I1=n11 I2=n348
XU289 AO12 $PINS O=n348 A1=n98 B1=n101 B2=n215
XU290 ND2S $PINS O=n170 I1=n180 I2=n172
XU291 ND2S $PINS O=n24 I1=n227 I2=n167
XU292 ND2S $PINS O=n16 I1=n219 I2=n123
XU293 ND2S $PINS O=n28 I1=n231 I2=n188
XU294 XNR2HS $PINS O=SUM[17] I1=n15 I2=n349
XU295 AO12S $PINS O=n349 A1=n121 B1=n124 B2=n219
XU296 XNR2HS $PINS O=SUM[23] I1=n9 I2=n350
XU297 AO12S $PINS O=n350 A1=n86 B1=n89 B2=n213
XU298 XNR2HS $PINS O=SUM[27] I1=n5 I2=n351
XU299 AO12 $PINS O=n351 A1=n59 B1=n74 B2=n58
XU300 XOR2HS $PINS O=SUM[13] I1=n19 I2=n353
XU301 XOR2HS $PINS O=SUM[25] I1=n7 I2=n354
XU302 OA12S $PINS O=n354 A1=n73 B1=n75 B2=n72
XU303 ND2S $PINS O=n51 I1=n76 I2=n53
XU304 XOR2HS $PINS O=SUM[9] I1=n23 I2=n355
XU305 OA12S $PINS O=n355 A1=n167 B1=n168 B2=n166
XU306 AO12 $PINS O=n356 A1=n186 B1=n189 B2=n231
XU307 XNR2HS $PINS O=SUM[11] I1=n21 I2=n357
XU308 AO12 $PINS O=n357 A1=n155 B1=n158 B2=n154
XU309 ND2S $PINS O=n136 I1=B[14] I2=A[14]
XU310 ND2S $PINS O=n178 I1=B[6] I2=A[6]
XU311 ND2S $PINS O=n197 I1=B[2] I2=A[2]
XU312 ND2S $PINS O=n113 I1=B[18] I2=A[18]
XU313 ND2S $PINS O=n157 I1=B[10] I2=A[10]
XU314 ND2S $PINS O=n88 I1=B[22] I2=A[22]
XU315 ND2S $PINS O=n141 I1=B[13] I2=A[13]
XU316 ND2S $PINS O=n95 I1=B[21] I2=A[21]
XU317 ND2S $PINS O=n183 I1=B[5] I2=A[5]
XU318 ND2S $PINS O=n133 I1=B[15] I2=A[15]
XU319 ND2S $PINS O=n83 I1=B[23] I2=A[23]
XU320 ND2S $PINS O=n175 I1=B[7] I2=A[7]
XU321 ND2S $PINS O=n194 I1=B[3] I2=A[3]
XU322 ND2S $PINS O=n152 I1=B[11] I2=A[11]
XU323 ND2S $PINS O=n164 I1=B[9] I2=A[9]
XU324 ND2S $PINS O=n118 I1=B[17] I2=A[17]
XU325 ND2S $PINS O=n110 I1=B[19] I2=A[19]
XU326 AN2 $PINS O=SUM[0] I1=n347 I2=n203
XU327 NR2 $PINS O=n76 I1=n78 I2=n105
XU328 INV1S $PINS O=n145 I=n146
XU329 INV1S $PINS O=n58 I=n60
XU330 OAI12HS $PINS O=n158 A1=n160 B1=n168 B2=n159
XU331 INV1S $PINS O=n160 I=n162
XU332 INV1S $PINS O=n159 I=n161
XU333 OAI12HS $PINS O=n89 A1=n91 B1=n102 B2=n90
XU334 INV1S $PINS O=n91 I=n93
XU335 INV1S $PINS O=n90 I=n92
XU336 AOI12HS $PINS O=n179 A1=n181 B1=n189 B2=n180
XU337 AOI12HS $PINS O=n137 A1=n139 B1=n146 B2=n138
XU338 AOI12HS $PINS O=n114 A1=n116 B1=n124 B2=n115
XU339 OAI12HS $PINS O=n146 A1=n148 B1=n168 B2=n147
XU340 AOI12HS $PINS O=n75 A1=n77 B1=n124 B2=n76
XU341 OAI12HS $PINS O=n127 A1=n129 B1=n148 B2=n128
XU342 NR2 $PINS O=n126 I1=n128 I2=n147
XU343 AOI12HS $PINS O=n129 A1=n131 B1=n130 B2=n139
XU344 AOI12HS $PINS O=n102 A1=n104 B1=n124 B2=n103
XU345 INV1S $PINS O=n104 I=n106
XU346 INV1S $PINS O=n103 I=n105
XU348 ND2 $PINS O=n128 I1=n138 I2=n130
XU349 ND2 $PINS O=n78 I1=n92 I2=n80
XU350 ND2 $PINS O=n60 I1=n67 I2=n344
XU351 INV1S $PINS O=n189 I=n190
XU352 INV1S $PINS O=n198 I=n199
XU353 INV1S $PINS O=n59 I=n61
XU354 OAI12HS $PINS O=n42 A1=n44 B1=n45 B2=n43
XU355 OAI12HS $PINS O=n50 A1=n52 B1=FE_OFN84_n125 B2=n51
XU356 AOI12HS $PINS O=n52 A1=n54 B1=n77 B2=n53
XU357 NR2 $PINS O=n53 I1=n55 I2=n60
XU358 OAI12HS $PINS O=n93 A1=n95 B1=n94 B2=n100
XU359 OAI12HS $PINS O=n162 A1=n164 B1=n163 B2=n167
XU360 XOR2HS $PINS O=SUM[1] I1=n203 I2=n31
XU361 ND2 $PINS O=n31 I1=n234 I2=n201
XU362 INV1S $PINS O=n234 I=n200
XU363 OAI12HS $PINS O=n139 A1=n141 B1=n140 B2=n144
XU364 OAI12HS $PINS O=n181 A1=n183 B1=n182 B2=n188
XU365 OAI12HS $PINS O=n116 A1=n118 B1=n117 B2=n123
XU366 OAI12HS $PINS O=n199 A1=n201 B1=n200 B2=n203
XU367 OAI12HS $PINS O=n68 A1=n70 B1=n69 B2=n73
XU368 AOI12HS $PINS O=n45 A1=n47 B1=n50 B2=n345
XU369 INV1S $PINS O=n47 I=n49
XU370 AOI12HS $PINS O=n37 A1=n39 B1=n42 B2=n346
XU371 INV1S $PINS O=n39 I=n41
XU372 XOR2HS $PINS O=SUM[6] I1=n26 I2=n179
XU373 ND2 $PINS O=n26 I1=n229 I2=n178
XU374 INV1S $PINS O=n229 I=n177
XU375 XOR2HS $PINS O=SUM[8] I1=n24 I2=n168
XU376 INV1S $PINS O=n227 I=n166
XU377 XOR2HS $PINS O=SUM[12] I1=n20 I2=n145
XU378 ND2 $PINS O=n20 I1=n223 I2=n144
XU379 INV1S $PINS O=n223 I=n143
XU380 XOR2HS $PINS O=SUM[14] I1=n18 I2=n137
XU381 ND2 $PINS O=n18 I1=n221 I2=n136
XU382 INV1S $PINS O=n221 I=n135
XU383 XOR2HS $PINS O=SUM[18] I1=n14 I2=n114
XU384 ND2 $PINS O=n14 I1=n217 I2=n113
XU385 INV1S $PINS O=n217 I=n112
XU386 XNR2HS $PINS O=SUM[24] I1=n8 I2=n74
XU387 ND2 $PINS O=n8 I1=n211 I2=n73
XU388 INV1S $PINS O=n211 I=n72
XU389 XNR2HS $PINS O=SUM[4] I1=n28 I2=n189
XU390 INV1S $PINS O=n231 I=n187
XU391 XNR2HS $PINS O=SUM[10] I1=n22 I2=n158
XU392 ND2 $PINS O=n22 I1=n154 I2=n157
XU393 XNR2HS $PINS O=SUM[16] I1=n16 I2=n124
XU394 INV1S $PINS O=n219 I=n122
XU395 XNR2HS $PINS O=SUM[20] I1=n12 I2=n101
XU396 ND2 $PINS O=n12 I1=n215 I2=n100
XU397 INV1S $PINS O=n215 I=n99
XU398 XNR2HS $PINS O=SUM[22] I1=n10 I2=n89
XU399 ND2 $PINS O=n10 I1=n213 I2=n88
XU400 INV1S $PINS O=n213 I=n87
XU401 XOR2HS $PINS O=SUM[29] I1=n3 I2=n45
XU402 ND2 $PINS O=n3 I1=n206 I2=n44
XU403 INV1S $PINS O=n206 I=n43
XU404 ND2 $PINS O=n27 I1=n230 I2=n183
XU405 INV1S $PINS O=n230 I=n182
XU406 ND2 $PINS O=n11 I1=n214 I2=n95
XU407 INV1S $PINS O=n214 I=n94
XU408 XOR2HS $PINS O=SUM[31] I1=n1 I2=n37
XU409 ND2 $PINS O=n1 I1=n204 I2=n36
XU410 INV1S $PINS O=n204 I=n35
XU411 ND2 $PINS O=n21 I1=n224 I2=n152
XU412 INV1S $PINS O=n224 I=n151
XU413 ND2 $PINS O=n15 I1=n218 I2=n118
XU414 INV1S $PINS O=n218 I=n117
XU415 ND2 $PINS O=n9 I1=n212 I2=n83
XU416 INV1S $PINS O=n212 I=n82
XU417 ND2 $PINS O=n5 I1=n208 I2=n56
XU418 INV1S $PINS O=n208 I=n55
XU419 ND2 $PINS O=n6 I1=n344 I2=n65
XU420 XNR2HS $PINS O=SUM[7] I1=n25 I2=n176
XU421 ND2 $PINS O=n25 I1=n228 I2=n175
XU422 OAI12HS $PINS O=n176 A1=n178 B1=n179 B2=n177
XU423 INV1S $PINS O=n228 I=n174
XU424 ND2 $PINS O=n23 I1=n226 I2=n164
XU425 INV1S $PINS O=n226 I=n163
XU426 XNR2HS $PINS O=SUM[19] I1=n13 I2=n111
XU427 ND2 $PINS O=n13 I1=n216 I2=n110
XU428 OAI12HS $PINS O=n111 A1=n113 B1=n114 B2=n112
XU429 INV1S $PINS O=n216 I=n109
XU430 ND2 $PINS O=n7 I1=n210 I2=n70
XU431 INV1S $PINS O=n210 I=n69
XU432 XNR2HS $PINS O=SUM[30] I1=n2 I2=n42
XU433 ND2 $PINS O=n2 I1=n346 I2=n41
XU434 OAI12HS $PINS O=n169 A1=n171 B1=n190 B2=n170
XU435 AOI12HS $PINS O=n171 A1=n173 B1=n172 B2=n181
XU436 NR2 $PINS O=n172 I1=n174 I2=n177
XU437 OAI12HS $PINS O=n77 A1=n79 B1=n106 B2=n78
XU438 AOI12HS $PINS O=n79 A1=n81 B1=n80 B2=n93
XU439 OAI12HS $PINS O=n81 A1=n83 B1=n82 B2=n88
XU440 AOI12HS $PINS O=n148 A1=n150 B1=n149 B2=n162
XU441 OAI12HS $PINS O=n150 A1=n152 B1=n151 B2=n157
XU442 AOI12HS $PINS O=n190 A1=n192 B1=n191 B2=n199
XU443 OAI12HS $PINS O=n192 A1=n194 B1=n193 B2=n197
XU444 NR2 $PINS O=n191 I1=n193 I2=n196
XU445 AOI12HS $PINS O=n106 A1=n108 B1=n107 B2=n116
XU446 OAI12HS $PINS O=n108 A1=n110 B1=n109 B2=n113
XU447 NR2 $PINS O=n138 I1=n140 I2=n143
XU448 NR2 $PINS O=n67 I1=n69 I2=n72
XU449 AOI12HS $PINS O=n61 A1=n63 B1=n68 B2=n344
XU450 INV1S $PINS O=n63 I=n65
XU451 NR2 $PINS O=n180 I1=n182 I2=n187
XU452 NR2 $PINS O=n115 I1=n117 I2=n122
XU453 NR2 $PINS O=n130 I1=n132 I2=n135
XU454 NR2 $PINS O=n107 I1=n109 I2=n112
XU455 NR2 $PINS O=n149 I1=n151 I2=n156
XU456 NR2 $PINS O=n80 I1=n82 I2=n87
XU457 NR2 $PINS O=n161 I1=n163 I2=n166
XU458 NR2 $PINS O=n92 I1=n94 I2=n99
XU459 XNR2HS $PINS O=SUM[3] I1=n29 I2=n195
XU460 ND2 $PINS O=n29 I1=n232 I2=n194
XU461 OAI12HS $PINS O=n195 A1=n197 B1=n198 B2=n196
XU462 INV1S $PINS O=n232 I=n193
XU463 ND2 $PINS O=n19 I1=n222 I2=n141
XU464 INV1S $PINS O=n222 I=n140
XU465 XNR2HS $PINS O=SUM[15] I1=n17 I2=n134
XU466 ND2 $PINS O=n17 I1=n220 I2=n133
XU467 OAI12HS $PINS O=n134 A1=n136 B1=n137 B2=n135
XU468 INV1S $PINS O=n220 I=n132
XU469 OAI12HS $PINS O=n173 A1=n175 B1=n174 B2=n178
XU470 OAI12HS $PINS O=n131 A1=n133 B1=n132 B2=n136
XU471 OAI12HS $PINS O=n54 A1=n56 B1=n61 B2=n55
XU472 XOR2HS $PINS O=SUM[2] I1=n30 I2=n198
XU473 ND2 $PINS O=n30 I1=n233 I2=n197
XU474 INV1S $PINS O=n233 I=n196
XU475 XNR2HS $PINS O=SUM[28] I1=n4 I2=n50
XU476 ND2 $PINS O=n4 I1=n345 I2=n49
XU477 INV1S $PINS O=n154 I=n156
XU478 INV1S $PINS O=n186 I=n188
XU479 INV1S $PINS O=n155 I=n157
XU480 INV1S $PINS O=n121 I=n123
XU481 INV1S $PINS O=n98 I=n100
XU482 INV1S $PINS O=n86 I=n88
XU483 NR2 $PINS O=n140 I1=A[13] I2=B[13]
XU484 NR2 $PINS O=n94 I1=A[21] I2=B[21]
XU485 NR2 $PINS O=n182 I1=A[5] I2=B[5]
XU486 NR2 $PINS O=n193 I1=A[3] I2=B[3]
XU487 NR2 $PINS O=n174 I1=A[7] I2=B[7]
XU488 NR2 $PINS O=n132 I1=A[15] I2=B[15]
XU489 NR2 $PINS O=n82 I1=A[23] I2=B[23]
XU490 NR2 $PINS O=n163 I1=A[9] I2=B[9]
XU491 NR2 $PINS O=n151 I1=A[11] I2=B[11]
XU492 NR2 $PINS O=n117 I1=A[17] I2=B[17]
XU493 NR2 $PINS O=n109 I1=A[19] I2=B[19]
XU494 NR2 $PINS O=n69 I1=A[25] I2=B[25]
XU495 NR2 $PINS O=n196 I1=A[2] I2=B[2]
XU496 NR2 $PINS O=n177 I1=A[6] I2=B[6]
XU497 NR2 $PINS O=n166 I1=A[8] I2=B[8]
XU498 NR2 $PINS O=n143 I1=A[12] I2=B[12]
XU499 NR2 $PINS O=n135 I1=A[14] I2=B[14]
XU500 NR2 $PINS O=n112 I1=A[18] I2=B[18]
XU501 NR2 $PINS O=n72 I1=A[24] I2=B[24]
XU502 NR2 $PINS O=n187 I1=A[4] I2=B[4]
XU503 NR2 $PINS O=n156 I1=A[10] I2=B[10]
XU504 NR2 $PINS O=n122 I1=A[16] I2=B[16]
XU505 NR2 $PINS O=n99 I1=A[20] I2=B[20]
XU506 NR2 $PINS O=n87 I1=A[22] I2=B[22]
XU507 NR2 $PINS O=n200 I1=A[1] I2=B[1]
XU508 ND2 $PINS O=n167 I1=B[8] I2=A[8]
XU509 ND2 $PINS O=n73 I1=B[24] I2=A[24]
XU510 ND2 $PINS O=n188 I1=B[4] I2=A[4]
XU511 ND2 $PINS O=n123 I1=B[16] I2=A[16]
XU512 ND2 $PINS O=n100 I1=B[20] I2=A[20]
XU513 ND2S $PINS O=n201 I1=B[1] I2=A[1]
XU514 ND2 $PINS O=n70 I1=B[25] I2=A[25]
XU515 NR2 $PINS O=n55 I1=A[27] I2=B[27]
XU516 NR2 $PINS O=n43 I1=A[29] I2=B[29]
XU517 NR2 $PINS O=n35 I1=A[31] I2=B[31]
XU518 ND2 $PINS O=n44 I1=B[29] I2=A[29]
XU519 ND2 $PINS O=n36 I1=B[31] I2=A[31]
XU520 ND2 $PINS O=n56 I1=B[27] I2=A[27]
XU521 ND2 $PINS O=n49 I1=B[28] I2=A[28]
XU522 ND2 $PINS O=n41 I1=B[30] I2=A[30]
XU523 ND2 $PINS O=n65 I1=B[26] I2=A[26]
XU524 OAI12HS $PINS O=n34 A1=n36 B1=n37 B2=n35
.ENDS

.SUBCKT mult_DW01_add_5 A[33] A[32] A[31] A[30] A[29] A[28] A[27] A[26] A[25]
+ A[24] A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12]
+ A[11] A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[33] B[32]
+ B[31] B[30] B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19]
+ B[18] B[17] B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6]
+ B[5] B[4] B[3] B[2] B[1] B[0] CI SUM[33] SUM[32] SUM[31] SUM[30] SUM[29]
+ SUM[28] SUM[27] SUM[26] SUM[25] SUM[24] SUM[23] SUM[22] SUM[21] SUM[20]
+ SUM[19] SUM[18] SUM[17] SUM[16] SUM[15] SUM[14] SUM[13] SUM[12] SUM[11]
+ SUM[10] SUM[9] SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2] SUM[1] SUM[0]
+ CO
XFE_RC_2336_0 OAI12H $PINS O=n60 A1=n62 B1=n95 B2=n61
XFE_RC_2265_0 AOI12H $PINS O=n95 A1=n97 B1=n132 B2=n96
XU3 HA1 $PINS S=SUM[32] C=n33 A=A[32] B=n34
XU286 OR2 $PINS O=n358 I1=n95 I2=n77
XU287 ND2P $PINS O=n76 I1=n358 I2=n78
XU289 AOI12H $PINS O=n71 A1=n73 B1=n76 B2=n72
XU291 ND2 $PINS O=n98 I1=n105 I2=n100
XU292 ND2S $PINS O=n110 I1=n112 I2=n124
XU293 ND2S $PINS O=n65 I1=n72 I2=n67
XU294 ND2S $PINS O=n159 I1=n161 I2=n168
XU295 ND2S $PINS O=n77 I1=n79 I2=n91
XU296 ND2S $PINS O=n44 I1=n51 I2=n46
XU297 ND2S $PINS O=n174 I1=n176 I2=n184
XU298 ND2S $PINS O=n199 I1=n201 I2=n206
XU299 ND2S $PINS O=n182 I1=A[8] I2=B[8]
XU300 ND2S $PINS O=n59 I1=A[28] I2=B[28]
XU301 ND2S $PINS O=n141 I1=A[15] I2=B[15]
XU302 ND2S $PINS O=n87 I1=A[24] I2=B[24]
XU303 ND2S $PINS O=n120 I1=A[19] I2=B[19]
XU304 ND2S $PINS O=n218 I1=A[1] I2=B[1]
XU305 ND2S $PINS O=n115 I1=A[20] I2=B[20]
XU306 ND2S $PINS O=n157 I1=A[12] I2=B[12]
XU307 ND2S $PINS O=n146 I1=A[14] I2=B[14]
XU308 ND2S $PINS O=n127 I1=A[18] I2=B[18]
XU309 ND2S $PINS O=n138 I1=A[16] I2=B[16]
XU310 ND2S $PINS O=n193 I1=A[6] I2=B[6]
XU311 ND2S $PINS O=n54 I1=A[29] I2=B[29]
XU312 ND2S $PINS O=n40 I1=A[31] I2=B[31]
XU313 ND2S $PINS O=n215 I1=A[2] I2=B[2]
XU314 ND2S $PINS O=n204 I1=A[4] I2=B[4]
XU315 ND2S $PINS O=n103 I1=A[22] I2=B[22]
XU316 ND2S $PINS O=n49 I1=A[30] I2=B[30]
XU317 ND2S $PINS O=n171 I1=A[10] I2=B[10]
XU318 ND2S $PINS O=n209 I1=A[3] I2=B[3]
XU319 ND2S $PINS O=n187 I1=A[7] I2=B[7]
XU320 ND2S $PINS O=n32 I1=n250 I2=n218
XU321 ND2S $PINS O=n35 I1=n63 I2=n37
XU322 NR2 $PINS O=n63 I1=n65 I2=n77
XU323 INV1S $PINS O=n62 I=n64
XU324 INV1S $PINS O=n61 I=n63
XU325 OAI12HS $PINS O=n121 A1=n123 B1=n131 B2=n122
XU326 INV1S $PINS O=n123 I=n125
XU327 INV1S $PINS O=n122 I=n124
XU328 OAI12HS $PINS O=n109 A1=n111 B1=n131 B2=n110
XU329 OAI12HS $PINS O=n88 A1=n94 B1=n95 B2=n93
XU330 AOI12HS $PINS O=n142 A1=n144 B1=n152 B2=n143
XU331 INV1S $PINS O=n131 I=n132
XU332 AOI12HS $PINS O=n50 A1=n52 B1=n60 B2=n51
XU333 AOI12HS $PINS O=n104 A1=n106 B1=n109 B2=n105
XU334 AOI12HS $PINS O=n41 A1=n43 B1=n60 B2=n42
XU335 INV1S $PINS O=n42 I=n44
XU336 INV1S $PINS O=n43 I=n45
XU337 INV1S $PINS O=n152 I=n153
XU339 NR2 $PINS O=n96 I1=n98 I2=n110
XU340 OAI12HS $PINS O=n97 A1=n99 B1=n111 B2=n98
XU341 AOI12HS $PINS O=n183 A1=n185 B1=n188 B2=n184
XU342 OAI12HS $PINS O=n165 A1=n171 B1=n172 B2=n170
XU343 OAI12HS $PINS O=n158 A1=n160 B1=n172 B2=n159
XU344 INV1S $PINS O=n172 I=n173
XU345 INV1S $PINS O=n188 I=n189
XU346 INV1S $PINS O=n197 I=n198
XU347 AOI12HS $PINS O=n205 A1=n207 B1=n210 B2=n206
XU348 INV1S $PINS O=n210 I=n211
XU349 OAI12HS $PINS O=n125 A1=n127 B1=n126 B2=n130
XU350 OAI12HS $PINS O=n144 A1=n146 B1=n145 B2=n151
XU351 OAI12HS $PINS O=n132 A1=n134 B1=n153 B2=n133
XU352 ND2 $PINS O=n133 I1=n135 I2=n143
XU353 AOI12HS $PINS O=n134 A1=n136 B1=n135 B2=n144
XU354 NR2 $PINS O=n135 I1=n137 I2=n140
XU355 OAI12HS $PINS O=n198 A1=n200 B1=n199 B2=n211
XU356 AOI12HS $PINS O=n200 A1=n202 B1=n201 B2=n207
XU357 INV1S $PINS O=n201 I=n203
XU358 OAI12HS $PINS O=n52 A1=n54 B1=n53 B2=n59
XU359 OAI12HS $PINS O=n64 A1=n66 B1=n78 B2=n65
XU360 AOI12HS $PINS O=n66 A1=n68 B1=n67 B2=n73
XU361 INV1S $PINS O=n68 I=n70
XU362 OAI12HS $PINS O=n173 A1=n175 B1=n189 B2=n174
XU363 AOI12HS $PINS O=n175 A1=n177 B1=n176 B2=n185
XU364 NR2 $PINS O=n176 I1=n181 I2=n178
XU365 AOI12HS $PINS O=n211 A1=n213 B1=n216 B2=n212
XU366 INV1S $PINS O=n213 I=n215
XU367 INV1S $PINS O=n212 I=n214
XU368 AOI12HS $PINS O=n111 A1=n113 B1=n112 B2=n125
XU369 OAI12HS $PINS O=n113 A1=n115 B1=n114 B2=n120
XU370 AOI12HS $PINS O=n78 A1=n80 B1=n79 B2=n92
XU371 OAI12HS $PINS O=n80 A1=n82 B1=n81 B2=n87
XU372 AOI12HS $PINS O=n153 A1=n155 B1=n173 B2=n154
XU373 NR2 $PINS O=n154 I1=n156 I2=n159
XU374 OAI12HS $PINS O=n155 A1=n157 B1=n160 B2=n156
XU375 AOI12HS $PINS O=n189 A1=n191 B1=n190 B2=n198
XU376 NR2 $PINS O=n190 I1=n195 I2=n192
XU377 OAI12HS $PINS O=n191 A1=n193 B1=n192 B2=n196
XU378 AOI12HS $PINS O=n160 A1=n162 B1=n161 B2=n169
XU379 INV1S $PINS O=n162 I=n164
XU380 AOI12HS $PINS O=n45 A1=n47 B1=n52 B2=n46
XU381 INV1S $PINS O=n47 I=n49
XU382 NR2 $PINS O=n143 I1=n145 I2=n150
XU383 NR2 $PINS O=n37 I1=n39 I2=n44
XU384 NR2 $PINS O=n51 I1=n58 I2=n53
XU385 NR2 $PINS O=n124 I1=n129 I2=n126
XU386 NR2 $PINS O=n79 I1=n81 I2=n86
XU387 NR2 $PINS O=n112 I1=n114 I2=n119
XU388 OAI12HS $PINS O=n139 A1=n141 B1=n142 B2=n140
XU389 AOI12HS $PINS O=n55 A1=n57 B1=n60 B2=n56
XU390 INV1S $PINS O=n57 I=n59
XU391 INV1S $PINS O=n56 I=n58
XU392 AOI12HS $PINS O=n116 A1=n118 B1=n121 B2=n117
XU393 INV1S $PINS O=n118 I=n120
XU394 INV1S $PINS O=n117 I=n119
XU395 AOI12HS $PINS O=n83 A1=n85 B1=n88 B2=n84
XU396 INV1S $PINS O=n85 I=n87
XU397 INV1S $PINS O=n84 I=n86
XU398 OAI12HS $PINS O=n136 A1=n138 B1=n141 B2=n137
XU399 OAI12HS $PINS O=n177 A1=n179 B1=n178 B2=n182
XU400 OAI12HS $PINS O=n38 A1=n40 B1=n45 B2=n39
XU401 AOI12HS $PINS O=n99 A1=n101 B1=n106 B2=n100
XU402 INV1S $PINS O=n101 I=n103
XU403 INV1S $PINS O=n169 I=n171
XU404 INV1S $PINS O=n92 I=n94
XU405 INV1S $PINS O=n73 I=n75
XU406 INV1S $PINS O=n207 I=n209
XU407 INV1S $PINS O=n185 I=n187
XU408 INV1S $PINS O=n100 I=n102
XU409 INV1S $PINS O=n206 I=n208
XU410 INV1S $PINS O=n184 I=n186
XU411 INV1S $PINS O=n46 I=n48
XU412 INV1S $PINS O=n106 I=n108
XU413 INV1S $PINS O=n105 I=n107
XU414 INV1S $PINS O=n72 I=n74
XU415 INV1S $PINS O=n67 I=n69
XU416 INV1S $PINS O=n168 I=n170
XU417 INV1S $PINS O=n91 I=n93
XU418 INV1S $PINS O=n161 I=n163
XU419 INV1S $PINS O=n202 I=n204
XU420 OAI12HS $PINS O=n128 A1=n130 B1=n131 B2=n129
XU421 OAI12HS $PINS O=n180 A1=n182 B1=n183 B2=n181
XU422 OAI12HS $PINS O=n194 A1=n196 B1=n197 B2=n195
XU423 AOI12HS $PINS O=n147 A1=n149 B1=n152 B2=n148
XU424 INV1S $PINS O=n149 I=n151
XU425 INV1S $PINS O=n148 I=n150
XU426 OR2B1S $PINS O=n28 I1=n195 B1=n196
XU427 OR2B1S $PINS O=n16 I1=n129 B1=n130
XU428 OR2B1S $PINS O=n9 I1=n86 B1=n87
XU429 OR2B1S $PINS O=n20 I1=n150 B1=n151
XU430 OR2B1S $PINS O=n14 I1=n119 B1=n120
XU431 OR2B1S $PINS O=n5 I1=n58 B1=n59
XU432 OR2B1S $PINS O=n18 I1=n140 B1=n141
XU433 OR2B1S $PINS O=n21 I1=n156 B1=n157
XU434 OR2B1S $PINS O=n15 I1=n126 B1=n127
XU435 OR2B1S $PINS O=n17 I1=n137 B1=n138
XU436 OR2B1S $PINS O=n19 I1=n145 B1=n146
XU437 OR2B1S $PINS O=n24 I1=n178 B1=n179
XU438 OR2B1S $PINS O=n13 I1=n114 B1=n115
XU439 OR2B1S $PINS O=n4 I1=n53 B1=n54
XU440 OR2B1S $PINS O=n2 I1=n39 B1=n40
XU441 OR2B1S $PINS O=n8 I1=n81 B1=n82
XU442 OR2B1S $PINS O=n22 I1=n163 B1=n164
XU443 OR2B1S $PINS O=n12 I1=n107 B1=n108
XU444 OR2B1S $PINS O=n7 I1=n74 B1=n75
XU445 OR2B1S $PINS O=n26 I1=n186 B1=n187
XU446 OR2B1S $PINS O=n23 I1=n170 B1=n171
XU447 OR2B1S $PINS O=n11 I1=n102 B1=n103
XU448 OR2B1S $PINS O=n10 I1=n93 B1=n94
XU449 OR2B1S $PINS O=n6 I1=n69 B1=n70
XU450 OR2B1S $PINS O=n3 I1=n48 B1=n49
XU451 OR2B1S $PINS O=n25 I1=n181 B1=n182
XU452 OR2B1S $PINS O=n27 I1=n192 B1=n193
XU453 OR2B1S $PINS O=n31 I1=n214 B1=n215
XU454 OR2B1S $PINS O=n30 I1=n208 B1=n209
XU455 OR2B1S $PINS O=n29 I1=n203 B1=n204
XU456 NR2 $PINS O=n137 I1=B[16] I2=A[16]
XU457 NR2 $PINS O=n39 I1=B[31] I2=A[31]
XU458 NR2 $PINS O=n181 I1=B[8] I2=A[8]
XU459 NR2 $PINS O=n129 I1=B[17] I2=A[17]
XU460 NR2 $PINS O=n195 I1=B[5] I2=A[5]
XU461 NR2 $PINS O=n156 I1=B[12] I2=A[12]
XU462 NR2 $PINS O=n140 I1=B[15] I2=A[15]
XU463 NR2 $PINS O=n81 I1=B[25] I2=A[25]
XU464 NR2 $PINS O=n145 I1=B[14] I2=A[14]
XU465 NR2 $PINS O=n114 I1=B[20] I2=A[20]
XU466 NR2 $PINS O=n150 I1=B[13] I2=A[13]
XU467 NR2 $PINS O=n119 I1=B[19] I2=A[19]
XU468 NR2 $PINS O=n86 I1=B[24] I2=A[24]
XU469 NR2 $PINS O=n53 I1=B[29] I2=A[29]
XU470 NR2 $PINS O=n178 I1=B[9] I2=A[9]
XU471 NR2 $PINS O=n126 I1=B[18] I2=A[18]
XU472 NR2 $PINS O=n192 I1=B[6] I2=A[6]
XU473 NR2 $PINS O=n48 I1=B[30] I2=A[30]
XU474 NR2 $PINS O=n208 I1=B[3] I2=A[3]
XU475 NR2 $PINS O=n186 I1=B[7] I2=A[7]
XU476 NR2 $PINS O=n203 I1=B[4] I2=A[4]
XU477 NR2 $PINS O=n102 I1=B[22] I2=A[22]
XU478 NR2 $PINS O=n170 I1=B[10] I2=A[10]
XU479 NR2 $PINS O=n163 I1=B[11] I2=A[11]
XU480 NR2 $PINS O=n93 I1=B[23] I2=A[23]
XU481 NR2 $PINS O=n74 I1=B[26] I2=A[26]
XU482 NR2 $PINS O=n69 I1=B[27] I2=A[27]
XU483 NR2 $PINS O=n214 I1=B[2] I2=A[2]
XU484 NR2 $PINS O=n107 I1=B[21] I2=A[21]
XU485 NR2 $PINS O=n217 I1=B[1] I2=A[1]
XU486 OAI12HS $PINS O=n216 A1=n218 B1=n217 B2=n219
XU487 ND2 $PINS O=n196 I1=A[5] I2=B[5]
XU488 ND2 $PINS O=n130 I1=A[17] I2=B[17]
XU489 ND2 $PINS O=n151 I1=A[13] I2=B[13]
XU490 ND2 $PINS O=n179 I1=A[9] I2=B[9]
XU491 ND2 $PINS O=n82 I1=A[25] I2=B[25]
XU492 ND2 $PINS O=n164 I1=A[11] I2=B[11]
XU493 ND2 $PINS O=n108 I1=A[21] I2=B[21]
XU494 ND2 $PINS O=n94 I1=A[23] I2=B[23]
XU495 ND2 $PINS O=n70 I1=A[27] I2=B[27]
XU496 ND2 $PINS O=n75 I1=A[26] I2=B[26]
XU497 NR2 $PINS O=n58 I1=B[28] I2=A[28]
XU498 XOR2HS $PINS O=SUM[1] I1=n219 I2=n32
XU499 INV1S $PINS O=n250 I=n217
XU500 OAI12HS $PINS O=n34 A1=n36 B1=n95 B2=n35
XU501 AOI12HS $PINS O=n36 A1=n38 B1=n64 B2=n37
XU502 ND2S $PINS O=n219 I1=A[0] I2=B[0]
XU503 XOR2HS $PINS O=SUM[23] I1=n10 I2=n95
XU504 XOR2HS $PINS O=SUM[30] I1=n3 I2=n50
XU505 XOR2HS $PINS O=SUM[22] I1=n11 I2=n104
XU506 XNR2HS $PINS O=SUM[16] I1=n17 I2=n139
XU507 XNR2HS $PINS O=SUM[24] I1=n9 I2=n88
XU508 XOR2HS $PINS O=SUM[20] I1=n13 I2=n116
XU509 XNR2HS $PINS O=SUM[26] I1=n7 I2=n76
XU510 XNR2HS $PINS O=SUM[28] I1=n5 I2=n60
XU511 XOR2HS $PINS O=SUM[31] I1=n2 I2=n41
XU512 XOR2HS $PINS O=SUM[25] I1=n8 I2=n83
XU513 XOR2HS $PINS O=SUM[27] I1=n6 I2=n71
XU514 XOR2HS $PINS O=SUM[29] I1=n4 I2=n55
XU515 XOR2HS $PINS O=SUM[33] I1=A[33] I2=n33
XU516 XOR2HS $PINS O=SUM[14] I1=n19 I2=n147
XU517 XNR2HS $PINS O=SUM[6] I1=n27 I2=n194
XU518 XOR2HS $PINS O=SUM[8] I1=n25 I2=n183
XU519 XOR2HS $PINS O=SUM[10] I1=n23 I2=n172
XU520 XNR2HS $PINS O=SUM[12] I1=n21 I2=n158
XU521 XNR2HS $PINS O=SUM[18] I1=n15 I2=n128
XU522 XOR2HS $PINS O=SUM[5] I1=n28 I2=n197
XU523 XNR2HS $PINS O=SUM[7] I1=n26 I2=n188
XU524 XNR2HS $PINS O=SUM[9] I1=n24 I2=n180
XU525 XNR2HS $PINS O=SUM[11] I1=n22 I2=n165
XU526 XNR2HS $PINS O=SUM[13] I1=n20 I2=n152
XU527 XOR2HS $PINS O=SUM[15] I1=n18 I2=n142
XU528 XOR2HS $PINS O=SUM[17] I1=n16 I2=n131
XU529 XNR2HS $PINS O=SUM[19] I1=n14 I2=n121
XU530 XNR2HS $PINS O=SUM[21] I1=n12 I2=n109
XU531 XNR2HS $PINS O=SUM[2] I1=n216 I2=n31
XU532 XOR2HS $PINS O=SUM[4] I1=n29 I2=n205
XU533 XNR2HS $PINS O=SUM[3] I1=n30 I2=n210
.ENDS

.SUBCKT mult i_rst mult_in_0[31] mult_in_0[30] mult_in_0[29] mult_in_0[28]
+ mult_in_0[27] mult_in_0[26] mult_in_0[25] mult_in_0[24] mult_in_0[23]
+ mult_in_0[22] mult_in_0[21] mult_in_0[20] mult_in_0[19] mult_in_0[18]
+ mult_in_0[17] mult_in_0[16] mult_in_0[15] mult_in_0[14] mult_in_0[13]
+ mult_in_0[12] mult_in_0[11] mult_in_0[10] mult_in_0[9] mult_in_0[8]
+ mult_in_0[7] mult_in_0[6] mult_in_0[5] mult_in_0[4] mult_in_0[3] mult_in_0[2]
+ mult_in_0[1] mult_in_0[0] mult_in_1[31] mult_in_1[30] mult_in_1[29]
+ mult_in_1[28] mult_in_1[27] mult_in_1[26] mult_in_1[25] mult_in_1[24]
+ mult_in_1[23] mult_in_1[22] mult_in_1[21] mult_in_1[20] mult_in_1[19]
+ mult_in_1[18] mult_in_1[17] mult_in_1[16] mult_in_1[15] mult_in_1[14]
+ mult_in_1[13] mult_in_1[12] mult_in_1[11] mult_in_1[10] mult_in_1[9]
+ mult_in_1[8] mult_in_1[7] mult_in_1[6] mult_in_1[5] mult_in_1[4] mult_in_1[3]
+ mult_in_1[2] mult_in_1[1] mult_in_1[0] prime[31] prime[30] prime[29]
+ prime[28] prime[27] prime[26] prime[25] prime[24] prime[23] prime[22]
+ prime[21] prime[20] prime[19] prime[18] prime[17] prime[16] prime[15]
+ prime[14] prime[13] prime[12] prime[11] prime[10] prime[9] prime[8] prime[7]
+ prime[6] prime[5] prime[4] prime[3] prime[2] prime[1] prime[0] sel_mult
+ mult_out[31] mult_out[30] mult_out[29] mult_out[28] mult_out[27] mult_out[26]
+ mult_out[25] mult_out[24] mult_out[23] mult_out[22] mult_out[21] mult_out[20]
+ mult_out[19] mult_out[18] mult_out[17] mult_out[16] mult_out[15] mult_out[14]
+ mult_out[13] mult_out[12] mult_out[11] mult_out[10] mult_out[9] mult_out[8]
+ mult_out[7] mult_out[6] mult_out[5] mult_out[4] mult_out[3] mult_out[2]
+ mult_out[1] mult_out[0] done_mult FE_OFN8_FE_DBTN1_i_i_rst
+ FE_OFN3_FE_DBTN1_i_i_rst FE_OFN1_FE_DBTN1_i_i_rst FE_OFN164_n FE_OFN171_n310
+ FE_OCPN174_FE_OFN338_n310 FE_OCPN176_FE_OFN86_n312
+ FE_OFN301_FE_OFN5_FE_DBTN1_i_i_rst FE_OFN311_FE_OFN2_FE_DBTN1_i_i_rst
+ FE_OFN310_FE_OFN2_FE_DBTN1_i_i_rst i_clk_clone4 i_clk_clone3 i_clk_clone2
+ i_clk_clone1 i_clk
XFE_PHC1572_N38 BUF1CK $PINS O=FE_PHN1572_N38 I=N38
XFE_PHC1188_mult_out_7 BUF1CK $PINS O=FE_PHN1188_mult_out_7 I=mult_out[7]
XFE_PHC1170_mult_out_31 BUF1CK $PINS O=FE_PHN1170_mult_out_31 I=mult_out[31]
XFE_PHC1169_mult_out_13 BUF1CK $PINS O=FE_PHN1169_mult_out_13 I=mult_out[13]
XFE_PHC1166_mult_out_5 BUF1CK $PINS O=FE_PHN1166_mult_out_5 I=mult_out[5]
XFE_PHC1165_mult_out_15 BUF1CK $PINS O=FE_PHN1165_mult_out_15 I=mult_out[15]
XFE_PHC1163_mult_out_21 BUF1CK $PINS O=FE_PHN1163_mult_out_21 I=mult_out[21]
XFE_PHC1161_mult_out_27 BUF1CK $PINS O=FE_PHN1161_mult_out_27 I=mult_out[27]
XFE_PHC1158_mult_out_28 BUF1CK $PINS O=FE_PHN1158_mult_out_28 I=mult_out[28]
XFE_PHC1157_mult_out_17 BUF1CK $PINS O=FE_PHN1157_mult_out_17 I=mult_out[17]
XFE_PHC1153_mult_out_30 BUF1CK $PINS O=FE_PHN1153_mult_out_30 I=mult_out[30]
XFE_PHC1148_mult_out_20 BUF1CK $PINS O=FE_PHN1148_mult_out_20 I=mult_out[20]
XFE_PHC1146_mult_out_6 BUF1CK $PINS O=FE_PHN1146_mult_out_6 I=mult_out[6]
XFE_PHC1145_mult_out_29 BUF1CK $PINS O=FE_PHN1145_mult_out_29 I=mult_out[29]
XFE_PHC1144_mult_out_4 BUF1CK $PINS O=FE_PHN1144_mult_out_4 I=mult_out[4]
XFE_PHC1142_mult_out_8 BUF1CK $PINS O=FE_PHN1142_mult_out_8 I=mult_out[8]
XFE_PHC1139_mult_out_19 BUF1CK $PINS O=FE_PHN1139_mult_out_19 I=mult_out[19]
XFE_PHC1137_mult_out_25 BUF1CK $PINS O=FE_PHN1137_mult_out_25 I=mult_out[25]
XFE_PHC1133_mult_out_14 BUF1CK $PINS O=FE_PHN1133_mult_out_14 I=mult_out[14]
XFE_PHC1129_mult_out_11 BUF1CK $PINS O=FE_PHN1129_mult_out_11 I=mult_out[11]
XFE_PHC1127_mult_out_16 BUF1CK $PINS O=FE_PHN1127_mult_out_16 I=mult_out[16]
XFE_PHC1125_mult_out_0 BUF1CK $PINS O=FE_PHN1125_mult_out_0 I=mult_out[0]
XFE_PHC1122_mult_out_3 BUF1CK $PINS O=FE_PHN1122_mult_out_3 I=mult_out[3]
XFE_PHC1120_mult_out_10 BUF1CK $PINS O=FE_PHN1120_mult_out_10 I=mult_out[10]
XFE_PHC1118_mult_out_22 BUF1CK $PINS O=FE_PHN1118_mult_out_22 I=mult_out[22]
XFE_PHC1116_mult_out_18 BUF1CK $PINS O=FE_PHN1116_mult_out_18 I=mult_out[18]
XFE_PHC1110_mult_out_12 BUF1CK $PINS O=FE_PHN1110_mult_out_12 I=mult_out[12]
XFE_PHC1106_mult_out_1 BUF1CK $PINS O=FE_PHN1106_mult_out_1 I=mult_out[1]
XFE_PHC1099_N38 BUF1S $PINS O=FE_PHN1099_N38 I=FE_PHN1572_N38
XFE_PHC1093_mult_out_26 BUF1CK $PINS O=FE_PHN1093_mult_out_26 I=mult_out[26]
XFE_PHC1070_mult_out_23 BUF1CK $PINS O=FE_PHN1070_mult_out_23 I=mult_out[23]
XFE_PHC1048_mult_out_24 BUF1CK $PINS O=FE_PHN1048_mult_out_24 I=mult_out[24]
XFE_PHC1028_mult_out_9 BUF1CK $PINS O=FE_PHN1028_mult_out_9 I=mult_out[9]
XFE_PHC1017_mult_out_2 BUF1CK $PINS O=FE_PHN1017_mult_out_2 I=mult_out[2]
XFE_PHC992_mult_out_mid_32 BUF1CK $PINS O=FE_PHN992_mult_out_mid_32
+ I=mult_out_mid[32]
XFE_OFC599_n4 BUF2CK $PINS O=FE_OFN632_n4 I=n4
XFE_OFC526_n200 BUF2CK $PINS O=FE_OFN559_n200 I=n200
XFE_OFC525_n7 BUF2CK $PINS O=FE_OFN558_n7 I=n7
XFE_OFC524_n2 BUF2CK $PINS O=FE_OFN557_n2 I=n2
XFE_DBTC95_N11 INV1S $PINS O=FE_DBTN95_N11 I=N11
Xsub_3283 mult_DW01_sub_0 $PINS A[32]=mult_out_mid[32] A[31]=mult_out[31]
+ A[30]=mult_out[30] A[29]=mult_out[29] A[28]=mult_out[28] A[27]=mult_out[27]
+ A[26]=mult_out[26] A[25]=mult_out[25] A[24]=mult_out[24] A[23]=mult_out[23]
+ A[22]=mult_out[22] A[21]=mult_out[21] A[20]=mult_out[20] A[19]=mult_out[19]
+ A[18]=mult_out[18] A[17]=mult_out[17] A[16]=mult_out[16] A[15]=mult_out[15]
+ A[14]=mult_out[14] A[13]=mult_out[13] A[12]=mult_out[12] A[11]=mult_out[11]
+ A[10]=mult_out[10] A[9]=mult_out[9] A[8]=mult_out[8] A[7]=mult_out[7]
+ A[6]=mult_out[6] A[5]=mult_out[5] A[4]=mult_out[4] A[3]=mult_out[3]
+ A[2]=mult_out[2] A[1]=mult_out[1] A[0]=mult_out[0] B[32]=net25629
+ B[31]=prime[31] B[30]=prime[30] B[29]=prime[29] B[28]=prime[28] B[27]=prime[27]
+ B[26]=prime[26] B[25]=prime[25] B[24]=prime[24] B[23]=prime[23] B[22]=prime[22]
+ B[21]=prime[21] B[20]=prime[20] B[19]=prime[19] B[18]=prime[18] B[17]=prime[17]
+ B[16]=prime[16] B[15]=prime[15] B[14]=prime[14] B[13]=prime[13] B[12]=prime[12]
+ B[11]=prime[11] B[10]=prime[10] B[9]=prime[9] B[8]=prime[8] B[7]=prime[7]
+ B[6]=prime[6] B[5]=prime[5] B[4]=prime[4] B[3]=prime[3] B[2]=FE_OFN164_n
+ B[1]=prime[1] B[0]=FE_OFN171_n310 CI=net25629 DIFF[32]=N97 DIFF[31]=N96
+ DIFF[30]=N95 DIFF[29]=N94 DIFF[28]=N93 DIFF[27]=N92 DIFF[26]=N91 DIFF[25]=N90
+ DIFF[24]=N89 DIFF[23]=N88 DIFF[22]=N87 DIFF[21]=N86 DIFF[20]=N85 DIFF[19]=N84
+ DIFF[18]=N83 DIFF[17]=N82 DIFF[16]=N81 DIFF[15]=N80 DIFF[14]=N79 DIFF[13]=N78
+ DIFF[12]=N77 DIFF[11]=N76 DIFF[10]=N75 DIFF[9]=N74 DIFF[8]=N73 DIFF[7]=N72
+ DIFF[6]=N71 DIFF[5]=N70 DIFF[4]=N69 DIFF[3]=N68 DIFF[2]=N67 DIFF[1]=N66
+ DIFF[0]=N65 FE_OFN170_mult_out_0=mult_out[0]
+ FE_OCPN175_FE_OFN338_n310=FE_OCPN174_FE_OFN338_n310
Xgt_3282 mult_DW_cmp_0 $PINS A[32]=mult_out_mid[32] A[31]=mult_out[31]
+ A[30]=mult_out[30] A[29]=mult_out[29] A[28]=mult_out[28] A[27]=mult_out[27]
+ A[26]=mult_out[26] A[25]=mult_out[25] A[24]=mult_out[24] A[23]=mult_out[23]
+ A[22]=mult_out[22] A[21]=mult_out[21] A[20]=mult_out[20] A[19]=mult_out[19]
+ A[18]=mult_out[18] A[17]=mult_out[17] A[16]=mult_out[16] A[15]=mult_out[15]
+ A[14]=mult_out[14] A[13]=mult_out[13] A[12]=mult_out[12] A[11]=mult_out[11]
+ A[10]=mult_out[10] A[9]=mult_out[9] A[8]=mult_out[8] A[7]=mult_out[7]
+ A[6]=mult_out[6] A[5]=mult_out[5] A[4]=mult_out[4] A[3]=mult_out[3]
+ A[2]=mult_out[2] A[1]=mult_out[1] A[0]=mult_out[0] B[32]=net25629
+ B[31]=prime[31] B[30]=prime[30] B[29]=prime[29] B[28]=prime[28] B[27]=prime[27]
+ B[26]=prime[26] B[25]=prime[25] B[24]=prime[24] B[23]=prime[23] B[22]=prime[22]
+ B[21]=prime[21] B[20]=prime[20] B[19]=prime[19] B[18]=prime[18] B[17]=prime[17]
+ B[16]=prime[16] B[15]=prime[15] B[14]=prime[14] B[13]=prime[13] B[12]=prime[12]
+ B[11]=prime[11] B[10]=prime[10] B[9]=prime[9] B[8]=prime[8] B[7]=prime[7]
+ B[6]=prime[6] B[5]=prime[5] B[4]=prime[4] B[3]=prime[3] B[2]=prime[2]
+ B[1]=FE_OCPN176_FE_OFN86_n312 B[0]=prime[0] TC=net25629 GE_LT=net25629
+ GE_GT_EQ=n3 GE_LT_GT_LE=N63
Xr313 mult_DW01_inc_0 $PINS A[10]=i[10] A[9]=i[9] A[8]=i[8] A[7]=i[7] A[6]=i[6]
+ A[5]=i[5] A[4]=N15 A[3]=N14 A[2]=N13 A[1]=N12 A[0]=N11 SUM[10]=N38 SUM[9]=N37
+ SUM[8]=N36 SUM[7]=N35 SUM[6]=N34 SUM[5]=N33 SUM[4]=N32 SUM[3]=N31 SUM[2]=N30
+ SUM[1]=N29 SUM[0]=N28 p1=FE_DBTN95_N11
Xmult_add_3252_aco mult_DW_mult_uns_1 $PINS a[31]=mult_in_1[31]
+ a[30]=mult_in_1[30] a[29]=mult_in_1[29] a[28]=mult_in_1[28] a[27]=mult_in_1[27]
+ a[26]=mult_in_1[26] a[25]=mult_in_1[25] a[24]=mult_in_1[24] a[23]=mult_in_1[23]
+ a[22]=mult_in_1[22] a[21]=mult_in_1[21] a[20]=mult_in_1[20] a[19]=mult_in_1[19]
+ a[18]=mult_in_1[18] a[17]=mult_in_1[17] a[16]=mult_in_1[16] a[15]=mult_in_1[15]
+ a[14]=mult_in_1[14] a[13]=mult_in_1[13] a[12]=mult_in_1[12] a[11]=mult_in_1[11]
+ a[10]=mult_in_1[10] a[9]=mult_in_1[9] a[8]=mult_in_1[8] a[7]=mult_in_1[7]
+ a[6]=mult_in_1[6] a[5]=mult_in_1[5] a[4]=mult_in_1[4] a[3]=mult_in_1[3]
+ a[2]=mult_in_1[2] a[1]=mult_in_1[1] a[0]=mult_in_1[0] b=N16
+ product[32]=SYNOPSYS_UNCONNECTED__0 product[31]=N222 product[30]=N221
+ product[29]=N220 product[28]=N219 product[27]=N218 product[26]=N217
+ product[25]=N216 product[24]=N215 product[23]=N214 product[22]=N213
+ product[21]=N212 product[20]=N211 product[19]=N210 product[18]=N209
+ product[17]=N208 product[16]=N207 product[15]=N206 product[14]=N205
+ product[13]=N204 product[12]=N203 product[11]=N202 product[10]=N201
+ product[9]=N200 product[8]=N199 product[7]=N198 product[6]=N197 product[5]=N196
+ product[4]=N195 product[3]=N194 product[2]=N193 product[1]=N192 product[0]=N191
Xadd_3252_aco mult_DW01_add_4 $PINS A[33]=net25629 A[32]=mult_out_mid[32]
+ A[31]=mult_out[31] A[30]=mult_out[30] A[29]=mult_out[29] A[28]=mult_out[28]
+ A[27]=mult_out[27] A[26]=mult_out[26] A[25]=mult_out[25] A[24]=mult_out[24]
+ A[23]=mult_out[23] A[22]=mult_out[22] A[21]=mult_out[21] A[20]=mult_out[20]
+ A[19]=mult_out[19] A[18]=mult_out[18] A[17]=mult_out[17] A[16]=mult_out[16]
+ A[15]=mult_out[15] A[14]=mult_out[14] A[13]=mult_out[13] A[12]=mult_out[12]
+ A[11]=mult_out[11] A[10]=mult_out[10] A[9]=mult_out[9] A[8]=mult_out[8]
+ A[7]=mult_out[7] A[6]=mult_out[6] A[5]=mult_out[5] A[4]=mult_out[4]
+ A[3]=mult_out[3] A[2]=mult_out[2] A[1]=mult_out[1] A[0]=mult_out[0]
+ B[33]=net25629 B[32]=net25629 B[31]=N222 B[30]=N221 B[29]=N220 B[28]=N219
+ B[27]=N218 B[26]=N217 B[25]=N216 B[24]=N215 B[23]=N214 B[22]=N213 B[21]=N212
+ B[20]=N211 B[19]=N210 B[18]=N209 B[17]=N208 B[16]=N207 B[15]=N206 B[14]=N205
+ B[13]=N204 B[12]=N203 B[11]=N202 B[10]=N201 B[9]=N200 B[8]=N199 B[7]=N198
+ B[6]=N197 B[5]=N196 B[4]=N195 B[3]=N194 B[2]=N193 B[1]=N192 B[0]=N191
+ CI=net25629 SUM[33]=connect_0[33] SUM[32]=connect_0[32] SUM[31]=connect_0[31]
+ SUM[30]=connect_0[30] SUM[29]=connect_0[29] SUM[28]=connect_0[28]
+ SUM[27]=connect_0[27] SUM[26]=connect_0[26] SUM[25]=connect_0[25]
+ SUM[24]=connect_0[24] SUM[23]=connect_0[23] SUM[22]=connect_0[22]
+ SUM[21]=connect_0[21] SUM[20]=connect_0[20] SUM[19]=connect_0[19]
+ SUM[18]=connect_0[18] SUM[17]=connect_0[17] SUM[16]=connect_0[16]
+ SUM[15]=connect_0[15] SUM[14]=connect_0[14] SUM[13]=connect_0[13]
+ SUM[12]=connect_0[12] SUM[11]=connect_0[11] SUM[10]=connect_0[10]
+ SUM[9]=connect_0[9] SUM[8]=connect_0[8] SUM[7]=connect_0[7] SUM[6]=connect_0[6]
+ SUM[5]=connect_0[5] SUM[4]=connect_0[4] SUM[3]=connect_0[3] SUM[2]=connect_0[2]
+ SUM[1]=connect_0[1] SUM[0]=connect_0[0]
Xadd_3253 mult_DW01_add_5 $PINS A[33]=connect_0[33] A[32]=connect_0[32]
+ A[31]=connect_0[31] A[30]=connect_0[30] A[29]=connect_0[29] A[28]=connect_0[28]
+ A[27]=connect_0[27] A[26]=connect_0[26] A[25]=connect_0[25] A[24]=connect_0[24]
+ A[23]=connect_0[23] A[22]=connect_0[22] A[21]=connect_0[21] A[20]=connect_0[20]
+ A[19]=connect_0[19] A[18]=connect_0[18] A[17]=connect_0[17] A[16]=connect_0[16]
+ A[15]=connect_0[15] A[14]=connect_0[14] A[13]=connect_0[13] A[12]=connect_0[12]
+ A[11]=connect_0[11] A[10]=connect_0[10] A[9]=connect_0[9] A[8]=connect_0[8]
+ A[7]=connect_0[7] A[6]=connect_0[6] A[5]=connect_0[5] A[4]=connect_0[4]
+ A[3]=connect_0[3] A[2]=connect_0[2] A[1]=connect_0[1] A[0]=connect_0[0]
+ B[33]=net25629 B[32]=net25629 B[31]=prime[31] B[30]=prime[30] B[29]=prime[29]
+ B[28]=prime[28] B[27]=prime[27] B[26]=prime[26] B[25]=prime[25] B[24]=prime[24]
+ B[23]=prime[23] B[22]=prime[22] B[21]=prime[21] B[20]=prime[20] B[19]=prime[19]
+ B[18]=prime[18] B[17]=prime[17] B[16]=prime[16] B[15]=prime[15] B[14]=prime[14]
+ B[13]=prime[13] B[12]=prime[12] B[11]=prime[11] B[10]=prime[10] B[9]=prime[9]
+ B[8]=prime[8] B[7]=prime[7] B[6]=prime[6] B[5]=prime[5] B[4]=prime[4]
+ B[3]=prime[3] B[2]=prime[2] B[1]=FE_OCPN176_FE_OFN86_n312
+ B[0]=FE_OCPN174_FE_OFN338_n310 CI=net25629 SUM[33]=connect_1[33]
+ SUM[32]=connect_1[32] SUM[31]=connect_1[31] SUM[30]=connect_1[30]
+ SUM[29]=connect_1[29] SUM[28]=connect_1[28] SUM[27]=connect_1[27]
+ SUM[26]=connect_1[26] SUM[25]=connect_1[25] SUM[24]=connect_1[24]
+ SUM[23]=connect_1[23] SUM[22]=connect_1[22] SUM[21]=connect_1[21]
+ SUM[20]=connect_1[20] SUM[19]=connect_1[19] SUM[18]=connect_1[18]
+ SUM[17]=connect_1[17] SUM[16]=connect_1[16] SUM[15]=connect_1[15]
+ SUM[14]=connect_1[14] SUM[13]=connect_1[13] SUM[12]=connect_1[12]
+ SUM[11]=connect_1[11] SUM[10]=connect_1[10] SUM[9]=connect_1[9]
+ SUM[8]=connect_1[8] SUM[7]=connect_1[7] SUM[6]=connect_1[6] SUM[5]=connect_1[5]
+ SUM[4]=connect_1[4] SUM[3]=connect_1[3] SUM[2]=connect_1[2] SUM[1]=connect_1[1]
+ SUM[0]=SYNOPSYS_UNCONNECTED__1
Xmult_out_mid_reg[32] QDFFRBN $PINS Q=mult_out_mid[32] D=n96 CK=i_clk_clone4
+ RB=FE_OFN310_FE_OFN2_FE_DBTN1_i_i_rst
Xi_reg[5] QDFFRBN $PINS Q=i[5] D=i_n[5] CK=i_clk RB=FE_OFN3_FE_DBTN1_i_i_rst
Xi_reg[6] QDFFRBN $PINS Q=i[6] D=i_n[6] CK=i_clk_clone3
+ RB=FE_OFN3_FE_DBTN1_i_i_rst
Xi_reg[8] QDFFRBN $PINS Q=i[8] D=i_n[8] CK=i_clk_clone3
+ RB=FE_OFN3_FE_DBTN1_i_i_rst
Xi_reg[9] QDFFRBN $PINS Q=i[9] D=i_n[9] CK=i_clk_clone3
+ RB=FE_OFN3_FE_DBTN1_i_i_rst
Xi_reg[10] QDFFRBN $PINS Q=i[10] D=i_n[10] CK=i_clk_clone3
+ RB=FE_OFN3_FE_DBTN1_i_i_rst
Xi_reg[7] QDFFRBN $PINS Q=i[7] D=i_n[7] CK=i_clk RB=FE_OFN3_FE_DBTN1_i_i_rst
Xmult_out_mid_reg[30] QDFFRBN $PINS Q=mult_out[30] D=n98 CK=i_clk_clone4
+ RB=FE_OFN310_FE_OFN2_FE_DBTN1_i_i_rst
Xmult_out_mid_reg[28] QDFFRBN $PINS Q=mult_out[28] D=n100 CK=i_clk_clone4
+ RB=FE_OFN311_FE_OFN2_FE_DBTN1_i_i_rst
Xmult_out_mid_reg[31] QDFFRBN $PINS Q=mult_out[31] D=n97 CK=i_clk_clone4
+ RB=FE_OFN310_FE_OFN2_FE_DBTN1_i_i_rst
Xmult_out_mid_reg[29] QDFFRBN $PINS Q=mult_out[29] D=n99 CK=i_clk_clone4
+ RB=FE_OFN311_FE_OFN2_FE_DBTN1_i_i_rst
Xmult_out_mid_reg[24] QDFFRBN $PINS Q=mult_out[24] D=n104 CK=i_clk_clone4
+ RB=FE_OFN311_FE_OFN2_FE_DBTN1_i_i_rst
Xmult_out_mid_reg[22] QDFFRBN $PINS Q=mult_out[22] D=n106 CK=i_clk_clone4
+ RB=FE_OFN311_FE_OFN2_FE_DBTN1_i_i_rst
Xmult_out_mid_reg[25] QDFFRBN $PINS Q=mult_out[25] D=n103 CK=i_clk_clone4
+ RB=FE_OFN311_FE_OFN2_FE_DBTN1_i_i_rst
Xmult_out_mid_reg[23] QDFFRBN $PINS Q=mult_out[23] D=n105 CK=i_clk_clone4
+ RB=FE_OFN311_FE_OFN2_FE_DBTN1_i_i_rst
Xstate_reg[0] QDFFRBN $PINS Q=state[0] D=state_n[0] CK=i_clk_clone3
+ RB=FE_OFN301_FE_OFN5_FE_DBTN1_i_i_rst
Xi_reg[2] QDFFRBN $PINS Q=N13 D=i_n[2] CK=i_clk_clone3
+ RB=FE_OFN3_FE_DBTN1_i_i_rst
Xstate_reg[1] QDFFRBN $PINS Q=state[1] D=n203 CK=i_clk_clone3
+ RB=FE_OFN301_FE_OFN5_FE_DBTN1_i_i_rst
Xi_reg[4] QDFFRBN $PINS Q=N15 D=i_n[4] CK=i_clk_clone3
+ RB=FE_OFN3_FE_DBTN1_i_i_rst
Xi_reg[3] QDFFRBN $PINS Q=N14 D=i_n[3] CK=i_clk RB=i_rst
Xmult_out_mid_reg[20] QDFFRBN $PINS Q=mult_out[20] D=n108 CK=i_clk_clone4
+ RB=FE_OFN311_FE_OFN2_FE_DBTN1_i_i_rst
Xmult_out_mid_reg[19] QDFFRBN $PINS Q=mult_out[19] D=n109 CK=i_clk_clone2
+ RB=FE_OFN311_FE_OFN2_FE_DBTN1_i_i_rst
Xmult_out_mid_reg[21] QDFFRBN $PINS Q=mult_out[21] D=n107 CK=i_clk_clone4
+ RB=FE_OFN311_FE_OFN2_FE_DBTN1_i_i_rst
Xi_reg[1] QDFFRBN $PINS Q=N12 D=i_n[1] CK=i_clk_clone3
+ RB=FE_OFN3_FE_DBTN1_i_i_rst
Xi_reg[0] QDFFRBN $PINS Q=N11 D=i_n[0] CK=i_clk_clone3 RB=i_rst
Xmult_out_mid_reg[18] QDFFRBN $PINS Q=mult_out[18] D=n110 CK=i_clk_clone2
+ RB=FE_OFN311_FE_OFN2_FE_DBTN1_i_i_rst
Xmult_out_mid_reg[16] QDFFRBN $PINS Q=mult_out[16] D=n112 CK=i_clk_clone2
+ RB=FE_OFN311_FE_OFN2_FE_DBTN1_i_i_rst
Xmult_out_mid_reg[17] QDFFRBN $PINS Q=mult_out[17] D=n111 CK=i_clk_clone2
+ RB=FE_OFN311_FE_OFN2_FE_DBTN1_i_i_rst
Xmult_out_mid_reg[14] QDFFRBN $PINS Q=mult_out[14] D=n114 CK=i_clk_clone1
+ RB=FE_OFN1_FE_DBTN1_i_i_rst
Xmult_out_mid_reg[12] QDFFRBN $PINS Q=mult_out[12] D=n116 CK=i_clk_clone1
+ RB=FE_OFN1_FE_DBTN1_i_i_rst
Xmult_out_mid_reg[15] QDFFRBN $PINS Q=mult_out[15] D=n113 CK=i_clk_clone1
+ RB=FE_OFN1_FE_DBTN1_i_i_rst
Xmult_out_mid_reg[13] QDFFRBN $PINS Q=mult_out[13] D=n115 CK=i_clk_clone1
+ RB=FE_OFN1_FE_DBTN1_i_i_rst
Xmult_out_mid_reg[10] QDFFRBN $PINS Q=mult_out[10] D=n118 CK=i_clk_clone1
+ RB=i_rst
Xmult_out_mid_reg[11] QDFFRBN $PINS Q=mult_out[11] D=n117 CK=i_clk_clone1
+ RB=FE_OFN1_FE_DBTN1_i_i_rst
Xmult_out_mid_reg[9] QDFFRBN $PINS Q=mult_out[9] D=n119 CK=i_clk_clone1
+ RB=i_rst
Xmult_out_mid_reg[8] QDFFRBN $PINS Q=mult_out[8] D=n120 CK=i_clk_clone1
+ RB=i_rst
Xmult_out_mid_reg[6] QDFFRBN $PINS Q=mult_out[6] D=n122 CK=i_clk_clone1
+ RB=i_rst
Xmult_out_mid_reg[7] QDFFRBN $PINS Q=mult_out[7] D=n121 CK=i_clk_clone1
+ RB=i_rst
Xmult_out_mid_reg[4] QDFFRBN $PINS Q=mult_out[4] D=n124 CK=i_clk_clone3
+ RB=FE_OFN8_FE_DBTN1_i_i_rst
Xmult_out_mid_reg[2] QDFFRBN $PINS Q=mult_out[2] D=n126 CK=i_clk_clone3
+ RB=FE_OFN8_FE_DBTN1_i_i_rst
Xmult_out_mid_reg[3] QDFFRBN $PINS Q=mult_out[3] D=n125 CK=i_clk_clone3
+ RB=FE_OFN8_FE_DBTN1_i_i_rst
Xmult_out_mid_reg[5] QDFFRBN $PINS Q=mult_out[5] D=n123 CK=i_clk_clone1
+ RB=FE_OFN8_FE_DBTN1_i_i_rst
Xmult_out_mid_reg[26] QDFFRBN $PINS Q=mult_out[26] D=n102 CK=i_clk_clone4
+ RB=FE_OFN311_FE_OFN2_FE_DBTN1_i_i_rst
Xmult_out_mid_reg[27] QDFFRBN $PINS Q=mult_out[27] D=n101 CK=i_clk_clone4
+ RB=FE_OFN311_FE_OFN2_FE_DBTN1_i_i_rst
Xmult_out_mid_reg[0] QDFFRBN $PINS Q=mult_out[0] D=n128 CK=i_clk_clone3
+ RB=FE_OFN3_FE_DBTN1_i_i_rst
Xmult_out_mid_reg[1] QDFFRBN $PINS Q=mult_out[1] D=n127 CK=i_clk_clone3
+ RB=FE_OFN3_FE_DBTN1_i_i_rst
XU3 AOI22S $PINS O=n36 A1=mult_in_0[11] A2=n8 B1=mult_in_0[10] B2=n9
XU4 AOI22S $PINS O=n23 A1=mult_in_0[15] A2=n8 B1=mult_in_0[14] B2=n9
XU7 OA12 $PINS O=n1 A1=n6 B1=n134 B2=n133
XU9 ND2 $PINS O=n96 I1=n198 I2=n199
XU10 AOI22H $PINS O=n198 A1=FE_PHN992_mult_out_mid_32 A2=FE_OFN559_n200 B1=N97
+ B2=FE_OFN558_n7
XU11 ND2S $PINS O=n27 I1=n35 I2=n36
XU12 ND2S $PINS O=n14 I1=n22 I2=n23
XU13 ND2S $PINS O=n30 I1=n31 I2=n32
XU14 ND2S $PINS O=n16 I1=n20 I2=n21
XU16 ND2S $PINS O=n29 I1=n33 I2=n34
XU17 ND2S $PINS O=n17 I1=n18 I2=n19
XU29 INV1S $PINS O=n203 I=n135
XU38 AN2B1S $PINS O=n2 I1=n1 B1=connect_0[0]
XU39 AN2 $PINS O=n4 I1=connect_0[0] I2=n1
XU47 AN2 $PINS O=n5 I1=n40 I2=FE_DBTN95_N11
XU48 INV1S $PINS O=n133 I=n87
XU49 INV1S $PINS O=n134 I=n132
XU53 OR2 $PINS O=n6 I1=n87 I2=sel_mult
XU54 OAI12HS $PINS O=state_n[0] A1=n132 B1=n87 B2=n130
XU55 INV1S $PINS O=n130 I=sel_mult
XU60 AN2 $PINS O=n7 I1=N63 I2=n203
XU68 OR2B1S $PINS O=n135 I1=n131 B1=n90
XU70 AN2 $PINS O=n8 I1=N12 I2=N11
XU71 AN2 $PINS O=n9 I1=N12 I2=FE_DBTN95_N11
XU72 AN2 $PINS O=n10 I1=N11 I2=n40
XU74 INV1S $PINS O=n40 I=N12
XU75 INV1S $PINS O=n205 I=state[0]
XU76 AN2 $PINS O=done_mult I1=n205 I2=state[1]
XU77 INV1S $PINS O=n94 I=N13
XU78 NR2 $PINS O=n90 I1=n205 I2=state[1]
XU79 NR3 $PINS O=n93 I1=i[7] I2=i[9] I3=i[8]
XU80 INV1S $PINS O=n89 I=N14
XU81 INV1S $PINS O=n91 I=N15
XU82 INV1S $PINS O=n92 I=i[10]
XU83 INV1S $PINS O=n88 I=i[6]
XU84 OR2 $PINS O=n87 I1=state[0] I2=state[1]
XU88 MUX2 $PINS O=N16 S=N13 A=n11 B=n12
XU89 MUX3 $PINS O=n12 S0=N14 S1=N15 A=n13 B=n14 C=n15
XU90 MUX2 $PINS O=n15 S=N14 A=n16 B=n17
XU91 AOI22S $PINS O=n19 A1=mult_in_0[31] A2=n8 B1=mult_in_0[30] B2=n9
XU92 AOI22S $PINS O=n18 A1=mult_in_0[29] A2=n10 B1=mult_in_0[28] B2=n5
XU93 AOI22S $PINS O=n21 A1=mult_in_0[23] A2=n8 B1=mult_in_0[22] B2=n9
XU94 AOI22S $PINS O=n20 A1=mult_in_0[21] A2=n10 B1=mult_in_0[20] B2=n5
XU95 AOI22S $PINS O=n22 A1=mult_in_0[13] A2=n10 B1=mult_in_0[12] B2=n5
XU96 ND2 $PINS O=n13 I1=n24 I2=n25
XU97 AOI22S $PINS O=n25 A1=mult_in_0[7] A2=n8 B1=mult_in_0[6] B2=n9
XU98 AOI22S $PINS O=n24 A1=mult_in_0[5] A2=n10 B1=mult_in_0[4] B2=n5
XU99 MUX3 $PINS O=n11 S0=N14 S1=N15 A=n26 B=n27 C=n28
XU100 MUX2 $PINS O=n28 S=N14 A=n29 B=n30
XU101 AOI22S $PINS O=n32 A1=mult_in_0[27] A2=n8 B1=mult_in_0[26] B2=n9
XU102 AOI22S $PINS O=n31 A1=mult_in_0[25] A2=n10 B1=mult_in_0[24] B2=n5
XU103 AOI22S $PINS O=n34 A1=mult_in_0[19] A2=n8 B1=mult_in_0[18] B2=n9
XU104 AOI22S $PINS O=n33 A1=mult_in_0[17] A2=n10 B1=mult_in_0[16] B2=n5
XU105 AOI22S $PINS O=n35 A1=mult_in_0[9] A2=n10 B1=mult_in_0[8] B2=n5
XU106 ND2 $PINS O=n26 I1=n37 I2=n38
XU107 AOI22S $PINS O=n38 A1=mult_in_0[3] A2=n8 B1=mult_in_0[2] B2=n9
XU108 AOI22S $PINS O=n37 A1=mult_in_0[1] A2=n10 B1=mult_in_0[0] B2=n5
XU109 ND2 $PINS O=n86 I1=i[5] I2=n93
XU110 AN4B1S $PINS O=n129 I1=n91 I2=n89 I3=n88 B1=n86
XU111 AN4B1S $PINS O=n95 I1=n94 I2=n40 I3=n92 B1=N11
XU112 ND2 $PINS O=n131 I1=n129 I2=n95
XU113 ND2 $PINS O=n132 I1=n90 I2=n131
XU114 AN2 $PINS O=i_n[5] I1=N33 I2=state_n[0]
XU115 AN2 $PINS O=i_n[6] I1=N34 I2=state_n[0]
XU116 AN2 $PINS O=i_n[3] I1=N31 I2=state_n[0]
XU117 AN2 $PINS O=i_n[2] I1=N30 I2=state_n[0]
XU118 AN2 $PINS O=i_n[1] I1=N29 I2=state_n[0]
XU119 AN2 $PINS O=i_n[0] I1=N28 I2=state_n[0]
XU120 AN2 $PINS O=i_n[10] I1=FE_PHN1099_N38 I2=state_n[0]
XU121 AN2 $PINS O=i_n[9] I1=N37 I2=state_n[0]
XU122 AN2 $PINS O=i_n[8] I1=N36 I2=state_n[0]
XU123 AN2 $PINS O=i_n[7] I1=N35 I2=state_n[0]
XU124 AN2 $PINS O=i_n[4] I1=N32 I2=state_n[0]
XU125 AOI22S $PINS O=n137 A1=connect_1[31] A2=FE_OFN632_n4 B1=connect_0[31]
+ B2=FE_OFN557_n2
XU126 OAI12HS $PINS O=n200 A1=n6 B1=N63 B2=n135
XU127 AOI22S $PINS O=n136 A1=FE_PHN1153_mult_out_30 A2=FE_OFN559_n200 B1=N95
+ B2=FE_OFN558_n7
XU128 ND2 $PINS O=n98 I1=n137 I2=n136
XU129 AOI22S $PINS O=n139 A1=connect_1[30] A2=FE_OFN632_n4 B1=connect_0[30]
+ B2=FE_OFN557_n2
XU130 AOI22S $PINS O=n138 A1=FE_PHN1145_mult_out_29 A2=FE_OFN559_n200 B1=N94
+ B2=FE_OFN558_n7
XU131 ND2 $PINS O=n99 I1=n139 I2=n138
XU132 AOI22S $PINS O=n141 A1=connect_1[29] A2=FE_OFN632_n4 B1=connect_0[29]
+ B2=FE_OFN557_n2
XU133 AOI22S $PINS O=n140 A1=FE_PHN1158_mult_out_28 A2=FE_OFN559_n200 B1=N93
+ B2=FE_OFN558_n7
XU134 ND2 $PINS O=n100 I1=n141 I2=n140
XU135 AOI22S $PINS O=n143 A1=connect_1[28] A2=FE_OFN632_n4 B1=connect_0[28]
+ B2=FE_OFN557_n2
XU136 AOI22S $PINS O=n142 A1=FE_PHN1161_mult_out_27 A2=FE_OFN559_n200 B1=N92
+ B2=FE_OFN558_n7
XU137 ND2 $PINS O=n101 I1=n143 I2=n142
XU138 AOI22S $PINS O=n145 A1=connect_1[27] A2=FE_OFN632_n4 B1=connect_0[27]
+ B2=FE_OFN557_n2
XU139 AOI22S $PINS O=n144 A1=FE_PHN1093_mult_out_26 A2=FE_OFN559_n200 B1=N91
+ B2=FE_OFN558_n7
XU140 ND2 $PINS O=n102 I1=n145 I2=n144
XU141 AOI22S $PINS O=n147 A1=connect_1[26] A2=FE_OFN632_n4 B1=connect_0[26]
+ B2=FE_OFN557_n2
XU142 AOI22S $PINS O=n146 A1=FE_PHN1137_mult_out_25 A2=FE_OFN559_n200 B1=N90
+ B2=FE_OFN558_n7
XU143 ND2 $PINS O=n103 I1=n147 I2=n146
XU144 AOI22S $PINS O=n149 A1=connect_1[25] A2=FE_OFN632_n4 B1=connect_0[25]
+ B2=FE_OFN557_n2
XU145 AOI22S $PINS O=n148 A1=FE_PHN1048_mult_out_24 A2=FE_OFN559_n200 B1=N89
+ B2=FE_OFN558_n7
XU146 ND2 $PINS O=n104 I1=n149 I2=n148
XU147 AOI22S $PINS O=n151 A1=connect_1[24] A2=FE_OFN632_n4 B1=connect_0[24]
+ B2=FE_OFN557_n2
XU148 AOI22S $PINS O=n150 A1=FE_PHN1070_mult_out_23 A2=FE_OFN559_n200 B1=N88
+ B2=FE_OFN558_n7
XU149 ND2 $PINS O=n105 I1=n151 I2=n150
XU150 AOI22S $PINS O=n153 A1=connect_1[23] A2=FE_OFN632_n4 B1=connect_0[23]
+ B2=FE_OFN557_n2
XU151 AOI22S $PINS O=n152 A1=FE_PHN1118_mult_out_22 A2=FE_OFN559_n200 B1=N87
+ B2=FE_OFN558_n7
XU152 ND2 $PINS O=n106 I1=n153 I2=n152
XU153 AOI22S $PINS O=n155 A1=connect_1[22] A2=FE_OFN632_n4 B1=connect_0[22]
+ B2=FE_OFN557_n2
XU154 AOI22S $PINS O=n154 A1=FE_PHN1163_mult_out_21 A2=FE_OFN559_n200 B1=N86
+ B2=FE_OFN558_n7
XU155 ND2 $PINS O=n107 I1=n155 I2=n154
XU156 AOI22S $PINS O=n157 A1=connect_1[21] A2=FE_OFN632_n4 B1=connect_0[21]
+ B2=FE_OFN557_n2
XU157 AOI22S $PINS O=n156 A1=FE_PHN1148_mult_out_20 A2=FE_OFN559_n200 B1=N85
+ B2=FE_OFN558_n7
XU158 ND2 $PINS O=n108 I1=n157 I2=n156
XU159 AOI22S $PINS O=n159 A1=connect_1[20] A2=FE_OFN632_n4 B1=connect_0[20]
+ B2=FE_OFN557_n2
XU160 AOI22S $PINS O=n158 A1=FE_PHN1139_mult_out_19 A2=FE_OFN559_n200 B1=N84
+ B2=FE_OFN558_n7
XU161 ND2 $PINS O=n109 I1=n159 I2=n158
XU162 AOI22S $PINS O=n161 A1=connect_1[19] A2=FE_OFN632_n4 B1=connect_0[19]
+ B2=FE_OFN557_n2
XU163 AOI22S $PINS O=n160 A1=FE_PHN1116_mult_out_18 A2=FE_OFN559_n200 B1=N83
+ B2=FE_OFN558_n7
XU164 ND2 $PINS O=n110 I1=n161 I2=n160
XU165 AOI22S $PINS O=n163 A1=connect_1[18] A2=FE_OFN632_n4 B1=connect_0[18]
+ B2=FE_OFN557_n2
XU166 AOI22S $PINS O=n162 A1=FE_PHN1157_mult_out_17 A2=FE_OFN559_n200 B1=N82
+ B2=FE_OFN558_n7
XU167 ND2 $PINS O=n111 I1=n163 I2=n162
XU168 AOI22S $PINS O=n165 A1=connect_1[17] A2=FE_OFN632_n4 B1=connect_0[17]
+ B2=FE_OFN557_n2
XU169 AOI22S $PINS O=n164 A1=FE_PHN1127_mult_out_16 A2=FE_OFN559_n200 B1=N81
+ B2=FE_OFN558_n7
XU170 ND2 $PINS O=n112 I1=n165 I2=n164
XU171 AOI22S $PINS O=n167 A1=connect_1[16] A2=FE_OFN632_n4 B1=connect_0[16]
+ B2=FE_OFN557_n2
XU172 AOI22S $PINS O=n166 A1=FE_PHN1165_mult_out_15 A2=FE_OFN559_n200 B1=N80
+ B2=FE_OFN558_n7
XU173 ND2 $PINS O=n113 I1=n167 I2=n166
XU174 AOI22S $PINS O=n169 A1=connect_1[15] A2=FE_OFN632_n4 B1=connect_0[15]
+ B2=FE_OFN557_n2
XU175 AOI22S $PINS O=n168 A1=FE_PHN1133_mult_out_14 A2=FE_OFN559_n200 B1=N79
+ B2=FE_OFN558_n7
XU176 ND2 $PINS O=n114 I1=n169 I2=n168
XU177 AOI22S $PINS O=n171 A1=connect_1[14] A2=FE_OFN632_n4 B1=connect_0[14]
+ B2=FE_OFN557_n2
XU178 AOI22S $PINS O=n170 A1=FE_PHN1169_mult_out_13 A2=FE_OFN559_n200 B1=N78
+ B2=FE_OFN558_n7
XU179 ND2 $PINS O=n115 I1=n171 I2=n170
XU180 AOI22S $PINS O=n173 A1=connect_1[13] A2=n4 B1=connect_0[13] B2=n2
XU181 AOI22S $PINS O=n172 A1=FE_PHN1110_mult_out_12 A2=n200 B1=N77 B2=n7
XU182 ND2 $PINS O=n116 I1=n173 I2=n172
XU183 AOI22S $PINS O=n175 A1=connect_1[12] A2=n4 B1=connect_0[12] B2=n2
XU184 AOI22S $PINS O=n174 A1=FE_PHN1129_mult_out_11 A2=n200 B1=N76 B2=n7
XU185 ND2 $PINS O=n117 I1=n175 I2=n174
XU186 AOI22S $PINS O=n177 A1=connect_1[11] A2=n4 B1=connect_0[11] B2=n2
XU187 AOI22S $PINS O=n176 A1=FE_PHN1120_mult_out_10 A2=n200 B1=N75 B2=n7
XU188 ND2 $PINS O=n118 I1=n177 I2=n176
XU189 AOI22S $PINS O=n179 A1=connect_1[10] A2=n4 B1=connect_0[10] B2=n2
XU190 AOI22S $PINS O=n178 A1=FE_PHN1028_mult_out_9 A2=n200 B1=N74 B2=n7
XU191 ND2 $PINS O=n119 I1=n179 I2=n178
XU192 AOI22S $PINS O=n181 A1=connect_1[9] A2=n4 B1=connect_0[9] B2=n2
XU193 AOI22S $PINS O=n180 A1=FE_PHN1142_mult_out_8 A2=n200 B1=N73 B2=n7
XU194 ND2 $PINS O=n120 I1=n181 I2=n180
XU195 AOI22S $PINS O=n183 A1=connect_1[8] A2=n4 B1=connect_0[8] B2=n2
XU196 AOI22S $PINS O=n182 A1=FE_PHN1188_mult_out_7 A2=n200 B1=N72 B2=n7
XU197 ND2 $PINS O=n121 I1=n183 I2=n182
XU198 AOI22S $PINS O=n185 A1=connect_1[7] A2=n4 B1=connect_0[7] B2=n2
XU199 AOI22S $PINS O=n184 A1=FE_PHN1146_mult_out_6 A2=n200 B1=N71 B2=n7
XU200 ND2 $PINS O=n122 I1=n185 I2=n184
XU201 AOI22S $PINS O=n187 A1=connect_1[6] A2=n4 B1=connect_0[6] B2=n2
XU202 AOI22S $PINS O=n186 A1=FE_PHN1166_mult_out_5 A2=n200 B1=N70 B2=n7
XU203 ND2 $PINS O=n123 I1=n187 I2=n186
XU204 AOI22S $PINS O=n189 A1=connect_1[5] A2=n4 B1=connect_0[5] B2=n2
XU205 AOI22S $PINS O=n188 A1=FE_PHN1144_mult_out_4 A2=n200 B1=N69 B2=n7
XU206 ND2 $PINS O=n124 I1=n189 I2=n188
XU207 AOI22S $PINS O=n191 A1=connect_1[4] A2=n4 B1=connect_0[4] B2=n2
XU208 AOI22S $PINS O=n190 A1=FE_PHN1122_mult_out_3 A2=n200 B1=N68 B2=n7
XU209 ND2 $PINS O=n125 I1=n191 I2=n190
XU210 AOI22S $PINS O=n193 A1=connect_1[3] A2=n4 B1=connect_0[3] B2=n2
XU211 AOI22S $PINS O=n192 A1=FE_PHN1017_mult_out_2 A2=n200 B1=N67 B2=n7
XU212 ND2 $PINS O=n126 I1=n193 I2=n192
XU213 AOI22S $PINS O=n195 A1=connect_1[2] A2=n4 B1=connect_0[2] B2=n2
XU214 AOI22S $PINS O=n194 A1=FE_PHN1106_mult_out_1 A2=n200 B1=N66 B2=n7
XU215 ND2 $PINS O=n127 I1=n195 I2=n194
XU216 AOI22S $PINS O=n197 A1=connect_1[32] A2=FE_OFN632_n4 B1=connect_0[32]
+ B2=FE_OFN557_n2
XU217 AOI22S $PINS O=n196 A1=FE_PHN1170_mult_out_31 A2=FE_OFN559_n200 B1=N96
+ B2=FE_OFN558_n7
XU218 ND2 $PINS O=n97 I1=n197 I2=n196
XU219 AOI22S $PINS O=n199 A1=connect_1[33] A2=FE_OFN632_n4 B1=connect_0[33]
+ B2=FE_OFN557_n2
XU220 AOI22S $PINS O=n202 A1=connect_1[1] A2=n4 B1=connect_0[1] B2=n2
XU221 AOI22S $PINS O=n201 A1=FE_PHN1125_mult_out_0 A2=n200 B1=N65 B2=n7
XU222 ND2 $PINS O=n128 I1=n202 I2=n201
.ENDS

.SUBCKT div_DW01_sub_0 A[32] A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24]
+ A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12] A[11]
+ A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[32] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] CI DIFF[32] DIFF[31] DIFF[30] DIFF[29] DIFF[28] DIFF[27]
+ DIFF[26] DIFF[25] DIFF[24] DIFF[23] DIFF[22] DIFF[21] DIFF[20] DIFF[19]
+ DIFF[18] DIFF[17] DIFF[16] DIFF[15] DIFF[14] DIFF[13] DIFF[12] DIFF[11]
+ DIFF[10] DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3] DIFF[2]
+ DIFF[1] DIFF[0] CO FE_OFN255_FE_OFN36_raw_prime_26
XFE_RC_2415_0 XOR2HS $PINS O=DIFF[14] I1=FE_RN_877_0 I2=carry[14]
XFE_OCPC377_carry_26 BUF1S $PINS O=FE_OCPN377_carry_26 I=carry[26]
XFE_RC_2318_0 XOR3 $PINS O=DIFF[2] I1=A[2] I2=n59 I3=carry[2]
XFE_RC_2317_0 MAO222 $PINS O=carry[3] A1=A[2] B1=n59 C1=carry[2]
XFE_RC_2257_0 ND3P $PINS O=carry[26] I1=n11 I2=n10 I3=n9
XFE_RC_2207_0 AN2 $PINS O=FE_RN_1508_0 I1=B[3] I2=A[3]
XFE_RC_2206_0 AN2B1S $PINS O=FE_RN_1509_0 I1=FE_RN_1512_0 B1=FE_RN_1508_0
XFE_RC_2205_0 XNR2HS $PINS O=FE_RN_1510_0 I1=A[3] I2=B[3]
XFE_RC_2204_0 MXL2HS $PINS OB=DIFF[3] S=carry[3] A=FE_RN_1510_0 B=FE_RN_1509_0
XFE_RC_2203_0 ND2S $PINS O=FE_RN_1511_0 I1=B[3] I2=A[3]
XFE_RC_2202_0 OR2S $PINS O=FE_RN_1512_0 I1=A[3] I2=B[3]
XFE_RC_2201_0 ND2 $PINS O=FE_RN_1513_0 I1=FE_RN_1512_0 I2=carry[3]
XFE_RC_2200_0 ND2P $PINS O=carry[4] I1=FE_RN_1513_0 I2=FE_RN_1511_0
XFE_RC_2167_0 INV1S $PINS O=FE_RN_1482_0 I=n50
XFE_RC_2166_0 ND3P $PINS O=carry[6] I1=n55 I2=n56 I3=FE_RN_1482_0
XFE_RC_2165_0 ND3P $PINS O=carry[25] I1=n6 I2=n7 I3=n5
XFE_RC_1978_0 INV1S $PINS O=FE_RN_1336_0 I=FE_RN_1337_0
XFE_RC_1977_0 XOR2HS $PINS O=FE_RN_1337_0 I1=A[6] I2=B[6]
XFE_RC_1975_0 ND2 $PINS O=FE_RN_1339_0 I1=FE_RN_1336_0 I2=carry[6]
XFE_RC_1974_0 OAI12HS $PINS O=DIFF[6] A1=FE_RN_1339_0 B1=FE_RN_1336_0
+ B2=carry[6]
XFE_RC_1973_0 ND2 $PINS O=FE_RN_1340_0 I1=B[6] I2=A[6]
XFE_RC_1972_0 OR2 $PINS O=FE_RN_1341_0 I1=A[6] I2=B[6]
XFE_RC_1971_0 ND2 $PINS O=FE_RN_1342_0 I1=FE_RN_1341_0 I2=carry[6]
XFE_RC_1970_0 ND2P $PINS O=carry[7] I1=FE_RN_1342_0 I2=FE_RN_1340_0
XFE_RC_1789_0 INV1S $PINS O=FE_RN_1192_0 I=FE_RN_1199_0
XFE_RC_1788_0 AOI12HS $PINS O=FE_RN_1193_0 A1=FE_RN_1192_0 B1=B[13] B2=A[13]
XFE_RC_1787_0 INV1S $PINS O=FE_RN_1194_0 I=B[13]
XFE_RC_1785_0 MAOI1 $PINS O=FE_RN_1196_0 A1=FE_RN_1194_0 A2=A[13] B1=A[13]
+ B2=FE_RN_1194_0
XFE_RC_1784_0 MXL2HS $PINS OB=DIFF[13] S=carry[13] A=FE_RN_1196_0
+ B=FE_RN_1193_0
XFE_RC_1783_0 ND2 $PINS O=FE_RN_1197_0 I1=B[13] I2=A[13]
XFE_RC_1781_0 OR2B1S $PINS O=FE_RN_1199_0 I1=A[13] B1=FE_RN_1194_0
XFE_RC_1780_0 ND2 $PINS O=FE_RN_1200_0 I1=FE_RN_1199_0 I2=carry[13]
XFE_RC_1779_0 ND2P $PINS O=carry[14] I1=FE_RN_1200_0 I2=FE_RN_1197_0
XFE_RC_1598_0 OR2 $PINS O=FE_RN_1060_0 I1=FE_RN_671_0 I2=FE_RN_676_0
XFE_RC_1597_0 ND2P $PINS O=carry[27] I1=FE_RN_679_0 I2=FE_RN_1060_0
XFE_RC_1360_0 XOR2HS $PINS O=FE_RN_877_0 I1=A[14] I2=n71
XFE_RC_1357_0 ND2S $PINS O=FE_RN_879_0 I1=n71 I2=A[14]
XFE_RC_1356_0 OR2S $PINS O=FE_RN_880_0 I1=A[14] I2=n71
XFE_RC_1355_0 ND2P $PINS O=FE_RN_881_0 I1=carry[14] I2=FE_RN_880_0
XFE_RC_1354_0 ND2P $PINS O=carry[15] I1=FE_RN_881_0 I2=FE_RN_879_0
XFE_RC_1164_0 AN2S $PINS O=FE_RN_738_0 I1=B[19] I2=A[19]
XFE_RC_1163_0 AN2B1S $PINS O=FE_RN_739_0 I1=FE_RN_742_0 B1=FE_RN_738_0
XFE_RC_1162_0 XNR2HS $PINS O=FE_RN_740_0 I1=A[19] I2=B[19]
XFE_RC_1161_0 MXL2HS $PINS OB=DIFF[19] S=carry[19] A=FE_RN_740_0 B=FE_RN_739_0
XFE_RC_1160_0 ND2 $PINS O=FE_RN_741_0 I1=B[19] I2=A[19]
XFE_RC_1159_0 OR2 $PINS O=FE_RN_742_0 I1=A[19] I2=B[19]
XFE_RC_1158_0 ND2 $PINS O=FE_RN_743_0 I1=FE_RN_742_0 I2=carry[19]
XFE_RC_1157_0 ND2P $PINS O=carry[20] I1=FE_RN_743_0 I2=FE_RN_741_0
XFE_RC_1074_0 INV1S $PINS O=FE_RN_670_0 I=FE_RN_673_0
XFE_RC_1073_0 INV1S $PINS O=FE_RN_671_0 I=n83
XFE_RC_1071_0 MOAI1S $PINS O=FE_RN_673_0 A1=FE_RN_671_0
+ A2=FE_OFN255_FE_OFN36_raw_prime_26 B1=FE_RN_671_0
+ B2=FE_OFN255_FE_OFN36_raw_prime_26
XFE_RC_1069_0 ND2 $PINS O=FE_RN_675_0 I1=FE_RN_670_0 I2=FE_OCPN377_carry_26
XFE_RC_1068_0 OAI12HS $PINS O=DIFF[26] A1=FE_RN_675_0 B1=FE_RN_670_0
+ B2=FE_OCPN377_carry_26
XFE_RC_1067_0 INV1S $PINS O=FE_RN_676_0 I=A[26]
XFE_RC_1065_0 OR2S $PINS O=FE_RN_678_0 I1=FE_OFN255_FE_OFN36_raw_prime_26
+ I2=n83
XFE_RC_1064_0 ND2P $PINS O=FE_RN_679_0 I1=carry[26] I2=FE_RN_678_0
XFE_RC_1046_0 OR2 $PINS O=FE_RN_657_0 I1=n75 I2=A[18]
XFE_RC_1045_0 ND2P $PINS O=FE_RN_7_0 I1=carry[18] I2=FE_RN_657_0
XFE_RC_863_0 INV1S $PINS O=FE_RN_514_0 I=FE_RN_515_0
XFE_RC_862_0 XOR2HS $PINS O=FE_RN_515_0 I1=A[27] I2=B[27]
XFE_RC_860_0 ND2 $PINS O=FE_RN_517_0 I1=FE_RN_514_0 I2=carry[27]
XFE_RC_859_0 OAI12HS $PINS O=DIFF[27] A1=FE_RN_517_0 B1=FE_RN_514_0
+ B2=carry[27]
XFE_RC_858_0 ND2S $PINS O=FE_RN_518_0 I1=B[27] I2=A[27]
XFE_RC_857_0 OR2S $PINS O=FE_RN_519_0 I1=A[27] I2=B[27]
XFE_RC_856_0 ND2 $PINS O=FE_RN_520_0 I1=carry[27] I2=FE_RN_519_0
XFE_RC_855_0 ND2P $PINS O=carry[28] I1=FE_RN_520_0 I2=FE_RN_518_0
XFE_RC_643_0 INV1S $PINS O=FE_RN_356_0 I=FE_RN_357_0
XFE_RC_642_0 XOR2HS $PINS O=FE_RN_357_0 I1=A[28] I2=n85
XFE_RC_640_0 ND2 $PINS O=FE_RN_359_0 I1=FE_RN_356_0 I2=carry[28]
XFE_RC_639_0 OAI12HS $PINS O=DIFF[28] A1=FE_RN_359_0 B1=FE_RN_356_0
+ B2=carry[28]
XFE_RC_638_0 ND2S $PINS O=FE_RN_360_0 I1=n85 I2=A[28]
XFE_RC_637_0 OR2S $PINS O=FE_RN_361_0 I1=A[28] I2=n85
XFE_RC_636_0 ND2P $PINS O=FE_RN_362_0 I1=carry[28] I2=FE_RN_361_0
XFE_RC_635_0 ND2P $PINS O=carry[29] I1=FE_RN_362_0 I2=FE_RN_360_0
XFE_RC_421_0 ND2S $PINS O=FE_RN_200_0 I1=B[29] I2=A[29]
XFE_RC_420_0 AN2 $PINS O=FE_RN_201_0 I1=FE_RN_204_0 I2=FE_RN_200_0
XFE_RC_419_0 XNR2HS $PINS O=FE_RN_202_0 I1=A[29] I2=B[29]
XFE_RC_418_0 MXL2HS $PINS OB=DIFF[29] S=carry[29] A=FE_RN_202_0 B=FE_RN_201_0
XFE_RC_417_0 ND2S $PINS O=FE_RN_203_0 I1=B[29] I2=A[29]
XFE_RC_416_0 OR2S $PINS O=FE_RN_204_0 I1=A[29] I2=B[29]
XFE_RC_415_0 ND2 $PINS O=FE_RN_205_0 I1=FE_RN_204_0 I2=carry[29]
XFE_RC_414_0 ND2P $PINS O=carry[30] I1=FE_RN_205_0 I2=FE_RN_203_0
XFE_RC_235_0 INV1S $PINS O=FE_RN_88_0 I=FE_RN_95_0
XFE_RC_234_0 AOI12HS $PINS O=FE_RN_89_0 A1=FE_RN_88_0 B1=B[17] B2=A[17]
XFE_RC_233_0 INV1S $PINS O=FE_RN_90_0 I=B[17]
XFE_RC_231_0 MAOI1 $PINS O=FE_RN_92_0 A1=FE_RN_90_0 A2=A[17] B1=A[17]
+ B2=FE_RN_90_0
XFE_RC_230_0 MXL2HS $PINS OB=DIFF[17] S=carry[17] A=FE_RN_92_0 B=FE_RN_89_0
XFE_RC_229_0 ND2 $PINS O=FE_RN_93_0 I1=B[17] I2=A[17]
XFE_RC_227_0 OR2B1S $PINS O=FE_RN_95_0 I1=A[17] B1=FE_RN_90_0
XFE_RC_226_0 ND2 $PINS O=FE_RN_96_0 I1=FE_RN_95_0 I2=carry[17]
XFE_RC_225_0 ND2P $PINS O=carry[18] I1=FE_RN_96_0 I2=FE_RN_93_0
XFE_RC_140_0 ND3P $PINS O=carry[12] I1=n27 I2=n26 I3=n25
XFE_RC_122_0 XOR3 $PINS O=DIFF[15] I1=A[15] I2=B[15] I3=carry[15]
XFE_RC_121_0 MAO222P $PINS O=carry[16] A1=A[15] B1=B[15] C1=carry[15]
XFE_RC_24_0 INV1S $PINS O=FE_RN_9_0 I=B[32]
XFE_RC_23_0 MXL2HS $PINS OB=DIFF[32] S=carry[32] A=B[32] B=FE_RN_9_0
XFE_RC_22_0 INV1S $PINS O=FE_RN_8_0 I=n34
XFE_RC_21_0 ND3P $PINS O=carry[23] I1=n43 I2=n42 I3=FE_RN_8_0
XFE_RC_19_0 ND3P $PINS O=carry[11] I1=n22 I2=n23 I3=n21
XFE_RC_15_0 INV1S $PINS O=FE_RN_2_0 I=FE_RN_3_0
XFE_RC_14_0 XOR2HS $PINS O=FE_RN_3_0 I1=A[18] I2=n75
XFE_RC_12_0 ND2 $PINS O=FE_RN_5_0 I1=FE_RN_2_0 I2=carry[18]
XFE_RC_11_0 OAI12HS $PINS O=DIFF[18] A1=FE_RN_5_0 B1=FE_RN_2_0 B2=carry[18]
XFE_RC_10_0 ND2S $PINS O=FE_RN_6_0 I1=n75 I2=A[18]
XFE_RC_8_0 ND2P $PINS O=carry[19] I1=FE_RN_7_0 I2=FE_RN_6_0
XFE_RC_6_0 ND3P $PINS O=carry[22] I1=n40 I2=n39 I3=n38
XFE_RC_3_0 ND3P $PINS O=carry[17] I1=n35 I2=n36 I3=n37
XFE_OFC243_div_out_2 INV1S $PINS O=n59 I=B[2]
XFE_OFC238_div_out_0 INV1S $PINS O=n57 I=B[0]
XFE_OFC234_div_out_4 INV1S $PINS O=n61 I=B[4]
XFE_OFC231_div_out_1 INV1S $PINS O=n58 I=B[1]
XU2_1 FA1 $PINS S=DIFF[1] CO=carry[2] A=A[1] B=n58 CI=carry[1]
XU2_0 FA1 $PINS S=DIFF[0] CO=carry[1] A=A[0] B=n57 CI=n89
XU1 ND3P $PINS O=carry[24] I1=n1 I2=n2 I3=n3
XU3 XOR3 $PINS O=DIFF[10] I1=A[10] I2=n67 I3=carry[10]
XU4 ND3HT $PINS O=carry[10] I1=n15 I2=n16 I3=n17
XU6 XNR2HS $PINS O=DIFF[31] I1=carry[31] I2=n4
XU7 ND3P $PINS O=carry[5] I1=n52 I2=n53 I3=n51
XU8 ND2 $PINS O=n31 I1=carry[31] I2=A[31]
XU9 ND2 $PINS O=n32 I1=carry[31] I2=B[31]
XU10 ND3P $PINS O=carry[31] I1=n28 I2=n29 I3=n30
XU11 ND3P $PINS O=carry[8] I1=n12 I2=n13 I3=n14
XU12 ND3P $PINS O=carry[13] I1=n47 I2=n48 I3=n49
XU13 XOR3 $PINS O=DIFF[9] I1=A[9] I2=B[9] I3=carry[9]
XU14 XOR3 $PINS O=DIFF[8] I1=A[8] I2=n65 I3=carry[8]
XU15 XOR3 $PINS O=DIFF[30] I1=A[30] I2=n87 I3=carry[30]
XU16 XOR3 $PINS O=DIFF[23] I1=A[23] I2=B[23] I3=carry[23]
XU17 ND2 $PINS O=n1 I1=carry[23] I2=A[23]
XU18 ND2 $PINS O=n2 I1=carry[23] I2=B[23]
XU19 ND2 $PINS O=n3 I1=A[23] I2=B[23]
XU20 ND3HT $PINS O=carry[9] I1=n19 I2=n18 I3=n20
XU22 INV1S $PINS O=n65 I=B[8]
XU23 INV1S $PINS O=n69 I=B[12]
XU24 INV1S $PINS O=n73 I=B[16]
XU26 ND2 $PINS O=n51 I1=A[4] I2=n61
XU28 ND2 $PINS O=n21 I1=A[10] I2=n67
XU29 ND2 $PINS O=n48 I1=carry[12] I2=n69
XU30 ND2 $PINS O=n47 I1=carry[12] I2=A[12]
XU31 ND2 $PINS O=n38 I1=A[21] I2=B[21]
XU32 INV1S $PINS O=n77 I=B[20]
XU33 ND2 $PINS O=n5 I1=A[24] I2=n81
XU34 INV1S $PINS O=n87 I=B[30]
XU36 ND3 $PINS O=carry[32] I1=n31 I2=n32 I3=n33
XU37 XOR3 $PINS O=DIFF[4] I1=A[4] I2=n61 I3=carry[4]
XU38 XOR3 $PINS O=DIFF[7] I1=A[7] I2=B[7] I3=carry[7]
XU39 XOR3 $PINS O=DIFF[12] I1=A[12] I2=n69 I3=carry[12]
XU40 XOR3 $PINS O=DIFF[16] I1=A[16] I2=n73 I3=carry[16]
XU42 XOR3 $PINS O=DIFF[21] I1=A[21] I2=B[21] I3=carry[21]
XU43 XOR3 $PINS O=DIFF[20] I1=A[20] I2=n77 I3=carry[20]
XU44 XOR3 $PINS O=DIFF[24] I1=A[24] I2=n81 I3=carry[24]
XU45 XNR2HS $PINS O=n4 I1=A[31] I2=B[31]
XU46 ND2 $PINS O=n6 I1=A[24] I2=carry[24]
XU47 ND2 $PINS O=n7 I1=n81 I2=carry[24]
XU49 XOR2HS $PINS O=n8 I1=A[25] I2=B[25]
XU50 XOR2HS $PINS O=DIFF[25] I1=n8 I2=carry[25]
XU51 ND2S $PINS O=n9 I1=A[25] I2=B[25]
XU52 ND2 $PINS O=n10 I1=A[25] I2=carry[25]
XU53 ND2 $PINS O=n11 I1=B[25] I2=carry[25]
XU55 ND2 $PINS O=n12 I1=carry[7] I2=A[7]
XU56 ND2 $PINS O=n13 I1=carry[7] I2=B[7]
XU57 ND2 $PINS O=n14 I1=A[7] I2=B[7]
XU58 ND2P $PINS O=n15 I1=carry[9] I2=A[9]
XU59 ND2P $PINS O=n16 I1=carry[9] I2=B[9]
XU60 ND2S $PINS O=n17 I1=A[9] I2=B[9]
XU61 ND2P $PINS O=n18 I1=carry[8] I2=A[8]
XU62 ND2P $PINS O=n19 I1=carry[8] I2=n65
XU63 ND2 $PINS O=n20 I1=A[8] I2=n65
XU64 ND2 $PINS O=n22 I1=A[10] I2=carry[10]
XU65 ND2 $PINS O=n23 I1=n67 I2=carry[10]
XU67 XOR2HS $PINS O=n24 I1=A[11] I2=B[11]
XU68 XOR2HS $PINS O=DIFF[11] I1=n24 I2=carry[11]
XU69 ND2S $PINS O=n25 I1=A[11] I2=B[11]
XU70 ND2 $PINS O=n26 I1=A[11] I2=carry[11]
XU71 ND2 $PINS O=n27 I1=B[11] I2=carry[11]
XU73 ND2 $PINS O=n28 I1=carry[30] I2=A[30]
XU74 ND2 $PINS O=n29 I1=carry[30] I2=n87
XU75 ND2S $PINS O=n30 I1=A[30] I2=n87
XU76 ND2S $PINS O=n33 I1=A[31] I2=B[31]
XU78 AN2 $PINS O=n34 I1=A[22] I2=n79
XU79 ND2 $PINS O=n35 I1=carry[16] I2=A[16]
XU80 ND2 $PINS O=n36 I1=carry[16] I2=n73
XU81 ND2 $PINS O=n37 I1=A[16] I2=n73
XU82 ND2 $PINS O=n39 I1=A[21] I2=carry[21]
XU83 ND2 $PINS O=n40 I1=B[21] I2=carry[21]
XU84 XOR2HS $PINS O=n41 I1=A[22] I2=n79
XU85 XOR2HS $PINS O=DIFF[22] I1=n41 I2=carry[22]
XU86 ND2 $PINS O=n42 I1=A[22] I2=carry[22]
XU87 ND2 $PINS O=n43 I1=n79 I2=carry[22]
XU88 ND2 $PINS O=n44 I1=carry[20] I2=A[20]
XU89 ND2 $PINS O=n45 I1=carry[20] I2=n77
XU90 ND2S $PINS O=n46 I1=A[20] I2=n77
XU91 ND3P $PINS O=carry[21] I1=n44 I2=n45 I3=n46
XU92 ND2 $PINS O=n49 I1=A[12] I2=n69
XU94 AN2 $PINS O=n50 I1=A[5] I2=B[5]
XU95 ND2 $PINS O=n52 I1=A[4] I2=carry[4]
XU96 ND2 $PINS O=n53 I1=n61 I2=carry[4]
XU97 XOR2HS $PINS O=n54 I1=A[5] I2=B[5]
XU98 XOR2HS $PINS O=DIFF[5] I1=n54 I2=carry[5]
XU99 ND2 $PINS O=n55 I1=carry[5] I2=A[5]
XU100 ND2 $PINS O=n56 I1=carry[5] I2=B[5]
XU101 INV1S $PINS O=n71 I=B[14]
XU102 INV1S $PINS O=n75 I=B[18]
XU103 INV1S $PINS O=n79 I=B[22]
XU105 INV1S $PINS O=n85 I=B[28]
XU108 INV1S $PINS O=n67 I=B[10]
XU109 INV1S $PINS O=n81 I=B[24]
XU110 INV1S $PINS O=n83 I=B[26]
XU124 TIE1 $PINS O=n89
.ENDS

.SUBCKT div_DW01_add_0 A[32] A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24]
+ A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12] A[11]
+ A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[32] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] CI SUM[32] SUM[31] SUM[30] SUM[29] SUM[28] SUM[27] SUM[26]
+ SUM[25] SUM[24] SUM[23] SUM[22] SUM[21] SUM[20] SUM[19] SUM[18] SUM[17]
+ SUM[16] SUM[15] SUM[14] SUM[13] SUM[12] SUM[11] SUM[10] SUM[9] SUM[8] SUM[7]
+ SUM[6] SUM[5] SUM[4] SUM[3] SUM[2] SUM[1] SUM[0] CO
+ FE_OFN246_FE_OFN38_raw_prime_24
XFE_RC_2413_0 XOR2HS $PINS O=SUM[10] I1=FE_RN_239_0 I2=carry[10]
XFE_RC_2399_0 XOR2HS $PINS O=SUM[3] I1=FE_RN_1016_0 I2=carry[3]
XFE_OCPC392_carry_30 BUF1S $PINS O=FE_OCPN392_carry_30 I=carry[30]
XFE_OCPC379_carry_12 BUF1S $PINS O=FE_OCPN379_carry_12 I=carry[12]
XFE_OCPC349_carry_25 BUF1S $PINS O=FE_OCPN349_carry_25 I=carry[25]
XFE_RC_2311_0 ND3P $PINS O=carry[17] I1=n29 I2=n28 I3=n27
XFE_RC_2308_0 ND3P $PINS O=carry[13] I1=FE_RN_981_0 I2=FE_RN_980_0
+ I3=FE_RN_979_0
XFE_RC_2294_0 ND3HT $PINS O=carry[21] I1=FE_RN_875_0 I2=FE_RN_874_0
+ I3=FE_RN_873_0
XFE_OCPC301_carry_24 BUF1S $PINS O=FE_OCPN301_carry_24 I=carry[24]
XFE_RC_1935_0 INV1S $PINS O=FE_RN_1304_0 I=A[8]
XFE_RC_1934_0 AN2B1S $PINS O=FE_RN_1305_0 I1=B[8] B1=FE_RN_1304_0
XFE_RC_1933_0 AN2B1S $PINS O=FE_RN_1306_0 I1=FE_RN_1310_0 B1=FE_RN_1305_0
XFE_RC_1932_0 XNR2HS $PINS O=FE_RN_1307_0 I1=B[8] I2=A[8]
XFE_RC_1931_0 MXL2HS $PINS OB=SUM[8] S=carry[8] A=FE_RN_1307_0 B=FE_RN_1306_0
XFE_RC_1930_0 ND2 $PINS O=FE_RN_1308_0 I1=A[8] I2=B[8]
XFE_RC_1929_0 INV1S $PINS O=FE_RN_1309_0 I=A[8]
XFE_RC_1928_0 OR2B1S $PINS O=FE_RN_1310_0 I1=B[8] B1=FE_RN_1309_0
XFE_RC_1927_0 ND2P $PINS O=FE_RN_1311_0 I1=FE_RN_1310_0 I2=carry[8]
XFE_RC_1926_0 ND2P $PINS O=carry[9] I1=FE_RN_1311_0 I2=FE_RN_1308_0
XFE_RC_1776_0 INV1S $PINS O=FE_RN_1190_0 I=n40
XFE_RC_1775_0 ND3P $PINS O=carry[31] I1=n52 I2=n53 I3=FE_RN_1190_0
XFE_RC_1699_0 INV1S $PINS O=FE_RN_1132_0 I=A[32]
XFE_RC_1698_0 MXL2HS $PINS OB=SUM[32] S=carry[32] A=FE_RN_1132_0 B=A[32]
XFE_RC_1659_0 ND3HT $PINS O=carry[30] I1=n50 I2=n49 I3=n48
XFE_RC_1542_0 XOR2HS $PINS O=FE_RN_1016_0 I1=B[3] I2=A[3]
XFE_RC_1539_0 ND2 $PINS O=FE_RN_1018_0 I1=A[3] I2=B[3]
XFE_RC_1538_0 OR2S $PINS O=FE_RN_1019_0 I1=B[3] I2=A[3]
XFE_RC_1537_0 ND2 $PINS O=FE_RN_1020_0 I1=carry[3] I2=FE_RN_1019_0
XFE_RC_1536_0 ND2P $PINS O=carry[4] I1=FE_RN_1020_0 I2=FE_RN_1018_0
XFE_RC_1527_0 INV1S $PINS O=FE_RN_1002_0 I=FE_RN_1003_0
XFE_RC_1526_0 XOR2HS $PINS O=FE_RN_1003_0 I1=B[7] I2=A[7]
XFE_RC_1524_0 ND2 $PINS O=FE_RN_1005_0 I1=FE_RN_1002_0 I2=carry[7]
XFE_RC_1523_0 OAI12HS $PINS O=SUM[7] A1=FE_RN_1005_0 B1=FE_RN_1002_0
+ B2=carry[7]
XFE_RC_1522_0 ND2 $PINS O=FE_RN_1006_0 I1=A[7] I2=B[7]
XFE_RC_1521_0 OR2 $PINS O=FE_RN_1007_0 I1=B[7] I2=A[7]
XFE_RC_1520_0 ND2P $PINS O=FE_RN_1008_0 I1=carry[7] I2=FE_RN_1007_0
XFE_RC_1519_0 ND2P $PINS O=carry[8] I1=FE_RN_1008_0 I2=FE_RN_1006_0
XFE_RC_1493_0 ND2S $PINS O=FE_RN_979_0 I1=B[12] I2=A[12]
XFE_RC_1492_0 ND2P $PINS O=FE_RN_980_0 I1=carry[12] I2=A[12]
XFE_RC_1491_0 ND2P $PINS O=FE_RN_981_0 I1=carry[12] I2=B[12]
XFE_RC_1435_0 INV1S $PINS O=FE_RN_936_0 I=A[24]
XFE_RC_1434_0 INV2 $PINS O=FE_RN_937_0 I=B[24]
XFE_RC_1433_0 OAI22H $PINS O=carry[25] A1=FE_RN_633_0 A2=FE_RN_636_0
+ B1=FE_RN_937_0 B2=FE_RN_936_0
XFE_RC_1370_0 ND3P $PINS O=carry[23] I1=n47 I2=n46 I3=FE_RN_866_0
XFE_RC_1353_0 ND2S $PINS O=FE_RN_873_0 I1=B[20] I2=A[20]
XFE_RC_1352_0 ND2P $PINS O=FE_RN_874_0 I1=carry[20] I2=A[20]
XFE_RC_1351_0 ND2P $PINS O=FE_RN_875_0 I1=carry[20] I2=B[20]
XFE_RC_1341_0 INV1S $PINS O=FE_RN_866_0 I=n41
XFE_RC_1211_0 AN2S $PINS O=FE_RN_769_0 I1=A[23] I2=B[23]
XFE_RC_1210_0 AN2B1S $PINS O=FE_RN_770_0 I1=FE_RN_773_0 B1=FE_RN_769_0
XFE_RC_1209_0 XNR2HS $PINS O=FE_RN_771_0 I1=B[23] I2=A[23]
XFE_RC_1208_0 MXL2HS $PINS OB=SUM[23] S=carry[23] A=FE_RN_771_0 B=FE_RN_770_0
XFE_RC_1207_0 ND2 $PINS O=FE_RN_772_0 I1=A[23] I2=B[23]
XFE_RC_1206_0 OR2 $PINS O=FE_RN_773_0 I1=B[23] I2=A[23]
XFE_RC_1205_0 ND2 $PINS O=FE_RN_774_0 I1=FE_RN_773_0 I2=carry[23]
XFE_RC_1204_0 ND2 $PINS O=carry[24] I1=FE_RN_774_0 I2=FE_RN_772_0
XFE_RC_1020_0 INV1S $PINS O=FE_RN_633_0 I=FE_RN_637_0
XFE_RC_1019_0 AOI12HS $PINS O=FE_RN_634_0 A1=FE_RN_633_0 B1=A[24]
+ B2=FE_OFN246_FE_OFN38_raw_prime_24
XFE_RC_1018_0 XNR2HS $PINS O=FE_RN_635_0 I1=FE_OFN246_FE_OFN38_raw_prime_24
+ I2=A[24]
XFE_RC_1017_0 MXL2HS $PINS OB=SUM[24] S=FE_OCPN301_carry_24 A=FE_RN_635_0
+ B=FE_RN_634_0
XFE_RC_1016_0 INV1S $PINS O=FE_RN_636_0 I=carry[24]
XFE_RC_1015_0 OR2S $PINS O=FE_RN_637_0 I1=FE_OFN246_FE_OFN38_raw_prime_24
+ I2=A[24]
XFE_RC_816_0 ND2S $PINS O=FE_RN_479_0 I1=A[9] I2=B[9]
XFE_RC_815_0 AN2 $PINS O=FE_RN_480_0 I1=FE_RN_483_0 I2=FE_RN_479_0
XFE_RC_814_0 XNR2HS $PINS O=FE_RN_481_0 I1=B[9] I2=A[9]
XFE_RC_813_0 MXL2HS $PINS OB=SUM[9] S=carry[9] A=FE_RN_481_0 B=FE_RN_480_0
XFE_RC_812_0 ND2S $PINS O=FE_RN_482_0 I1=A[9] I2=B[9]
XFE_RC_811_0 OR2S $PINS O=FE_RN_483_0 I1=B[9] I2=A[9]
XFE_RC_810_0 ND2 $PINS O=FE_RN_484_0 I1=FE_RN_483_0 I2=carry[9]
XFE_RC_809_0 ND2P $PINS O=carry[10] I1=FE_RN_484_0 I2=FE_RN_482_0
XFE_RC_651_0 ND2S $PINS O=FE_RN_363_0 I1=A[25] I2=B[25]
XFE_RC_650_0 AN2 $PINS O=FE_RN_364_0 I1=FE_RN_367_0 I2=FE_RN_363_0
XFE_RC_649_0 XNR2HS $PINS O=FE_RN_365_0 I1=B[25] I2=A[25]
XFE_RC_648_0 MXL2HS $PINS OB=SUM[25] S=FE_OCPN349_carry_25 A=FE_RN_365_0
+ B=FE_RN_364_0
XFE_RC_647_0 ND2S $PINS O=FE_RN_366_0 I1=A[25] I2=B[25]
XFE_RC_646_0 OR2S $PINS O=FE_RN_367_0 I1=B[25] I2=A[25]
XFE_RC_645_0 ND2 $PINS O=FE_RN_368_0 I1=FE_RN_367_0 I2=carry[25]
XFE_RC_644_0 ND2P $PINS O=carry[26] I1=FE_RN_368_0 I2=FE_RN_366_0
XFE_RC_474_0 XOR2HS $PINS O=FE_RN_239_0 I1=B[10] I2=A[10]
XFE_RC_471_0 ND2S $PINS O=FE_RN_241_0 I1=A[10] I2=B[10]
XFE_RC_470_0 OR2S $PINS O=FE_RN_242_0 I1=B[10] I2=A[10]
XFE_RC_469_0 ND2P $PINS O=FE_RN_243_0 I1=carry[10] I2=FE_RN_242_0
XFE_RC_468_0 ND2T $PINS O=carry[11] I1=FE_RN_243_0 I2=FE_RN_241_0
XFE_RC_282_0 INV1S $PINS O=FE_RN_118_0 I=FE_RN_119_0
XFE_RC_281_0 XOR2HS $PINS O=FE_RN_119_0 I1=B[11] I2=A[11]
XFE_RC_279_0 ND2 $PINS O=FE_RN_121_0 I1=FE_RN_118_0 I2=carry[11]
XFE_RC_278_0 OAI12HS $PINS O=SUM[11] A1=FE_RN_121_0 B1=FE_RN_118_0 B2=carry[11]
XFE_RC_277_0 ND2S $PINS O=FE_RN_122_0 I1=A[11] I2=B[11]
XFE_RC_276_0 OR2S $PINS O=FE_RN_123_0 I1=B[11] I2=A[11]
XFE_RC_275_0 ND2P $PINS O=FE_RN_124_0 I1=carry[11] I2=FE_RN_123_0
XFE_RC_274_0 ND2P $PINS O=carry[12] I1=FE_RN_124_0 I2=FE_RN_122_0
XFE_RC_79_0 ND2S $PINS O=FE_RN_26_0 I1=A[26] I2=B[26]
XFE_RC_78_0 AN2 $PINS O=FE_RN_27_0 I1=FE_RN_30_0 I2=FE_RN_26_0
XFE_RC_77_0 XNR2HS $PINS O=FE_RN_28_0 I1=B[26] I2=A[26]
XFE_RC_76_0 MXL2HS $PINS OB=SUM[26] S=carry[26] A=FE_RN_28_0 B=FE_RN_27_0
XFE_RC_75_0 ND2S $PINS O=FE_RN_29_0 I1=A[26] I2=B[26]
XFE_RC_74_0 OR2S $PINS O=FE_RN_30_0 I1=B[26] I2=A[26]
XFE_RC_73_0 ND2 $PINS O=FE_RN_31_0 I1=FE_RN_30_0 I2=carry[26]
XFE_RC_72_0 ND2P $PINS O=carry[27] I1=FE_RN_31_0 I2=FE_RN_29_0
XFE_RC_49_0 ND3P $PINS O=carry[6] I1=n14 I2=n15 I3=n13
XFE_RC_47_0 XOR3 $PINS O=SUM[12] I1=A[12] I2=B[12] I3=FE_OCPN379_carry_12
XFE_RC_29_0 XOR3 $PINS O=SUM[20] I1=A[20] I2=B[20] I3=carry[20]
XFE_RC_20_0 ND3P $PINS O=carry[7] I1=n18 I2=n19 I3=n17
XFE_RC_4_0 ND3P $PINS O=carry[22] I1=n44 I2=n43 I3=n42
XU1_31 FA1 $PINS S=SUM[31] CO=carry[32] A=A[31] B=B[31] CI=carry[31]
XU1_2 FA1 $PINS S=SUM[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1_1 FA1 $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=carry[1]
XU1 ND3P $PINS O=carry[19] I1=n34 I2=n35 I3=n36
XU2 XOR3 $PINS O=SUM[28] I1=B[28] I2=A[28] I3=carry[28]
XU3 ND3P $PINS O=carry[28] I1=n4 I2=n5 I3=n6
XU4 XOR3 $PINS O=SUM[17] I1=B[17] I2=A[17] I3=carry[17]
XU6 XOR3 $PINS O=SUM[15] I1=A[15] I2=B[15] I3=carry[15]
XU7 ND3P $PINS O=carry[15] I1=n20 I2=n21 I3=n22
XU8 XOR3 $PINS O=SUM[5] I1=A[5] I2=B[5] I3=carry[5]
XU9 ND3P $PINS O=carry[5] I1=n10 I2=n11 I3=n12
XU12 ND3P $PINS O=n30 I1=n38 I2=n37 I3=n39
XU13 ND2 $PINS O=n38 I1=carry[17] I2=A[17]
XU14 ND2P $PINS O=n37 I1=carry[17] I2=B[17]
XU15 ND2 $PINS O=n20 I1=carry[14] I2=B[14]
XU16 ND2 $PINS O=n21 I1=carry[14] I2=A[14]
XU17 ND2 $PINS O=n34 I1=n30 I2=B[18]
XU18 XOR3 $PINS O=SUM[29] I1=A[29] I2=B[29] I3=carry[29]
XU19 XOR3 $PINS O=SUM[19] I1=B[19] I2=A[19] I3=carry[19]
XU20 ND2 $PINS O=n1 I1=carry[19] I2=B[19]
XU21 ND2 $PINS O=n2 I1=carry[19] I2=A[19]
XU22 ND2 $PINS O=n3 I1=B[19] I2=A[19]
XU23 ND3P $PINS O=carry[20] I1=n1 I2=n2 I3=n3
XU24 AN2S $PINS O=carry[1] I1=B[0] I2=A[0]
XU25 ND3P $PINS O=carry[29] I1=n31 I2=n32 I3=n33
XU26 ND3P $PINS O=carry[16] I1=n24 I2=n25 I3=n23
XU27 ND3P $PINS O=carry[14] I1=n7 I2=n8 I3=n9
XU28 ND2 $PINS O=n13 I1=A[5] I2=B[5]
XU29 ND2 $PINS O=n48 I1=A[29] I2=B[29]
XU30 ND2 $PINS O=n35 I1=n30 I2=A[18]
XU31 ND2 $PINS O=n23 I1=A[15] I2=B[15]
XU32 ND2 $PINS O=n42 I1=A[21] I2=B[21]
XU34 XOR3 $PINS O=SUM[14] I1=B[14] I2=A[14] I3=carry[14]
XU35 XOR3 $PINS O=SUM[18] I1=B[18] I2=A[18] I3=n30
XU36 XOR3 $PINS O=SUM[21] I1=A[21] I2=B[21] I3=carry[21]
XU37 XOR3 $PINS O=SUM[27] I1=B[27] I2=A[27] I3=carry[27]
XU38 ND2 $PINS O=n4 I1=carry[27] I2=B[27]
XU39 ND2 $PINS O=n5 I1=carry[27] I2=A[27]
XU40 ND2 $PINS O=n6 I1=B[27] I2=A[27]
XU41 ND2 $PINS O=n32 I1=carry[28] I2=A[28]
XU42 XOR3 $PINS O=SUM[13] I1=B[13] I2=A[13] I3=carry[13]
XU43 ND2 $PINS O=n7 I1=carry[13] I2=B[13]
XU44 ND2 $PINS O=n8 I1=carry[13] I2=A[13]
XU45 ND2 $PINS O=n9 I1=B[13] I2=A[13]
XU46 XOR3 $PINS O=SUM[4] I1=B[4] I2=A[4] I3=carry[4]
XU47 ND2 $PINS O=n10 I1=carry[4] I2=B[4]
XU48 ND2 $PINS O=n11 I1=carry[4] I2=A[4]
XU49 ND2 $PINS O=n12 I1=B[4] I2=A[4]
XU50 ND2 $PINS O=n14 I1=A[5] I2=carry[5]
XU51 ND2 $PINS O=n15 I1=B[5] I2=carry[5]
XU53 XOR2HS $PINS O=n16 I1=A[6] I2=B[6]
XU54 XOR2HS $PINS O=SUM[6] I1=n16 I2=carry[6]
XU55 ND2S $PINS O=n17 I1=A[6] I2=B[6]
XU56 ND2 $PINS O=n18 I1=A[6] I2=carry[6]
XU57 ND2 $PINS O=n19 I1=B[6] I2=carry[6]
XU58 ND2S $PINS O=n22 I1=B[14] I2=A[14]
XU59 ND2 $PINS O=n24 I1=A[15] I2=carry[15]
XU60 ND2P $PINS O=n25 I1=B[15] I2=carry[15]
XU61 XOR2HS $PINS O=n26 I1=A[16] I2=B[16]
XU62 XOR2HS $PINS O=SUM[16] I1=n26 I2=carry[16]
XU63 ND2S $PINS O=n27 I1=A[16] I2=B[16]
XU64 ND2 $PINS O=n28 I1=A[16] I2=carry[16]
XU65 ND2 $PINS O=n29 I1=B[16] I2=carry[16]
XU66 ND2 $PINS O=n31 I1=carry[28] I2=B[28]
XU67 ND2S $PINS O=n33 I1=B[28] I2=A[28]
XU68 ND2S $PINS O=n36 I1=B[18] I2=A[18]
XU69 ND2 $PINS O=n39 I1=B[17] I2=A[17]
XU71 AN2 $PINS O=n40 I1=A[30] I2=B[30]
XU73 AN2 $PINS O=n41 I1=A[22] I2=B[22]
XU74 ND2 $PINS O=n43 I1=A[21] I2=carry[21]
XU75 ND2 $PINS O=n44 I1=B[21] I2=carry[21]
XU76 XOR2HS $PINS O=n45 I1=A[22] I2=B[22]
XU77 XOR2HS $PINS O=SUM[22] I1=n45 I2=carry[22]
XU78 ND2 $PINS O=n46 I1=A[22] I2=carry[22]
XU79 ND2 $PINS O=n47 I1=B[22] I2=carry[22]
XU80 ND2P $PINS O=n49 I1=A[29] I2=carry[29]
XU81 ND2 $PINS O=n50 I1=B[29] I2=carry[29]
XU82 XOR2HS $PINS O=n51 I1=A[30] I2=B[30]
XU83 XOR2HS $PINS O=SUM[30] I1=n51 I2=FE_OCPN392_carry_30
XU84 ND2P $PINS O=n52 I1=A[30] I2=carry[30]
XU85 ND2P $PINS O=n53 I1=B[30] I2=carry[30]
.ENDS

.SUBCKT div_DW01_sub_1 A[32] A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24]
+ A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12] A[11]
+ A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[32] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] CI DIFF[32] DIFF[31] DIFF[30] DIFF[29] DIFF[28] DIFF[27]
+ DIFF[26] DIFF[25] DIFF[24] DIFF[23] DIFF[22] DIFF[21] DIFF[20] DIFF[19]
+ DIFF[18] DIFF[17] DIFF[16] DIFF[15] DIFF[14] DIFF[13] DIFF[12] DIFF[11]
+ DIFF[10] DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3] DIFF[2]
+ DIFF[1] DIFF[0] CO FE_OCPN172_FE_OCPN339_n310
XFE_RC_2389_0 XNR2HS $PINS O=FE_RN_345_0 I1=A[17] I2=n75
XFE_RC_2388_0 XNR2HS $PINS O=FE_RN_1252_0 I1=A[29] I2=n87
XFE_OCPC664_FE_OFN86_n312 INV2 $PINS O=n59 I=B[1]
XFE_RC_2340_0 ND3P $PINS O=carry[13] I1=n40 I2=n41 I3=n42
XFE_RC_2339_0 ND3P $PINS O=carry[17] I1=n17 I2=n18 I3=n16
XFE_RC_2334_0 OR2 $PINS O=FE_RN_1569_0 I1=FE_RN_1428_0 I2=FE_RN_1424_0
XFE_RC_2333_0 ND2 $PINS O=carry[31] I1=FE_RN_1430_0 I2=FE_RN_1569_0
XFE_OFC644_FE_OFN96_raw_prime_3 INV2 $PINS O=n61 I=B[3]
XFE_OCPC412_carry_14 BUF1S $PINS O=FE_OCPN412_carry_14 I=carry[14]
XFE_OCPC410_carry_27 BUF1S $PINS O=FE_OCPN410_carry_27 I=carry[27]
XFE_OCPC374_carry_25 BUF1S $PINS O=FE_OCPN374_carry_25 I=carry[25]
XFE_OCPC373_carry_17 BUF1S $PINS O=FE_OCPN373_carry_17 I=carry[17]
XFE_OCPC369_carry_16 BUF1S $PINS O=FE_OCPN369_carry_16 I=carry[16]
XFE_OCPC262_carry_30 BUF1S $PINS O=FE_OCPN262_carry_30 I=carry[30]
XFE_RC_2094_0 INV1S $PINS O=FE_RN_1422_0 I=FE_RN_1429_0
XFE_RC_2093_0 AOI12HS $PINS O=FE_RN_1423_0 A1=FE_RN_1422_0 B1=A[30] B2=n88
XFE_RC_2092_0 INV1S $PINS O=FE_RN_1424_0 I=n88
XFE_RC_2091_0 INV1S $PINS O=FE_RN_1425_0 I=A[30]
XFE_RC_2090_0 AOI22S $PINS O=FE_RN_1426_0 A1=FE_RN_1425_0 A2=n88 B1=A[30]
+ B2=FE_RN_1424_0
XFE_RC_2089_0 MXL2HS $PINS OB=DIFF[30] S=FE_OCPN262_carry_30 A=FE_RN_1426_0
+ B=FE_RN_1423_0
XFE_RC_2087_0 INV1S $PINS O=FE_RN_1428_0 I=A[30]
XFE_RC_2086_0 OR2S $PINS O=FE_RN_1429_0 I1=n88 I2=A[30]
XFE_RC_2085_0 ND2 $PINS O=FE_RN_1430_0 I1=FE_RN_1429_0 I2=carry[30]
XFE_RC_1937_0 OR2 $PINS O=FE_RN_1312_0 I1=FE_RN_1254_0 I2=FE_RN_1253_0
XFE_RC_1936_0 ND2P $PINS O=carry[30] I1=FE_RN_1257_0 I2=FE_RN_1312_0
XFE_RC_1864_0 INV1S $PINS O=FE_RN_1248_0 I=FE_RN_1256_0
XFE_RC_1863_0 AOI12HS $PINS O=FE_RN_1249_0 A1=FE_RN_1248_0 B1=A[29] B2=n87
XFE_RC_1859_0 MXL2HS $PINS OB=DIFF[29] S=carry[29] A=FE_RN_1252_0
+ B=FE_RN_1249_0
XFE_RC_1858_0 INV1S $PINS O=FE_RN_1253_0 I=n87
XFE_RC_1857_0 INV1S $PINS O=FE_RN_1254_0 I=A[29]
XFE_RC_1856_0 INV1S $PINS O=FE_RN_1255_0 I=A[29]
XFE_RC_1855_0 OR2B1S $PINS O=FE_RN_1256_0 I1=n87 B1=FE_RN_1255_0
XFE_RC_1854_0 ND2 $PINS O=FE_RN_1257_0 I1=FE_RN_1256_0 I2=carry[29]
XFE_RC_1639_0 ND2 $PINS O=FE_RN_1084_0 I1=A[10] I2=n68
XFE_RC_1638_0 AN2 $PINS O=FE_RN_1085_0 I1=FE_RN_1088_0 I2=FE_RN_1084_0
XFE_RC_1637_0 XNR2HS $PINS O=FE_RN_1086_0 I1=n68 I2=A[10]
XFE_RC_1636_0 MXL2HS $PINS OB=DIFF[10] S=carry[10] A=FE_RN_1086_0
+ B=FE_RN_1085_0
XFE_RC_1635_0 ND2 $PINS O=FE_RN_1087_0 I1=A[10] I2=n68
XFE_RC_1634_0 OR2 $PINS O=FE_RN_1088_0 I1=n68 I2=A[10]
XFE_RC_1633_0 ND2 $PINS O=FE_RN_1089_0 I1=FE_RN_1088_0 I2=carry[10]
XFE_RC_1632_0 ND2P $PINS O=carry[11] I1=FE_RN_1089_0 I2=FE_RN_1087_0
XFE_RC_1506_0 OR2 $PINS O=FE_RN_991_0 I1=FE_RN_927_0 I2=FE_RN_923_0
XFE_RC_1505_0 ND2P $PINS O=carry[22] I1=FE_RN_929_0 I2=FE_RN_991_0
XFE_RC_1423_0 INV1S $PINS O=FE_RN_921_0 I=FE_RN_928_0
XFE_RC_1422_0 AOI12HS $PINS O=FE_RN_922_0 A1=FE_RN_921_0 B1=A[21] B2=n79
XFE_RC_1421_0 INV1S $PINS O=FE_RN_923_0 I=n79
XFE_RC_1420_0 INV1S $PINS O=FE_RN_924_0 I=A[21]
XFE_RC_1419_0 AOI22S $PINS O=FE_RN_925_0 A1=FE_RN_924_0 A2=n79 B1=A[21]
+ B2=FE_RN_923_0
XFE_RC_1418_0 MXL2HS $PINS OB=DIFF[21] S=carry[21] A=FE_RN_925_0 B=FE_RN_922_0
XFE_RC_1416_0 INV1S $PINS O=FE_RN_927_0 I=A[21]
XFE_RC_1415_0 OR2S $PINS O=FE_RN_928_0 I1=n79 I2=A[21]
XFE_RC_1414_0 ND2 $PINS O=FE_RN_929_0 I1=FE_RN_928_0 I2=carry[21]
XFE_RC_1196_0 ND2S $PINS O=FE_RN_762_0 I1=A[22] I2=n80
XFE_RC_1195_0 AN2 $PINS O=FE_RN_763_0 I1=FE_RN_766_0 I2=FE_RN_762_0
XFE_RC_1194_0 XNR2HS $PINS O=FE_RN_764_0 I1=n80 I2=A[22]
XFE_RC_1193_0 MXL2HS $PINS OB=DIFF[22] S=carry[22] A=FE_RN_764_0 B=FE_RN_763_0
XFE_RC_1192_0 ND2S $PINS O=FE_RN_765_0 I1=A[22] I2=n80
XFE_RC_1191_0 OR2 $PINS O=FE_RN_766_0 I1=n80 I2=A[22]
XFE_RC_1190_0 ND2 $PINS O=FE_RN_767_0 I1=FE_RN_766_0 I2=carry[22]
XFE_RC_1189_0 ND2P $PINS O=carry[23] I1=FE_RN_767_0 I2=FE_RN_765_0
XFE_RC_983_0 AN2 $PINS O=FE_RN_605_0 I1=A[28] I2=n86
XFE_RC_982_0 AN2B1S $PINS O=FE_RN_606_0 I1=FE_RN_609_0 B1=FE_RN_605_0
XFE_RC_981_0 XNR2HS $PINS O=FE_RN_607_0 I1=n86 I2=A[28]
XFE_RC_980_0 MXL2HS $PINS OB=DIFF[28] S=carry[28] A=FE_RN_607_0 B=FE_RN_606_0
XFE_RC_979_0 ND2S $PINS O=FE_RN_608_0 I1=A[28] I2=n86
XFE_RC_978_0 OR2S $PINS O=FE_RN_609_0 I1=n86 I2=A[28]
XFE_RC_977_0 ND2 $PINS O=FE_RN_610_0 I1=FE_RN_609_0 I2=carry[28]
XFE_RC_976_0 ND2P $PINS O=carry[29] I1=FE_RN_610_0 I2=FE_RN_608_0
XFE_RC_824_0 ND2 $PINS O=FE_RN_485_0 I1=A[23] I2=n81
XFE_RC_823_0 AN2 $PINS O=FE_RN_486_0 I1=FE_RN_489_0 I2=FE_RN_485_0
XFE_RC_822_0 XNR2HS $PINS O=FE_RN_487_0 I1=n81 I2=A[23]
XFE_RC_821_0 MXL2HS $PINS OB=DIFF[23] S=carry[23] A=FE_RN_487_0 B=FE_RN_486_0
XFE_RC_820_0 ND2 $PINS O=FE_RN_488_0 I1=A[23] I2=n81
XFE_RC_819_0 OR2S $PINS O=FE_RN_489_0 I1=n81 I2=A[23]
XFE_RC_818_0 ND2 $PINS O=FE_RN_490_0 I1=FE_RN_489_0 I2=carry[23]
XFE_RC_817_0 ND2P $PINS O=carry[24] I1=FE_RN_490_0 I2=FE_RN_488_0
XFE_RC_625_0 INV1S $PINS O=FE_RN_341_0 I=FE_RN_348_0
XFE_RC_624_0 AOI12HS $PINS O=FE_RN_342_0 A1=FE_RN_341_0 B1=A[17] B2=n75
XFE_RC_620_0 MXL2HS $PINS OB=DIFF[17] S=FE_OCPN373_carry_17 A=FE_RN_345_0
+ B=FE_RN_342_0
XFE_RC_619_0 ND2S $PINS O=FE_RN_346_0 I1=A[17] I2=n75
XFE_RC_618_0 INV1S $PINS O=FE_RN_347_0 I=A[17]
XFE_RC_617_0 OR2B1S $PINS O=FE_RN_348_0 I1=n75 B1=FE_RN_347_0
XFE_RC_616_0 ND2 $PINS O=FE_RN_349_0 I1=FE_RN_348_0 I2=carry[17]
XFE_RC_615_0 ND2P $PINS O=carry[18] I1=FE_RN_349_0 I2=FE_RN_346_0
XFE_RC_439_0 ND2S $PINS O=FE_RN_213_0 I1=A[18] I2=n76
XFE_RC_438_0 AN2 $PINS O=FE_RN_214_0 I1=FE_RN_217_0 I2=FE_RN_213_0
XFE_RC_437_0 XNR2HS $PINS O=FE_RN_215_0 I1=n76 I2=A[18]
XFE_RC_436_0 MXL2HS $PINS OB=DIFF[18] S=carry[18] A=FE_RN_215_0 B=FE_RN_214_0
XFE_RC_435_0 ND2S $PINS O=FE_RN_216_0 I1=A[18] I2=n76
XFE_RC_434_0 OR2 $PINS O=FE_RN_217_0 I1=n76 I2=A[18]
XFE_RC_433_0 ND2 $PINS O=FE_RN_218_0 I1=FE_RN_217_0 I2=carry[18]
XFE_RC_432_0 ND2P $PINS O=carry[19] I1=FE_RN_218_0 I2=FE_RN_216_0
XFE_RC_253_0 ND3P $PINS O=carry[26] I1=n25 I2=n26 I3=n24
XFE_RC_224_0 ND2 $PINS O=FE_RN_82_0 I1=A[19] I2=n77
XFE_RC_223_0 AN2 $PINS O=FE_RN_83_0 I1=FE_RN_86_0 I2=FE_RN_82_0
XFE_RC_222_0 XNR2HS $PINS O=FE_RN_84_0 I1=n77 I2=A[19]
XFE_RC_221_0 MXL2HS $PINS OB=DIFF[19] S=carry[19] A=FE_RN_84_0 B=FE_RN_83_0
XFE_RC_220_0 ND2 $PINS O=FE_RN_85_0 I1=A[19] I2=n77
XFE_RC_219_0 OR2S $PINS O=FE_RN_86_0 I1=n77 I2=A[19]
XFE_RC_218_0 ND2 $PINS O=FE_RN_87_0 I1=FE_RN_86_0 I2=carry[19]
XFE_RC_217_0 ND2P $PINS O=carry[20] I1=FE_RN_87_0 I2=FE_RN_85_0
XFE_RC_135_0 ND3P $PINS O=carry[16] I1=n13 I2=n14 I3=n12
XFE_RC_131_0 ND3P $PINS O=carry[27] I1=n30 I2=n29 I3=n28
XFE_RC_130_0 ND3P $PINS O=carry[14] I1=n35 I2=n36 I3=n34
XFE_RC_127_0 XOR3 $PINS O=DIFF[11] I1=A[11] I2=n69 I3=carry[11]
XFE_RC_126_0 MAO222P $PINS O=carry[12] A1=A[11] B1=n69 C1=carry[11]
XFE_RC_100_0 INV1S $PINS O=FE_RN_43_0 I=n19
XFE_RC_99_0 ND3P $PINS O=carry[28] I1=n33 I2=n32 I3=FE_RN_43_0
XFE_RC_98_0 INV1S $PINS O=FE_RN_42_0 I=n27
XFE_RC_97_0 ND3P $PINS O=carry[15] I1=n39 I2=n38 I3=FE_RN_42_0
XFE_RC_81_0 ND3P $PINS O=carry[25] I1=n22 I2=n21 I3=n20
XFE_OFC239_div_out_0 INV1S $PINS O=n57 I=A[0]
XFE_OFC215_raw_prime_5 INV1S $PINS O=n63 I=B[5]
XFE_OFC201_raw_prime_9 INV1S $PINS O=n67 I=B[9]
XFE_OFC177_raw_prime_10 INV1S $PINS O=n68 I=B[10]
XFE_OFC164_raw_prime_7 INV1S $PINS O=n65 I=B[7]
XFE_OFC155_raw_prime_6 INV1S $PINS O=n64 I=B[6]
XFE_OFC124_raw_prime_8 INV1S $PINS O=n66 I=B[8]
XFE_OFC92_raw_prime_4 INV1S $PINS O=n62 I=B[4]
XU2_31 FA1 $PINS S=DIFF[31] CO=carry[32] A=A[31] B=n89 CI=carry[31]
XU2_9 FA1 $PINS S=DIFF[9] CO=carry[10] A=A[9] B=n67 CI=carry[9]
XU2_8 FA1 $PINS S=DIFF[8] CO=carry[9] A=A[8] B=n66 CI=carry[8]
XU2_7 FA1 $PINS S=DIFF[7] CO=carry[8] A=A[7] B=n65 CI=carry[7]
XU1 ND2 $PINS O=n2 I1=carry[1] I2=A[1]
XU2 ND2P $PINS O=carry[5] I1=n55 I2=n5
XU3 ND2P $PINS O=n7 I1=carry[5] I2=A[5]
XU4 ND2P $PINS O=n6 I1=carry[5] I2=n63
XU5 ND2P $PINS O=n9 I1=carry[6] I2=n64
XU6 ND2P $PINS O=n10 I1=carry[6] I2=A[6]
XU7 XOR3 $PINS O=DIFF[12] I1=n70 I2=A[12] I3=carry[12]
XU8 XOR3 $PINS O=DIFF[24] I1=A[24] I2=n82 I3=carry[24]
XU9 XOR3 $PINS O=DIFF[20] I1=n78 I2=A[20] I3=carry[20]
XU10 XOR3 $PINS O=DIFF[3] I1=A[3] I2=n61 I3=carry[3]
XU11 XOR3 $PINS O=DIFF[13] I1=A[13] I2=n71 I3=carry[13]
XU12 ND3P $PINS O=carry[21] I1=n43 I2=n44 I3=n45
XU13 ND2 $PINS O=n55 I1=n62 I2=carry[4]
XU15 ND3HT $PINS O=carry[6] I1=n6 I2=n7 I3=n8
XU16 XOR3 $PINS O=DIFF[26] I1=A[26] I2=n84 I3=carry[26]
XU17 XOR3S $PINS O=DIFF[1] I1=n59 I2=A[1] I3=carry[1]
XU19 ND2 $PINS O=n54 I1=A[4] I2=carry[4]
XU20 ND3P $PINS O=carry[4] I1=n51 I2=n50 I3=n49
XU21 XOR3 $PINS O=DIFF[15] I1=A[15] I2=n73 I3=carry[15]
XU22 XOR3 $PINS O=DIFF[2] I1=B[2] I2=A[2] I3=carry[2]
XU23 ND3P $PINS O=carry[2] I1=n1 I2=n2 I3=n3
XU24 XOR3 $PINS O=DIFF[6] I1=n64 I2=A[6] I3=carry[6]
XU26 ND2P $PINS O=n4 I1=n54 I2=n53
XU27 ND2 $PINS O=n53 I1=A[4] I2=n62
XU28 INV1S $PINS O=n58 I=FE_OCPN172_FE_OCPN339_n310
XU29 XOR3 $PINS O=DIFF[5] I1=n63 I2=A[5] I3=carry[5]
XU30 ND2 $PINS O=n1 I1=carry[1] I2=n59
XU31 ND2 $PINS O=n3 I1=n59 I2=A[1]
XU32 INV2CK $PINS O=n5 I=n4
XU33 ND3P $PINS O=carry[7] I1=n9 I2=n10 I3=n11
XU36 INV1S $PINS O=n70 I=B[12]
XU38 ND2 $PINS O=n12 I1=A[15] I2=n73
XU39 ND2 $PINS O=n17 I1=A[16] I2=carry[16]
XU40 ND2P $PINS O=n44 I1=carry[20] I2=A[20]
XU41 ND2 $PINS O=n28 I1=A[26] I2=n84
XU42 ND2 $PINS O=n20 I1=A[24] I2=n82
XU44 ND2 $PINS O=n49 I1=A[3] I2=n61
XU46 ND2 $PINS O=n40 I1=carry[12] I2=n70
XU47 ND2 $PINS O=n41 I1=carry[12] I2=A[12]
XU49 ND2 $PINS O=n34 I1=A[13] I2=n71
XU50 ND2 $PINS O=n35 I1=A[13] I2=carry[13]
XU51 ND2 $PINS O=n36 I1=carry[13] I2=n71
XU52 INV1S $PINS O=n78 I=B[20]
XU54 ND2 $PINS O=n8 I1=n63 I2=A[5]
XU56 ND2 $PINS O=n11 I1=n64 I2=A[6]
XU57 ND2 $PINS O=n13 I1=A[15] I2=carry[15]
XU58 ND2 $PINS O=n14 I1=n73 I2=carry[15]
XU59 XOR2HS $PINS O=n15 I1=A[16] I2=n74
XU60 XOR2HS $PINS O=DIFF[16] I1=n15 I2=FE_OCPN369_carry_16
XU61 ND2S $PINS O=n16 I1=A[16] I2=n74
XU62 ND2 $PINS O=n18 I1=n74 I2=carry[16]
XU64 AN2 $PINS O=n19 I1=A[27] I2=n85
XU65 ND2 $PINS O=n21 I1=A[24] I2=carry[24]
XU66 ND2 $PINS O=n22 I1=n82 I2=carry[24]
XU68 XOR2HS $PINS O=n23 I1=A[25] I2=n83
XU69 XOR2HS $PINS O=DIFF[25] I1=n23 I2=FE_OCPN374_carry_25
XU70 ND2S $PINS O=n24 I1=A[25] I2=n83
XU71 ND2 $PINS O=n25 I1=A[25] I2=carry[25]
XU72 ND2 $PINS O=n26 I1=n83 I2=carry[25]
XU74 AN2 $PINS O=n27 I1=A[14] I2=n72
XU75 ND2 $PINS O=n29 I1=A[26] I2=carry[26]
XU76 ND2 $PINS O=n30 I1=n84 I2=carry[26]
XU78 XOR2HS $PINS O=n31 I1=A[27] I2=n85
XU79 XOR2HS $PINS O=DIFF[27] I1=n31 I2=FE_OCPN410_carry_27
XU80 ND2 $PINS O=n32 I1=A[27] I2=carry[27]
XU81 ND2 $PINS O=n33 I1=n85 I2=carry[27]
XU82 XOR2HS $PINS O=n37 I1=A[14] I2=n72
XU83 XOR2HS $PINS O=DIFF[14] I1=n37 I2=FE_OCPN412_carry_14
XU84 ND2 $PINS O=n38 I1=A[14] I2=carry[14]
XU85 ND2 $PINS O=n39 I1=n72 I2=carry[14]
XU86 ND2S $PINS O=n42 I1=n70 I2=A[12]
XU87 ND2 $PINS O=n43 I1=carry[20] I2=n78
XU88 ND2S $PINS O=n45 I1=n78 I2=A[20]
XU89 ND2 $PINS O=n46 I1=carry[2] I2=B[2]
XU90 ND2 $PINS O=n47 I1=carry[2] I2=A[2]
XU91 ND2S $PINS O=n48 I1=B[2] I2=A[2]
XU92 ND3P $PINS O=carry[3] I1=n46 I2=n47 I3=n48
XU93 ND2 $PINS O=n50 I1=A[3] I2=carry[3]
XU94 ND2 $PINS O=n51 I1=n61 I2=carry[3]
XU95 XOR2HS $PINS O=n52 I1=A[4] I2=n62
XU96 XOR2HS $PINS O=DIFF[4] I1=n52 I2=carry[4]
XU98 INV1S $PINS O=n88 I=B[30]
XU99 INV1S $PINS O=n80 I=B[22]
XU102 INV1S $PINS O=n86 I=B[28]
XU103 INV1S $PINS O=n84 I=B[26]
XU104 INV1S $PINS O=n82 I=B[24]
XU105 INV1S $PINS O=n76 I=B[18]
XU106 INV1S $PINS O=n74 I=B[16]
XU107 INV1S $PINS O=n72 I=B[14]
XU109 INV1S $PINS O=n89 I=B[31]
XU110 XNR2HS $PINS O=DIFF[32] I1=A[32] I2=carry[32]
XU111 INV1S $PINS O=n87 I=B[29]
XU112 INV1S $PINS O=n79 I=B[21]
XU113 INV1S $PINS O=n71 I=B[13]
XU114 INV1S $PINS O=n75 I=B[17]
XU115 INV1S $PINS O=n81 I=B[23]
XU116 INV1S $PINS O=n77 I=B[19]
XU117 INV1S $PINS O=n73 I=B[15]
XU118 INV1S $PINS O=n85 I=B[27]
XU119 INV1S $PINS O=n83 I=B[25]
XU120 INV1S $PINS O=n69 I=B[11]
XU123 XNR2HS $PINS O=DIFF[0] I1=n58 I2=A[0]
XU124 ND2P $PINS O=carry[1] I1=B[0] I2=n57
.ENDS

.SUBCKT div_DW01_sub_2 A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24] A[23]
+ A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12] A[11] A[10]
+ A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30] B[29] B[28]
+ B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15]
+ B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1]
+ B[0] CI DIFF[31] DIFF[30] DIFF[29] DIFF[28] DIFF[27] DIFF[26] DIFF[25]
+ DIFF[24] DIFF[23] DIFF[22] DIFF[21] DIFF[20] DIFF[19] DIFF[18] DIFF[17]
+ DIFF[16] DIFF[15] DIFF[14] DIFF[13] DIFF[12] DIFF[11] DIFF[10] DIFF[9]
+ DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3] DIFF[2] DIFF[1] DIFF[0] CO
XFE_RC_2272_0 XOR3 $PINS O=DIFF[28] I1=A[28] I2=n46 I3=carry[28]
XFE_RC_2271_0 MAO222P $PINS O=carry[29] A1=A[28] B1=n46 C1=carry[28]
XFE_RC_2164_0 ND3P $PINS O=carry[26] I1=n4 I2=n5 I3=n6
XFE_RC_2163_0 ND2S $PINS O=FE_RN_1476_0 I1=A[23] I2=n51
XFE_RC_2162_0 AN2 $PINS O=FE_RN_1477_0 I1=FE_RN_1480_0 I2=FE_RN_1476_0
XFE_RC_2161_0 XNR2HS $PINS O=FE_RN_1478_0 I1=n51 I2=A[23]
XFE_RC_2160_0 MXL2HS $PINS OB=DIFF[23] S=carry[23] A=FE_RN_1478_0
+ B=FE_RN_1477_0
XFE_RC_2158_0 OR2 $PINS O=FE_RN_1480_0 I1=n51 I2=A[23]
XFE_RC_2157_0 ND2 $PINS O=FE_RN_1481_0 I1=FE_RN_1480_0 I2=carry[23]
XFE_RC_2156_0 ND2P $PINS O=carry[24] I1=FE_RN_1481_0 I2=FE_RN_1476_0
XFE_RC_1953_0 INV1S $PINS O=FE_RN_1319_0 I=FE_RN_1323_0
XFE_RC_1952_0 AOI12HS $PINS O=FE_RN_1320_0 A1=FE_RN_1319_0 B1=A[26] B2=n48
XFE_RC_1951_0 XNR2HS $PINS O=FE_RN_1321_0 I1=n48 I2=A[26]
XFE_RC_1950_0 MXL2HS $PINS OB=DIFF[26] S=carry[26] A=FE_RN_1321_0
+ B=FE_RN_1320_0
XFE_RC_1949_0 ND2S $PINS O=FE_RN_1322_0 I1=A[26] I2=n48
XFE_RC_1948_0 OR2 $PINS O=FE_RN_1323_0 I1=n48 I2=A[26]
XFE_RC_1947_0 ND2 $PINS O=FE_RN_1324_0 I1=FE_RN_1323_0 I2=carry[26]
XFE_RC_1946_0 ND2P $PINS O=carry[27] I1=FE_RN_1324_0 I2=FE_RN_1322_0
XFE_RC_1697_0 ND3P $PINS O=carry[30] I1=n35 I2=n36 I3=n37
XFE_RC_1667_0 ND2S $PINS O=FE_RN_1104_0 I1=A[6] I2=n68
XFE_RC_1666_0 AN2 $PINS O=FE_RN_1105_0 I1=FE_RN_1108_0 I2=FE_RN_1104_0
XFE_RC_1665_0 XNR2HS $PINS O=FE_RN_1106_0 I1=n68 I2=A[6]
XFE_RC_1664_0 MXL2HS $PINS OB=DIFF[6] S=carry[6] A=FE_RN_1106_0 B=FE_RN_1105_0
XFE_RC_1662_0 OR2 $PINS O=FE_RN_1108_0 I1=n68 I2=A[6]
XFE_RC_1661_0 ND2 $PINS O=FE_RN_1109_0 I1=FE_RN_1108_0 I2=carry[6]
XFE_RC_1660_0 ND2P $PINS O=carry[7] I1=FE_RN_1109_0 I2=FE_RN_1104_0
XFE_RC_1451_0 ND2S $PINS O=FE_RN_944_0 I1=A[7] I2=n67
XFE_RC_1450_0 AN2 $PINS O=FE_RN_945_0 I1=FE_RN_948_0 I2=FE_RN_944_0
XFE_RC_1449_0 XNR2HS $PINS O=FE_RN_946_0 I1=n67 I2=A[7]
XFE_RC_1448_0 MXL2HS $PINS OB=DIFF[7] S=carry[7] A=FE_RN_946_0 B=FE_RN_945_0
XFE_RC_1446_0 OR2 $PINS O=FE_RN_948_0 I1=n67 I2=A[7]
XFE_RC_1445_0 ND2 $PINS O=FE_RN_949_0 I1=FE_RN_948_0 I2=carry[7]
XFE_RC_1444_0 ND2P $PINS O=carry[8] I1=FE_RN_949_0 I2=FE_RN_944_0
XFE_RC_1227_0 ND2S $PINS O=FE_RN_781_0 I1=A[24] I2=n50
XFE_RC_1226_0 AN2 $PINS O=FE_RN_782_0 I1=FE_RN_785_0 I2=FE_RN_781_0
XFE_RC_1225_0 XNR2HS $PINS O=FE_RN_783_0 I1=n50 I2=A[24]
XFE_RC_1224_0 MXL2HS $PINS OB=DIFF[24] S=carry[24] A=FE_RN_783_0 B=FE_RN_782_0
XFE_RC_1222_0 OR2 $PINS O=FE_RN_785_0 I1=n50 I2=A[24]
XFE_RC_1221_0 ND2 $PINS O=FE_RN_786_0 I1=FE_RN_785_0 I2=carry[24]
XFE_RC_1220_0 ND2P $PINS O=carry[25] I1=FE_RN_786_0 I2=FE_RN_781_0
XFE_RC_1198_0 ND3P $PINS O=carry[17] I1=n29 I2=n28 I3=n30
XFE_RC_1197_0 ND3P $PINS O=carry[4] I1=n2 I2=n1 I3=n3
XU2_20 FA1 $PINS S=DIFF[20] CO=carry[21] A=A[20] B=n54 CI=carry[20]
XU2_21 FA1 $PINS S=DIFF[21] CO=carry[22] A=A[21] B=n53 CI=carry[21]
XU2_5 FA1 $PINS S=DIFF[5] CO=carry[6] A=A[5] B=n69 CI=carry[5]
XU2_31 XOR3 $PINS O=DIFF[31] I1=A[31] I2=B[31] I3=carry[31]
XU2_30 FA1 $PINS S=DIFF[30] CO=carry[31] A=A[30] B=n44 CI=carry[30]
XU2_18 FA1 $PINS S=DIFF[18] CO=carry[19] A=A[18] B=n56 CI=carry[18]
XU2_2 FA1 $PINS S=DIFF[2] CO=carry[3] A=A[2] B=n72 CI=carry[2]
XU2_1 FA1 $PINS S=DIFF[1] CO=carry[2] A=A[1] B=n73 CI=carry[1]
XU2_19 FA1 $PINS S=DIFF[19] CO=carry[20] A=A[19] B=n55 CI=carry[19]
XU2_4 FA1 $PINS S=DIFF[4] CO=carry[5] A=A[4] B=n70 CI=carry[4]
XU2_22 FA1 $PINS S=DIFF[22] CO=carry[23] A=A[22] B=n52 CI=carry[22]
XU1 INV1S $PINS O=n73 I=B[1]
XU2 XOR3 $PINS O=DIFF[9] I1=n65 I2=A[9] I3=carry[9]
XU3 XOR3 $PINS O=DIFF[16] I1=n58 I2=A[16] I3=carry[16]
XU4 XOR3 $PINS O=DIFF[11] I1=n63 I2=A[11] I3=carry[11]
XU5 XOR3 $PINS O=DIFF[17] I1=n57 I2=A[17] I3=carry[17]
XU6 XOR3 $PINS O=DIFF[13] I1=n61 I2=A[13] I3=carry[13]
XU7 XOR3 $PINS O=DIFF[14] I1=n60 I2=A[14] I3=carry[14]
XU8 ND3P $PINS O=carry[11] I1=n16 I2=n17 I3=n18
XU9 ND3P $PINS O=carry[9] I1=n7 I2=n8 I3=n9
XU11 ND3P $PINS O=carry[13] I1=n38 I2=n39 I3=n40
XU12 ND3P $PINS O=carry[16] I1=n19 I2=n20 I3=n21
XU13 ND3P $PINS O=carry[14] I1=n41 I2=n42 I3=n43
XU14 XOR3 $PINS O=DIFF[15] I1=n59 I2=A[15] I3=carry[15]
XU15 XOR3 $PINS O=DIFF[10] I1=n64 I2=A[10] I3=carry[10]
XU16 XOR3 $PINS O=DIFF[3] I1=n71 I2=A[3] I3=carry[3]
XU17 XOR3 $PINS O=DIFF[8] I1=n66 I2=A[8] I3=carry[8]
XU18 XOR3 $PINS O=DIFF[27] I1=n47 I2=A[27] I3=carry[27]
XU19 XOR3 $PINS O=DIFF[25] I1=n49 I2=A[25] I3=carry[25]
XU20 XOR3 $PINS O=DIFF[12] I1=n62 I2=A[12] I3=carry[12]
XU21 ND2 $PINS O=n2 I1=carry[3] I2=A[3]
XU22 INV1S $PINS O=n71 I=B[3]
XU23 ND2S $PINS O=n3 I1=n71 I2=A[3]
XU25 INV1S $PINS O=n66 I=B[8]
XU26 INV1S $PINS O=n49 I=B[25]
XU28 ND2 $PINS O=n1 I1=carry[3] I2=n71
XU29 ND2 $PINS O=n4 I1=carry[25] I2=n49
XU30 ND2 $PINS O=n5 I1=carry[25] I2=A[25]
XU31 ND2S $PINS O=n6 I1=n49 I2=A[25]
XU32 ND2 $PINS O=n7 I1=carry[8] I2=n66
XU33 ND2 $PINS O=n8 I1=carry[8] I2=A[8]
XU34 ND2S $PINS O=n9 I1=n66 I2=A[8]
XU35 ND3P $PINS O=carry[10] I1=n10 I2=n11 I3=n12
XU36 ND3P $PINS O=carry[15] I1=n13 I2=n14 I3=n15
XU37 ND3P $PINS O=carry[12] I1=n25 I2=n26 I3=n27
XU38 INV1S $PINS O=n65 I=B[9]
XU39 INV1S $PINS O=n60 I=B[14]
XU40 ND2 $PINS O=n10 I1=carry[9] I2=n65
XU41 ND2 $PINS O=n11 I1=carry[9] I2=A[9]
XU42 ND2S $PINS O=n12 I1=n65 I2=A[9]
XU43 ND2 $PINS O=n13 I1=carry[14] I2=n60
XU44 ND2 $PINS O=n14 I1=carry[14] I2=A[14]
XU45 ND2S $PINS O=n15 I1=n60 I2=A[14]
XU46 INV1S $PINS O=n59 I=B[15]
XU47 INV1S $PINS O=n64 I=B[10]
XU48 ND2 $PINS O=n16 I1=carry[10] I2=n64
XU49 ND2 $PINS O=n17 I1=carry[10] I2=A[10]
XU50 ND2S $PINS O=n18 I1=n64 I2=A[10]
XU51 ND2 $PINS O=n19 I1=carry[15] I2=n59
XU52 ND2 $PINS O=n20 I1=carry[15] I2=A[15]
XU53 ND2S $PINS O=n21 I1=n59 I2=A[15]
XU54 INV1S $PINS O=n62 I=B[12]
XU55 INV1S $PINS O=n63 I=B[11]
XU56 INV1S $PINS O=n58 I=B[16]
XU57 INV1S $PINS O=n47 I=B[27]
XU58 ND3P $PINS O=carry[28] I1=n22 I2=n23 I3=n24
XU59 ND2 $PINS O=n22 I1=carry[27] I2=n47
XU60 ND2 $PINS O=n23 I1=carry[27] I2=A[27]
XU61 ND2S $PINS O=n24 I1=n47 I2=A[27]
XU62 ND2 $PINS O=n25 I1=carry[11] I2=n63
XU63 ND2 $PINS O=n26 I1=carry[11] I2=A[11]
XU64 ND2S $PINS O=n27 I1=n63 I2=A[11]
XU65 ND2 $PINS O=n28 I1=carry[16] I2=n58
XU66 ND2 $PINS O=n29 I1=carry[16] I2=A[16]
XU67 ND2S $PINS O=n30 I1=n58 I2=A[16]
XU68 INV1S $PINS O=n45 I=B[29]
XU70 INV1S $PINS O=n57 I=B[17]
XU71 ND3P $PINS O=carry[18] I1=n31 I2=n32 I3=n33
XU72 ND2 $PINS O=n31 I1=carry[17] I2=n57
XU73 ND2 $PINS O=n32 I1=carry[17] I2=A[17]
XU74 ND2S $PINS O=n33 I1=n57 I2=A[17]
XU75 XOR2HS $PINS O=n34 I1=n45 I2=A[29]
XU76 XOR2HS $PINS O=DIFF[29] I1=carry[29] I2=n34
XU77 ND2 $PINS O=n35 I1=carry[29] I2=n45
XU78 ND2 $PINS O=n36 I1=carry[29] I2=A[29]
XU79 ND2S $PINS O=n37 I1=n45 I2=A[29]
XU80 ND2 $PINS O=n38 I1=carry[12] I2=n62
XU81 ND2 $PINS O=n39 I1=carry[12] I2=A[12]
XU82 ND2S $PINS O=n40 I1=n62 I2=A[12]
XU83 INV1S $PINS O=n61 I=B[13]
XU84 ND2 $PINS O=n41 I1=carry[13] I2=n61
XU85 ND2 $PINS O=n42 I1=carry[13] I2=A[13]
XU86 ND2S $PINS O=n43 I1=n61 I2=A[13]
XU87 INV1S $PINS O=n51 I=B[23]
XU88 INV1S $PINS O=n69 I=B[5]
XU89 INV1S $PINS O=n55 I=B[19]
XU90 INV1S $PINS O=n67 I=B[7]
XU91 INV1S $PINS O=n53 I=B[21]
XU92 INV1S $PINS O=n44 I=B[30]
XU93 INV1S $PINS O=n46 I=B[28]
XU94 INV1S $PINS O=n48 I=B[26]
XU95 INV1S $PINS O=n50 I=B[24]
XU96 INV1S $PINS O=n56 I=B[18]
XU97 INV1S $PINS O=n68 I=B[6]
XU98 INV1S $PINS O=n54 I=B[20]
XU99 INV1S $PINS O=n72 I=B[2]
XU100 INV1S $PINS O=n70 I=B[4]
XU101 INV1S $PINS O=n52 I=B[22]
XU103 OR2B1S $PINS O=carry[1] I1=A[0] B1=B[0]
.ENDS

.SUBCKT div_DW01_sub_3 A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24] A[23]
+ A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12] A[11] A[10]
+ A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30] B[29] B[28]
+ B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15]
+ B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1]
+ B[0] CI DIFF[31] DIFF[30] DIFF[29] DIFF[28] DIFF[27] DIFF[26] DIFF[25]
+ DIFF[24] DIFF[23] DIFF[22] DIFF[21] DIFF[20] DIFF[19] DIFF[18] DIFF[17]
+ DIFF[16] DIFF[15] DIFF[14] DIFF[13] DIFF[12] DIFF[11] DIFF[10] DIFF[9]
+ DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3] DIFF[2] DIFF[1] DIFF[0] CO p1
+ p2
XFE_RC_2355_0 ND2S $PINS O=FE_RN_1570_0 I1=A[20] I2=n56
XFE_RC_2354_0 AN2 $PINS O=FE_RN_1571_0 I1=FE_RN_1574_0 I2=FE_RN_1570_0
XFE_RC_2353_0 XNR2HS $PINS O=FE_RN_1572_0 I1=n56 I2=A[20]
XFE_RC_2352_0 MXL2HS $PINS OB=DIFF[20] S=carry[20] A=FE_RN_1572_0
+ B=FE_RN_1571_0
XFE_RC_2350_0 OR2 $PINS O=FE_RN_1574_0 I1=n56 I2=A[20]
XFE_RC_2349_0 ND2 $PINS O=FE_RN_1575_0 I1=FE_RN_1574_0 I2=carry[20]
XFE_RC_2348_0 ND2P $PINS O=carry[21] I1=FE_RN_1575_0 I2=FE_RN_1570_0
XFE_RC_2338_0 XOR3 $PINS O=DIFF[7] I1=A[7] I2=n69 I3=carry[7]
XFE_RC_2337_0 MAO222 $PINS O=carry[8] A1=A[7] B1=n69 C1=carry[7]
XFE_RC_2335_0 ND3P $PINS O=carry[9] I1=n13 I2=n14 I3=n15
XFE_RC_2314_0 ND3 $PINS O=carry[5] I1=n1 I2=n2 I3=n3
XFE_RC_2199_0 ND2S $PINS O=FE_RN_1502_0 I1=A[10] I2=n66
XFE_RC_2198_0 AN2 $PINS O=FE_RN_1503_0 I1=FE_RN_1506_0 I2=FE_RN_1502_0
XFE_RC_2197_0 XNR2HS $PINS O=FE_RN_1504_0 I1=n66 I2=A[10]
XFE_RC_2196_0 MXL2HS $PINS OB=DIFF[10] S=carry[10] A=FE_RN_1504_0
+ B=FE_RN_1503_0
XFE_RC_2194_0 OR2 $PINS O=FE_RN_1506_0 I1=n66 I2=A[10]
XFE_RC_2193_0 ND2 $PINS O=FE_RN_1507_0 I1=FE_RN_1506_0 I2=carry[10]
XFE_RC_2192_0 ND2P $PINS O=carry[11] I1=FE_RN_1507_0 I2=FE_RN_1502_0
XFE_RC_1954_0 ND3P $PINS O=carry[27] I1=n29 I2=n28 I3=n30
XFE_RC_1945_0 ND2 $PINS O=FE_RN_1313_0 I1=A[21] I2=n55
XFE_RC_1944_0 AN2 $PINS O=FE_RN_1314_0 I1=FE_RN_1317_0 I2=FE_RN_1313_0
XFE_RC_1943_0 XNR2HS $PINS O=FE_RN_1315_0 I1=n55 I2=p2
XFE_RC_1942_0 MXL2HS $PINS OB=DIFF[21] S=carry[21] A=FE_RN_1315_0
+ B=FE_RN_1314_0
XFE_RC_1940_0 OR2 $PINS O=FE_RN_1317_0 I1=n55 I2=p2
XFE_RC_1939_0 ND2 $PINS O=FE_RN_1318_0 I1=FE_RN_1317_0 I2=carry[21]
XFE_RC_1938_0 ND2P $PINS O=carry[22] I1=FE_RN_1318_0 I2=FE_RN_1313_0
XFE_RC_1754_0 INV1S $PINS O=FE_RN_1166_0 I=FE_RN_1174_0
XFE_RC_1753_0 AOI12HS $PINS O=FE_RN_1167_0 A1=FE_RN_1166_0 B1=A[27] B2=n49
XFE_RC_1752_0 INV1S $PINS O=FE_RN_1168_0 I=A[27]
XFE_RC_1750_0 NR2 $PINS O=FE_RN_1170_0 I1=n49 I2=FE_RN_1168_0
XFE_RC_1749_0 AOI12HS $PINS O=FE_RN_1171_0 A1=FE_RN_1170_0 B1=FE_RN_1168_0
+ B2=n49
XFE_RC_1748_0 MXL2HS $PINS OB=DIFF[27] S=carry[27] A=FE_RN_1171_0
+ B=FE_RN_1167_0
XFE_RC_1747_0 ND2 $PINS O=FE_RN_1172_0 I1=A[27] I2=n49
XFE_RC_1745_0 OR2B1S $PINS O=FE_RN_1174_0 I1=n49 B1=FE_RN_1168_0
XFE_RC_1744_0 ND2 $PINS O=FE_RN_1175_0 I1=FE_RN_1174_0 I2=carry[27]
XFE_RC_1743_0 ND2P $PINS O=carry[28] I1=FE_RN_1175_0 I2=FE_RN_1172_0
XFE_RC_1640_0 ND3P $PINS O=carry[25] I1=n22 I2=n23 I3=n24
XFE_RC_1631_0 ND3P $PINS O=carry[3] I1=n4 I2=n5 I3=n6
XFE_RC_1432_0 INV1S $PINS O=FE_RN_930_0 I=FE_RN_931_0
XFE_RC_1431_0 XOR2HS $PINS O=FE_RN_931_0 I1=n73 I2=A[3]
XFE_RC_1429_0 ND2 $PINS O=FE_RN_933_0 I1=FE_RN_930_0 I2=carry[3]
XFE_RC_1428_0 OAI12HS $PINS O=DIFF[3] A1=FE_RN_933_0 B1=FE_RN_930_0 B2=carry[3]
XFE_RC_1427_0 INV1S $PINS O=FE_RN_934_0 I=A[3]
XFE_RC_1426_0 OR2B1S $PINS O=FE_RN_935_0 I1=n73 B1=FE_RN_934_0
XFE_RC_1425_0 AO22 $PINS O=carry[4] A1=A[3] A2=n73 B1=FE_RN_935_0 B2=carry[3]
XFE_RC_1390_0 INV1S $PINS O=FE_RN_894_0 I=FE_RN_902_0
XFE_RC_1389_0 AOI12HS $PINS O=FE_RN_895_0 A1=FE_RN_894_0 B1=A[25] B2=n51
XFE_RC_1388_0 INV1S $PINS O=FE_RN_896_0 I=A[25]
XFE_RC_1386_0 NR2 $PINS O=FE_RN_898_0 I1=n51 I2=FE_RN_896_0
XFE_RC_1385_0 AOI12HS $PINS O=FE_RN_899_0 A1=FE_RN_898_0 B1=FE_RN_896_0 B2=n51
XFE_RC_1384_0 MXL2HS $PINS OB=DIFF[25] S=carry[25] A=FE_RN_899_0 B=FE_RN_895_0
XFE_RC_1383_0 ND2S $PINS O=FE_RN_900_0 I1=A[25] I2=n51
XFE_RC_1381_0 OR2B1S $PINS O=FE_RN_902_0 I1=n51 B1=FE_RN_896_0
XFE_RC_1380_0 ND2 $PINS O=FE_RN_903_0 I1=FE_RN_902_0 I2=carry[25]
XFE_RC_1379_0 ND2P $PINS O=carry[26] I1=FE_RN_903_0 I2=FE_RN_900_0
XFE_RC_1293_0 ND3P $PINS O=carry[14] I1=n26 I2=n25 I3=n27
XFE_RC_1292_0 ND3P $PINS O=carry[29] I1=n34 I2=n35 I3=n36
XFE_RC_1280_0 ND3 $PINS O=carry[2] I1=n43 I2=n45 I3=n44
XFE_RC_1256_0 ND3P $PINS O=carry[23] I1=n11 I2=n10 I3=n12
XFE_OFC294_V_1 INV2 $PINS O=n75 I=B[1]
XU2_18 FA1 $PINS S=DIFF[18] CO=carry[19] A=A[18] B=n58 CI=carry[18]
XU2_30 FA1 $PINS S=DIFF[30] CO=carry[31] A=A[30] B=n46 CI=carry[30]
XU2_31 XOR3 $PINS O=DIFF[31] I1=A[31] I2=B[31] I3=carry[31]
XU2_17 FA1 $PINS S=DIFF[17] CO=carry[18] A=A[17] B=n59 CI=carry[17]
XU2_9 FA1 $PINS S=DIFF[9] CO=carry[10] A=A[9] B=n67 CI=carry[9]
XU2_6 FA1 $PINS S=DIFF[6] CO=carry[7] A=A[6] B=n70 CI=carry[6]
XU2_19 FA1 $PINS S=DIFF[19] CO=carry[20] A=A[19] B=n57 CI=carry[19]
XU2_29 FA1 $PINS S=DIFF[29] CO=carry[30] A=A[29] B=n47 CI=carry[29]
XU2_5 FA1 $PINS S=DIFF[5] CO=carry[6] A=A[5] B=n71 CI=carry[5]
XU1 ND3P $PINS O=carry[16] I1=n37 I2=n38 I3=n39
XU2 XOR3 $PINS O=DIFF[24] I1=n52 I2=A[24] I3=carry[24]
XU3 ND3P $PINS O=carry[24] I1=n16 I2=n17 I3=n18
XU4 XOR3 $PINS O=DIFF[13] I1=n63 I2=A[13] I3=carry[13]
XU5 ND3P $PINS O=carry[13] I1=n19 I2=n20 I3=n21
XU7 INV1S $PINS O=n74 I=B[2]
XU8 OR2B1 $PINS O=carry[1] I1=A[0] B1=B[0]
XU11 XOR3 $PINS O=DIFF[23] I1=n53 I2=A[23] I3=carry[23]
XU12 XOR3 $PINS O=DIFF[15] I1=n61 I2=A[15] I3=carry[15]
XU13 XOR3 $PINS O=DIFF[11] I1=n65 I2=A[11] I3=carry[11]
XU14 XOR3 $PINS O=DIFF[4] I1=n72 I2=A[4] I3=carry[4]
XU15 ND2 $PINS O=n1 I1=carry[4] I2=n72
XU16 ND2 $PINS O=n2 I1=carry[4] I2=A[4]
XU17 ND2 $PINS O=n3 I1=n72 I2=A[4]
XU19 ND3P $PINS O=carry[15] I1=n31 I2=n32 I3=n33
XU20 ND2S $PINS O=n44 I1=n75 I2=A[1]
XU23 XOR3 $PINS O=DIFF[12] I1=n64 I2=A[12] I3=carry[12]
XU24 XOR3 $PINS O=DIFF[2] I1=n74 I2=A[2] I3=carry[2]
XU25 XOR3 $PINS O=DIFF[8] I1=n68 I2=A[8] I3=carry[8]
XU26 XOR3 $PINS O=DIFF[22] I1=n54 I2=A[22] I3=carry[22]
XU27 XOR3 $PINS O=DIFF[26] I1=n50 I2=A[26] I3=carry[26]
XU28 XOR3 $PINS O=DIFF[28] I1=n48 I2=p1 I3=carry[28]
XU29 XOR3 $PINS O=DIFF[16] I1=n60 I2=A[16] I3=carry[16]
XU30 XOR3 $PINS O=DIFF[14] I1=n62 I2=A[14] I3=carry[14]
XU31 ND3P $PINS O=carry[12] I1=n7 I2=n8 I3=n9
XU32 ND2 $PINS O=n6 I1=n74 I2=A[2]
XU33 ND2 $PINS O=n5 I1=carry[2] I2=A[2]
XU34 INV1S $PINS O=n54 I=B[22]
XU35 INV1S $PINS O=n64 I=B[12]
XU37 INV1S $PINS O=n65 I=B[11]
XU38 ND2 $PINS O=n4 I1=carry[2] I2=n74
XU39 ND2 $PINS O=n7 I1=carry[11] I2=n65
XU40 ND2 $PINS O=n8 I1=carry[11] I2=A[11]
XU41 ND2S $PINS O=n9 I1=n65 I2=A[11]
XU42 ND2 $PINS O=n10 I1=carry[22] I2=n54
XU43 ND2 $PINS O=n11 I1=carry[22] I2=A[22]
XU44 ND2S $PINS O=n12 I1=n54 I2=A[22]
XU46 INV1S $PINS O=n63 I=B[13]
XU47 INV1S $PINS O=n52 I=B[24]
XU48 INV1S $PINS O=n68 I=B[8]
XU50 INV1S $PINS O=n53 I=B[23]
XU51 ND2 $PINS O=n13 I1=carry[8] I2=n68
XU52 ND2 $PINS O=n14 I1=carry[8] I2=A[8]
XU53 ND2S $PINS O=n15 I1=n68 I2=A[8]
XU54 ND2 $PINS O=n16 I1=carry[23] I2=n53
XU55 ND2 $PINS O=n17 I1=carry[23] I2=A[23]
XU56 ND2S $PINS O=n18 I1=n53 I2=A[23]
XU57 ND2 $PINS O=n22 I1=carry[24] I2=n52
XU58 ND2 $PINS O=n19 I1=carry[12] I2=n64
XU59 ND2 $PINS O=n20 I1=carry[12] I2=A[12]
XU60 ND2S $PINS O=n21 I1=n64 I2=A[12]
XU61 INV1S $PINS O=n62 I=B[14]
XU63 ND2 $PINS O=n23 I1=carry[24] I2=A[24]
XU64 ND2S $PINS O=n24 I1=n52 I2=A[24]
XU65 ND2 $PINS O=n25 I1=carry[13] I2=n63
XU66 ND2 $PINS O=n26 I1=carry[13] I2=A[13]
XU67 ND2S $PINS O=n27 I1=n63 I2=A[13]
XU68 INV1S $PINS O=n61 I=B[15]
XU69 XOR3S $PINS O=DIFF[1] I1=carry[1] I2=A[1] I3=n75
XU70 INV1S $PINS O=n50 I=B[26]
XU71 ND2 $PINS O=n28 I1=carry[26] I2=n50
XU72 ND2 $PINS O=n29 I1=carry[26] I2=A[26]
XU73 ND2S $PINS O=n30 I1=n50 I2=A[26]
XU74 ND2 $PINS O=n31 I1=carry[14] I2=n62
XU75 ND2 $PINS O=n32 I1=carry[14] I2=A[14]
XU76 ND2S $PINS O=n33 I1=n62 I2=A[14]
XU77 INV1S $PINS O=n48 I=B[28]
XU78 ND2 $PINS O=n34 I1=carry[28] I2=n48
XU79 ND2 $PINS O=n35 I1=carry[28] I2=A[28]
XU80 ND2S $PINS O=n36 I1=n48 I2=A[28]
XU81 ND2 $PINS O=n45 I1=carry[1] I2=A[1]
XU82 ND2 $PINS O=n37 I1=carry[15] I2=n61
XU83 ND2 $PINS O=n38 I1=carry[15] I2=A[15]
XU84 ND2S $PINS O=n39 I1=n61 I2=A[15]
XU85 INV1S $PINS O=n60 I=B[16]
XU86 ND3P $PINS O=carry[17] I1=n40 I2=n41 I3=n42
XU87 ND2 $PINS O=n40 I1=carry[16] I2=n60
XU88 ND2 $PINS O=n41 I1=carry[16] I2=A[16]
XU89 ND2S $PINS O=n42 I1=n60 I2=A[16]
XU90 INV1S $PINS O=n46 I=B[30]
XU91 ND2 $PINS O=n43 I1=n75 I2=carry[1]
XU92 INV1S $PINS O=n72 I=B[4]
XU93 INV1S $PINS O=n70 I=B[6]
XU94 INV1S $PINS O=n56 I=B[20]
XU95 INV1S $PINS O=n66 I=B[10]
XU96 INV1S $PINS O=n58 I=B[18]
XU97 INV1S $PINS O=n73 I=B[3]
XU98 INV1S $PINS O=n71 I=B[5]
XU99 INV1S $PINS O=n69 I=B[7]
XU100 INV1S $PINS O=n67 I=B[9]
XU101 INV1S $PINS O=n59 I=B[17]
XU102 INV1S $PINS O=n57 I=B[19]
XU103 INV1S $PINS O=n55 I=B[21]
XU104 INV1S $PINS O=n51 I=B[25]
XU105 INV1S $PINS O=n49 I=B[27]
XU106 INV1S $PINS O=n47 I=B[29]
.ENDS

.SUBCKT div_DW01_inc_0 A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] SUM[9]
+ SUM[8] SUM[7] SUM[6] SUM[5] SUM[4] SUM[3] SUM[2] SUM[1] SUM[0]
XU1_1_8 HA1 $PINS S=SUM[8] C=carry[9] A=A[8] B=carry[8]
XU1_1_7 HA1 $PINS S=SUM[7] C=carry[8] A=A[7] B=carry[7]
XU1_1_6 HA1 $PINS S=SUM[6] C=carry[7] A=A[6] B=carry[6]
XU1_1_5 HA1 $PINS S=SUM[5] C=carry[6] A=A[5] B=carry[5]
XU1_1_4 HA1 $PINS S=SUM[4] C=carry[5] A=A[4] B=carry[4]
XU1_1_3 HA1 $PINS S=SUM[3] C=carry[4] A=A[3] B=carry[3]
XU1_1_2 HA1 $PINS S=SUM[2] C=carry[3] A=A[2] B=carry[2]
XU1_1_1 HA1 $PINS S=SUM[1] C=carry[2] A=A[1] B=A[0]
XU1 XOR2HS $PINS O=SUM[9] I1=carry[9] I2=A[9]
XU2 INV1S $PINS O=SUM[0] I=A[0]
.ENDS

.SUBCKT div_DW01_sub_5 A[32] A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24]
+ A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12] A[11]
+ A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[32] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] CI DIFF[32] DIFF[31] DIFF[30] DIFF[29] DIFF[28] DIFF[27]
+ DIFF[26] DIFF[25] DIFF[24] DIFF[23] DIFF[22] DIFF[21] DIFF[20] DIFF[19]
+ DIFF[18] DIFF[17] DIFF[16] DIFF[15] DIFF[14] DIFF[13] DIFF[12] DIFF[11]
+ DIFF[10] DIFF[9] DIFF[8] DIFF[7] DIFF[6] DIFF[5] DIFF[4] DIFF[3] DIFF[2]
+ DIFF[1] DIFF[0] CO p1 FE_DBTN85_S_6 FE_OCPN173_FE_OCPN339_n310
XFE_OCPC656_carry_20 BUF1S $PINS O=FE_OCPN656_carry_20 I=carry[20]
XFE_OCPC418_carry_19 BUF1S $PINS O=FE_OCPN418_carry_19 I=carry[19]
XFE_OCPC367_carry_29 BUF1S $PINS O=FE_OCPN367_carry_29 I=carry[29]
XFE_OCPC354_carry_25 BUF1S $PINS O=FE_OCPN354_carry_25 I=carry[25]
XFE_RC_2321_0 ND3P $PINS O=carry[31] I1=n50 I2=n49 I3=n48
XFE_RC_2283_0 ND3P $PINS O=carry[9] I1=n10 I2=n9 I3=n8
XFE_RC_2282_0 ND3P $PINS O=carry[16] I1=n15 I2=n16 I3=n14
XFE_RC_2072_0 XNR2HS $PINS O=FE_RN_1407_0 I1=n66 I2=A[9]
XFE_RC_2071_0 ND2 $PINS O=FE_RN_1408_0 I1=A[9] I2=n66
XFE_RC_2070_0 ND2 $PINS O=FE_RN_1409_0 I1=FE_RN_1412_0 I2=FE_RN_1408_0
XFE_RC_2069_0 ND2 $PINS O=FE_RN_1410_0 I1=carry[9] I2=FE_RN_1409_0
XFE_RC_2068_0 OAI12HS $PINS O=DIFF[9] A1=FE_RN_1410_0 B1=carry[9]
+ B2=FE_RN_1407_0
XFE_RC_2066_0 OR2 $PINS O=FE_RN_1412_0 I1=n66 I2=A[9]
XFE_RC_2065_0 ND2 $PINS O=FE_RN_1413_0 I1=FE_RN_1412_0 I2=carry[9]
XFE_RC_2064_0 ND2P $PINS O=carry[10] I1=FE_RN_1413_0 I2=FE_RN_1408_0
XFE_RC_1885_0 ND2 $PINS O=FE_RN_1268_0 I1=A[10] I2=n67
XFE_RC_1884_0 AN2 $PINS O=FE_RN_1269_0 I1=FE_RN_1272_0 I2=FE_RN_1268_0
XFE_RC_1883_0 XNR2HS $PINS O=FE_RN_1270_0 I1=n67 I2=A[10]
XFE_RC_1882_0 MXL2HS $PINS OB=DIFF[10] S=carry[10] A=FE_RN_1270_0
+ B=FE_RN_1269_0
XFE_RC_1880_0 OR2 $PINS O=FE_RN_1272_0 I1=n67 I2=A[10]
XFE_RC_1879_0 ND2 $PINS O=FE_RN_1273_0 I1=FE_RN_1272_0 I2=carry[10]
XFE_RC_1878_0 ND2P $PINS O=carry[11] I1=FE_RN_1273_0 I2=FE_RN_1268_0
XFE_RC_1658_0 ND2S $PINS O=FE_RN_1098_0 I1=A[11] I2=n68
XFE_RC_1657_0 AN2S $PINS O=FE_RN_1099_0 I1=FE_RN_1102_0 I2=FE_RN_1098_0
XFE_RC_1656_0 XNR2HS $PINS O=FE_RN_1100_0 I1=n68 I2=A[11]
XFE_RC_1655_0 MXL2HS $PINS OB=DIFF[11] S=carry[11] A=FE_RN_1100_0
+ B=FE_RN_1099_0
XFE_RC_1654_0 ND2S $PINS O=FE_RN_1101_0 I1=A[11] I2=n68
XFE_RC_1653_0 OR2S $PINS O=FE_RN_1102_0 I1=n68 I2=A[11]
XFE_RC_1652_0 ND2 $PINS O=FE_RN_1103_0 I1=FE_RN_1102_0 I2=carry[11]
XFE_RC_1651_0 ND2P $PINS O=carry[12] I1=FE_RN_1103_0 I2=FE_RN_1101_0
XFE_RC_1443_0 ND2 $PINS O=FE_RN_938_0 I1=A[12] I2=n69
XFE_RC_1442_0 AN2 $PINS O=FE_RN_939_0 I1=FE_RN_942_0 I2=FE_RN_938_0
XFE_RC_1441_0 XNR2HS $PINS O=FE_RN_940_0 I1=n69 I2=A[12]
XFE_RC_1440_0 MXL2HS $PINS OB=DIFF[12] S=carry[12] A=FE_RN_940_0 B=FE_RN_939_0
XFE_RC_1438_0 OR2S $PINS O=FE_RN_942_0 I1=n69 I2=A[12]
XFE_RC_1437_0 ND2 $PINS O=FE_RN_943_0 I1=FE_RN_942_0 I2=carry[12]
XFE_RC_1436_0 ND2P $PINS O=carry[13] I1=FE_RN_943_0 I2=FE_RN_938_0
XFE_RC_1199_0 MOAI1 $PINS O=carry[25] A1=FE_RN_590_0 A2=FE_RN_587_0 B1=n81
+ B2=A[24]
XFE_RC_1148_0 ND3P $PINS O=carry[29] I1=n37 I2=n36 I3=n35
XFE_RC_1147_0 ND2S $PINS O=FE_RN_726_0 I1=A[13] I2=n70
XFE_RC_1146_0 AN2 $PINS O=FE_RN_727_0 I1=FE_RN_730_0 I2=FE_RN_726_0
XFE_RC_1145_0 XNR2HS $PINS O=FE_RN_728_0 I1=n70 I2=A[13]
XFE_RC_1144_0 MXL2HS $PINS OB=DIFF[13] S=carry[13] A=FE_RN_728_0 B=FE_RN_727_0
XFE_RC_1143_0 ND2S $PINS O=FE_RN_729_0 I1=A[13] I2=n70
XFE_RC_1142_0 OR2S $PINS O=FE_RN_730_0 I1=n70 I2=A[13]
XFE_RC_1141_0 ND2 $PINS O=FE_RN_731_0 I1=FE_RN_730_0 I2=carry[13]
XFE_RC_1140_0 ND2P $PINS O=carry[14] I1=FE_RN_731_0 I2=FE_RN_729_0
XFE_RC_1003_0 ND3P $PINS O=carry[6] I1=n12 I2=n11 I3=n13
XFE_RC_959_0 INV1S $PINS O=FE_RN_587_0 I=FE_RN_591_0
XFE_RC_958_0 AOI12HS $PINS O=FE_RN_588_0 A1=FE_RN_587_0 B1=A[24] B2=n81
XFE_RC_957_0 XNR2HS $PINS O=FE_RN_589_0 I1=n81 I2=A[24]
XFE_RC_956_0 MXL2HS $PINS OB=DIFF[24] S=carry[24] A=FE_RN_589_0 B=FE_RN_588_0
XFE_RC_955_0 INV1S $PINS O=FE_RN_590_0 I=carry[24]
XFE_RC_954_0 OR2S $PINS O=FE_RN_591_0 I1=n81 I2=A[24]
XFE_RC_882_0 INV1S $PINS O=FE_RN_533_0 I=FE_DBTN85_S_6
XFE_RC_881_0 OR2B1S $PINS O=FE_RN_534_0 I1=FE_RN_497_0 B1=FE_RN_533_0
XFE_RC_880_0 ND2P $PINS O=carry[7] I1=FE_RN_501_0 I2=FE_RN_534_0
XFE_RC_837_0 INV1S $PINS O=FE_RN_491_0 I=FE_RN_500_0
XFE_RC_836_0 AOI12HS $PINS O=FE_RN_492_0 A1=FE_RN_491_0 B1=A[6] B2=n63
XFE_RC_833_0 NR2 $PINS O=FE_RN_495_0 I1=n63 I2=FE_DBTN85_S_6
XFE_RC_832_0 AOI12HS $PINS O=FE_RN_496_0 A1=FE_RN_495_0 B1=FE_DBTN85_S_6 B2=n63
XFE_RC_831_0 MXL2HS $PINS OB=DIFF[6] S=carry[6] A=FE_RN_496_0 B=FE_RN_492_0
XFE_RC_830_0 INV1S $PINS O=FE_RN_497_0 I=n63
XFE_RC_827_0 OR2B1S $PINS O=FE_RN_500_0 I1=n63 B1=FE_DBTN85_S_6
XFE_RC_826_0 ND2 $PINS O=FE_RN_501_0 I1=FE_RN_500_0 I2=carry[6]
XFE_RC_634_0 ND2S $PINS O=FE_RN_350_0 I1=A[14] I2=n71
XFE_RC_633_0 AN2 $PINS O=FE_RN_351_0 I1=FE_RN_354_0 I2=FE_RN_350_0
XFE_RC_632_0 XNR2HS $PINS O=FE_RN_352_0 I1=n71 I2=A[14]
XFE_RC_631_0 MXL2HS $PINS OB=DIFF[14] S=carry[14] A=FE_RN_352_0 B=FE_RN_351_0
XFE_RC_629_0 OR2S $PINS O=FE_RN_354_0 I1=n71 I2=A[14]
XFE_RC_628_0 ND2 $PINS O=FE_RN_355_0 I1=FE_RN_354_0 I2=carry[14]
XFE_RC_627_0 ND2P $PINS O=carry[15] I1=FE_RN_355_0 I2=FE_RN_350_0
XFE_RC_385_0 ND3P $PINS O=carry[28] I1=n34 I2=n33 I3=n32
XFE_RC_384_0 ND2S $PINS O=FE_RN_176_0 I1=A[25] I2=n82
XFE_RC_383_0 AN2 $PINS O=FE_RN_177_0 I1=FE_RN_180_0 I2=FE_RN_176_0
XFE_RC_382_0 XNR2HS $PINS O=FE_RN_178_0 I1=n82 I2=A[25]
XFE_RC_381_0 MXL2HS $PINS OB=DIFF[25] S=FE_OCPN354_carry_25 A=FE_RN_178_0
+ B=FE_RN_177_0
XFE_RC_380_0 ND2S $PINS O=FE_RN_179_0 I1=A[25] I2=n82
XFE_RC_379_0 OR2S $PINS O=FE_RN_180_0 I1=n82 I2=A[25]
XFE_RC_378_0 ND2 $PINS O=FE_RN_181_0 I1=FE_RN_180_0 I2=carry[25]
XFE_RC_377_0 ND2P $PINS O=carry[26] I1=FE_RN_181_0 I2=FE_RN_179_0
XFE_RC_329_0 ND3P $PINS O=carry[17] I1=n20 I2=n19 I3=n18
XFE_RC_328_0 ND3P $PINS O=carry[21] I1=n27 I2=n26 I3=n25
XFE_RC_174_0 ND3P $PINS O=carry[8] I1=n5 I2=n6 I3=n4
XFE_RC_170_0 XNR2HS $PINS O=FE_RN_53_0 I1=n74 I2=A[17]
XFE_RC_169_0 ND2S $PINS O=FE_RN_54_0 I1=A[17] I2=n74
XFE_RC_168_0 ND2S $PINS O=FE_RN_55_0 I1=FE_RN_58_0 I2=FE_RN_54_0
XFE_RC_167_0 ND2 $PINS O=FE_RN_56_0 I1=carry[17] I2=FE_RN_55_0
XFE_RC_166_0 OAI12HS $PINS O=DIFF[17] A1=FE_RN_56_0 B1=carry[17] B2=FE_RN_53_0
XFE_RC_164_0 OR2S $PINS O=FE_RN_58_0 I1=n74 I2=A[17]
XFE_RC_163_0 ND2 $PINS O=FE_RN_59_0 I1=FE_RN_58_0 I2=carry[17]
XFE_RC_162_0 ND2P $PINS O=carry[18] I1=FE_RN_59_0 I2=FE_RN_54_0
XFE_RC_60_0 ND3P $PINS O=carry[20] I1=n23 I2=n22 I3=n21
XFE_OFC287_raw_prime_3 INV1S $PINS O=n60 I=B[3]
XFE_OFC214_raw_prime_5 INV1S $PINS O=n62 I=B[5]
XFE_OFC200_raw_prime_9 INV1S $PINS O=n66 I=B[9]
XFE_OFC176_raw_prime_10 INV1S $PINS O=n67 I=B[10]
XFE_OFC163_raw_prime_7 INV1S $PINS O=n64 I=B[7]
XFE_OFC154_raw_prime_6 INV1S $PINS O=n63 I=B[6]
XFE_OFC123_raw_prime_8 INV1S $PINS O=n65 I=B[8]
XFE_OFC107_n312 INV1S $PINS O=n58 I=B[1]
XFE_OFC91_raw_prime_4 INV1S $PINS O=n61 I=B[4]
XU2_23 FA1 $PINS S=DIFF[23] CO=carry[24] A=A[23] B=n80 CI=carry[23]
XU2_22 FA1 $PINS S=DIFF[22] CO=carry[23] A=A[22] B=n79 CI=carry[22]
XU2_21 FA1 $PINS S=DIFF[21] CO=carry[22] A=A[21] B=n78 CI=carry[21]
XU2_4 FA1 $PINS S=DIFF[4] CO=carry[5] A=A[4] B=n61 CI=carry[4]
XU2_2 FA1 $PINS S=DIFF[2] CO=carry[3] A=A[2] B=B[2] CI=carry[2]
XU1 INV1S $PINS O=n57 I=FE_OCPN173_FE_OCPN339_n310
XU3 XOR3 $PINS O=DIFF[3] I1=n60 I2=A[3] I3=carry[3]
XU4 XOR3 $PINS O=DIFF[5] I1=n62 I2=A[5] I3=carry[5]
XU5 XOR3 $PINS O=DIFF[18] I1=n75 I2=A[18] I3=carry[18]
XU6 XOR3 $PINS O=DIFF[15] I1=A[15] I2=n72 I3=carry[15]
XU7 XOR3 $PINS O=DIFF[26] I1=A[26] I2=n83 I3=carry[26]
XU9 XOR3 $PINS O=DIFF[7] I1=A[7] I2=n64 I3=carry[7]
XU12 ND3P $PINS O=carry[2] I1=n42 I2=n43 I3=n44
XU13 ND3P $PINS O=carry[4] I1=n45 I2=n46 I3=n47
XU15 XOR3 $PINS O=DIFF[28] I1=A[28] I2=n85 I3=carry[28]
XU16 XOR3 $PINS O=DIFF[19] I1=A[19] I2=n76 I3=FE_OCPN418_carry_19
XU17 XOR3 $PINS O=DIFF[30] I1=A[30] I2=n87 I3=carry[30]
XU18 ND3 $PINS O=carry[32] I1=n52 I2=n53 I3=n54
XU19 ND3P $PINS O=carry[19] I1=n1 I2=n2 I3=n3
XU20 ND2 $PINS O=n43 I1=carry[1] I2=A[1]
XU21 ND2 $PINS O=n4 I1=A[7] I2=n64
XU23 ND2 $PINS O=n35 I1=A[28] I2=n85
XU25 ND2 $PINS O=n14 I1=A[15] I2=n72
XU26 ND2 $PINS O=n28 I1=A[26] I2=n83
XU28 ND2 $PINS O=n1 I1=carry[18] I2=n75
XU29 ND2 $PINS O=n2 I1=carry[18] I2=A[18]
XU30 ND2 $PINS O=n3 I1=n75 I2=A[18]
XU31 ND2 $PINS O=n5 I1=A[7] I2=carry[7]
XU32 ND2 $PINS O=n6 I1=n64 I2=carry[7]
XU34 XOR2HS $PINS O=n7 I1=A[8] I2=n65
XU35 XOR2HS $PINS O=DIFF[8] I1=n7 I2=carry[8]
XU36 ND2S $PINS O=n8 I1=A[8] I2=n65
XU37 ND2 $PINS O=n9 I1=A[8] I2=carry[8]
XU38 ND2 $PINS O=n10 I1=n65 I2=carry[8]
XU39 ND2 $PINS O=n11 I1=carry[5] I2=n62
XU40 ND2 $PINS O=n12 I1=carry[5] I2=A[5]
XU41 ND2 $PINS O=n13 I1=n62 I2=A[5]
XU42 ND2 $PINS O=n15 I1=A[15] I2=carry[15]
XU43 ND2 $PINS O=n16 I1=n72 I2=carry[15]
XU45 XOR2HS $PINS O=n17 I1=A[16] I2=n73
XU46 XOR2HS $PINS O=DIFF[16] I1=n17 I2=carry[16]
XU47 ND2S $PINS O=n18 I1=A[16] I2=n73
XU48 ND2 $PINS O=n19 I1=A[16] I2=carry[16]
XU49 ND2 $PINS O=n20 I1=n73 I2=carry[16]
XU50 ND2 $PINS O=n21 I1=A[19] I2=n76
XU51 ND2 $PINS O=n22 I1=A[19] I2=carry[19]
XU52 ND2 $PINS O=n23 I1=n76 I2=carry[19]
XU54 XOR2HS $PINS O=n24 I1=A[20] I2=n77
XU55 XOR2HS $PINS O=DIFF[20] I1=n24 I2=FE_OCPN656_carry_20
XU56 ND2S $PINS O=n25 I1=A[20] I2=n77
XU57 ND2 $PINS O=n26 I1=A[20] I2=carry[20]
XU58 ND2 $PINS O=n27 I1=n77 I2=carry[20]
XU60 ND2 $PINS O=n29 I1=A[26] I2=carry[26]
XU61 ND2 $PINS O=n30 I1=n83 I2=carry[26]
XU62 ND3P $PINS O=carry[27] I1=n30 I2=n29 I3=n28
XU63 XOR2HS $PINS O=n31 I1=A[27] I2=n84
XU64 XOR2HS $PINS O=DIFF[27] I1=n31 I2=carry[27]
XU65 ND2S $PINS O=n32 I1=A[27] I2=n84
XU66 ND2 $PINS O=n33 I1=A[27] I2=carry[27]
XU67 ND2 $PINS O=n34 I1=n84 I2=carry[27]
XU69 ND2 $PINS O=n36 I1=A[28] I2=carry[28]
XU70 ND2 $PINS O=n37 I1=n85 I2=carry[28]
XU72 XOR2HS $PINS O=n38 I1=A[29] I2=n86
XU73 XOR2HS $PINS O=DIFF[29] I1=n38 I2=FE_OCPN367_carry_29
XU74 ND2S $PINS O=n39 I1=A[29] I2=n86
XU75 ND2 $PINS O=n40 I1=A[29] I2=carry[29]
XU76 ND2 $PINS O=n41 I1=n86 I2=carry[29]
XU77 ND3P $PINS O=carry[30] I1=n41 I2=n40 I3=n39
XU78 XNR2HS $PINS O=DIFF[32] I1=A[32] I2=carry[32]
XU80 ND2 $PINS O=n44 I1=n58 I2=A[1]
XU81 XOR3S $PINS O=DIFF[1] I1=n58 I2=A[1] I3=carry[1]
XU82 ND2 $PINS O=n42 I1=carry[1] I2=n58
XU83 ND2 $PINS O=carry[1] I1=B[0] I2=p1
XU84 ND2 $PINS O=n48 I1=A[30] I2=n87
XU85 ND2 $PINS O=n47 I1=n60 I2=A[3]
XU86 ND2 $PINS O=n45 I1=carry[3] I2=n60
XU87 ND2 $PINS O=n46 I1=carry[3] I2=A[3]
XU88 ND2 $PINS O=n49 I1=A[30] I2=carry[30]
XU89 ND2 $PINS O=n50 I1=carry[30] I2=n87
XU91 XOR2HS $PINS O=n51 I1=A[31] I2=n88
XU92 XOR2HS $PINS O=DIFF[31] I1=n51 I2=carry[31]
XU93 ND2S $PINS O=n52 I1=A[31] I2=n88
XU94 ND2 $PINS O=n53 I1=A[31] I2=carry[31]
XU95 ND2 $PINS O=n54 I1=n88 I2=carry[31]
XU96 INV1S $PINS O=n86 I=B[29]
XU97 INV1S $PINS O=n78 I=B[21]
XU98 INV1S $PINS O=n70 I=B[13]
XU99 INV1S $PINS O=n74 I=B[17]
XU100 INV1S $PINS O=n80 I=B[23]
XU101 INV1S $PINS O=n76 I=B[19]
XU102 INV1S $PINS O=n72 I=B[15]
XU103 INV1S $PINS O=n84 I=B[27]
XU104 INV1S $PINS O=n82 I=B[25]
XU105 INV1S $PINS O=n68 I=B[11]
XU108 INV1S $PINS O=n85 I=B[28]
XU109 INV1S $PINS O=n83 I=B[26]
XU110 INV1S $PINS O=n81 I=B[24]
XU111 INV1S $PINS O=n79 I=B[22]
XU112 INV1S $PINS O=n77 I=B[20]
XU113 INV1S $PINS O=n75 I=B[18]
XU114 INV1S $PINS O=n73 I=B[16]
XU115 INV1S $PINS O=n71 I=B[14]
XU116 INV1S $PINS O=n69 I=B[12]
XU120 INV1S $PINS O=n87 I=B[30]
XU121 INV1S $PINS O=n88 I=B[31]
XU123 XNR2HS $PINS O=DIFF[0] I1=n57 I2=A[0]
.ENDS

.SUBCKT div_DW_cmp_1 A[32] A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24]
+ A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12] A[11]
+ A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[32] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] TC GE_LT GE_GT_EQ GE_LT_GT_LE EQ_NE
XFE_RC_2410_0 AO12 $PINS O=n282 A1=n292 B1=n291 B2=n293
XU159 INV1S $PINS O=n235 I=B[11]
XU160 INV1S $PINS O=n259 I=n323
XU161 INV1S $PINS O=n237 I=B[14]
XU162 INV1S $PINS O=n248 I=B[30]
XU163 INV1S $PINS O=n243 I=B[22]
XU164 INV1S $PINS O=n230 I=B[2]
XU165 INV1S $PINS O=n240 I=B[18]
XU166 INV1S $PINS O=n254 I=n340
XU167 INV1S $PINS O=n247 I=B[29]
XU168 INV1S $PINS O=n242 I=B[21]
XU169 INV1S $PINS O=n236 I=B[13]
XU170 INV1S $PINS O=n239 I=B[17]
XU171 INV1S $PINS O=n234 I=B[9]
XU172 INV1S $PINS O=n245 I=B[25]
XU173 INV1S $PINS O=n233 I=B[7]
XU174 INV1S $PINS O=n232 I=B[5]
XU175 INV1S $PINS O=n246 I=B[27]
XU176 INV1S $PINS O=n238 I=B[15]
XU177 INV1S $PINS O=n244 I=B[23]
XU178 INV1S $PINS O=n231 I=B[3]
XU179 INV1S $PINS O=n241 I=B[19]
XU180 INV1S $PINS O=n249 I=B[31]
XU181 INV1S $PINS O=n256 I=n321
XU182 INV1S $PINS O=n267 I=n312
XU183 INV1S $PINS O=n261 I=n330
XU184 INV1S $PINS O=n265 I=n301
XU185 INV1S $PINS O=n250 I=n288
XU202 OR2 $PINS O=GE_LT_GT_LE I1=A[32] I2=n273
XU203 AOI13HS $PINS O=n273 A1=n277 B1=n274 B2=n275 B3=n276
XU204 AOI22S $PINS O=n277 A1=n278 A2=n279 B1=n279 B2=n280
XU205 AOI22S $PINS O=n279 A1=n281 A2=n282 B1=n283 B2=n284
XU206 OAI112HS $PINS O=n284 A1=n285 B1=n286 C1=A[29] C2=n247
XU207 ND3 $PINS O=n285 I1=n287 I2=A[28] I3=B[28]
XU208 ND2 $PINS O=n283 I1=n286 I2=n288
XU209 OA22 $PINS O=n286 A1=A[31] A2=n249 B1=n248 B2=n289
XU210 ND2 $PINS O=n289 I1=n290 I2=A[30]
XU212 MOAI1S $PINS O=n293 A1=A[25] A2=n245 B1=B[24] B2=n294
XU213 AN2 $PINS O=n294 I1=n295 I2=A[24]
XU214 MOAI1S $PINS O=n292 A1=A[27] A2=n246 B1=B[26] B2=n296
XU215 AN2 $PINS O=n296 I1=n297 I2=A[26]
XU216 AOI22S $PINS O=n278 A1=n298 A2=n299 B1=n300 B2=n265
XU217 AOI22S $PINS O=n300 A1=n302 A2=n303 B1=n303 B2=n304
XU218 OA22 $PINS O=n303 A1=A[19] A2=n241 B1=n240 B2=n305
XU219 ND2 $PINS O=n305 I1=n306 I2=A[18]
XU220 AOI13HS $PINS O=n302 A1=n308 B1=n307 B2=A[16] B3=B[16]
XU221 NR2 $PINS O=n308 I1=A[17] I2=n239
XU222 OAI112HS $PINS O=n299 A1=n309 B1=n310 C1=A[21] C2=n242
XU223 ND3 $PINS O=n309 I1=n311 I2=A[20] I3=B[20]
XU224 ND2 $PINS O=n298 I1=n310 I2=n312
XU225 OA22 $PINS O=n310 A1=A[23] A2=n244 B1=n243 B2=n313
XU226 ND2 $PINS O=n313 I1=n314 I2=A[22]
XU227 NR3 $PINS O=n276 I1=n304 I2=n301 I3=n280
XU228 ND3 $PINS O=n280 I1=n291 I2=n281 I3=n315
XU229 OA12 $PINS O=n315 A1=n295 B1=B[24] B2=A[24]
XU230 ND2 $PINS O=n295 I1=A[25] I2=n245
XU231 OA112 $PINS O=n281 A1=n287 B1=n250 C1=B[28] C2=A[28]
XU232 OAI12HS $PINS O=n288 A1=n290 B1=B[30] B2=A[30]
XU233 ND2 $PINS O=n290 I1=A[31] I2=n249
XU234 ND2 $PINS O=n287 I1=A[29] I2=n247
XU235 OA12 $PINS O=n291 A1=n297 B1=B[26] B2=A[26]
XU236 ND2 $PINS O=n297 I1=A[27] I2=n246
XU237 OAI112HS $PINS O=n301 A1=n311 B1=n267 C1=B[20] C2=A[20]
XU238 OAI12HS $PINS O=n312 A1=n314 B1=B[22] B2=A[22]
XU239 ND2 $PINS O=n314 I1=A[23] I2=n244
XU240 ND2 $PINS O=n311 I1=A[21] I2=n242
XU241 OAI12HS $PINS O=n304 A1=n306 B1=B[18] B2=A[18]
XU242 ND2 $PINS O=n306 I1=A[19] I2=n241
XU243 OA12 $PINS O=n275 A1=n307 B1=B[16] B2=A[16]
XU244 ND2 $PINS O=n307 I1=A[17] I2=n239
XU245 AOI13HS $PINS O=n274 A1=n318 B1=n316 B2=n317 B3=n256
XU246 AOI13HS $PINS O=n318 A1=n321 B1=n319 B2=n259 B3=n320
XU247 OA12 $PINS O=n320 A1=n322 B1=B[8] B2=A[8]
XU248 MOAI1S $PINS O=n321 A1=n323 A2=n324 B1=n325 B2=n326
XU249 OAI112HS $PINS O=n326 A1=n327 B1=n328 C1=A[13] C2=n236
XU250 ND3 $PINS O=n327 I1=n329 I2=A[12] I3=B[12]
XU251 ND2 $PINS O=n325 I1=n328 I2=n330
XU252 OA22 $PINS O=n328 A1=A[15] A2=n238 B1=n237 B2=n331
XU253 ND2 $PINS O=n331 I1=n332 I2=A[14]
XU254 OAI22S $PINS O=n324 A1=n319 A2=n333 B1=n333 B2=n334
XU255 MOAI1S $PINS O=n334 A1=A[9] A2=n234 B1=B[8] B2=n335
XU256 AN2 $PINS O=n335 I1=n322 I2=A[8]
XU257 ND2 $PINS O=n322 I1=A[9] I2=n234
XU258 MOAI1S $PINS O=n333 A1=A[11] A2=n235 B1=B[10] B2=n336
XU259 AN2 $PINS O=n336 I1=n337 I2=A[10]
XU260 OA12 $PINS O=n319 A1=n337 B1=B[10] B2=A[10]
XU261 ND2 $PINS O=n337 I1=A[11] I2=n235
XU262 OAI112HS $PINS O=n323 A1=n329 B1=n261 C1=B[12] C2=A[12]
XU263 OAI12HS $PINS O=n330 A1=n332 B1=B[14] B2=A[14]
XU264 ND2 $PINS O=n332 I1=A[15] I2=n238
XU265 ND2 $PINS O=n329 I1=A[13] I2=n236
XU266 OAI22S $PINS O=n317 A1=n338 A2=n339 B1=n340 B2=n338
XU267 MOAI1S $PINS O=n339 A1=A[5] A2=n232 B1=B[4] B2=n341
XU268 AN2 $PINS O=n341 I1=n342 I2=A[4]
XU269 MOAI1S $PINS O=n338 A1=A[7] A2=n233 B1=B[6] B2=n343
XU270 AN2 $PINS O=n343 I1=n344 I2=A[6]
XU271 AO112 $PINS O=n316 A1=n254 B1=n347 C1=n345 C2=n346
XU272 OAI112HS $PINS O=n347 A1=n342 B1=n348 C1=B[4] C2=A[4]
XU273 ND2 $PINS O=n348 I1=n349 I2=n345
XU274 AOI22S $PINS O=n349 A1=B[1] A2=A[1] B1=n350 B2=B[0]
XU275 NR2 $PINS O=n350 I1=A[0] I2=n351
XU276 NR2 $PINS O=n351 I1=B[1] I2=A[1]
XU277 ND2 $PINS O=n342 I1=A[5] I2=n232
XU278 OA12 $PINS O=n340 A1=n344 B1=B[6] B2=A[6]
XU279 ND2 $PINS O=n344 I1=A[7] I2=n233
XU280 OAI12HS $PINS O=n346 A1=n352 B1=B[2] B2=A[2]
XU281 OA22 $PINS O=n345 A1=A[3] A2=n231 B1=n230 B2=n353
XU282 ND2 $PINS O=n353 I1=n352 I2=A[2]
XU283 ND2 $PINS O=n352 I1=A[3] I2=n231
.ENDS

.SUBCKT div_DW_cmp_2 A[32] A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24]
+ A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12] A[11]
+ A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[32] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] TC GE_LT GE_GT_EQ GE_LT_GT_LE EQ_NE
+ FE_OCPN351_FE_OCPN344_FE_OFN86_n312
XFE_RC_2411_0 AO12 $PINS O=n282 A1=n292 B1=n291 B2=n293
XU159 INV1S $PINS O=n235 I=B[11]
XU160 INV1S $PINS O=n234 I=B[9]
XU161 INV1S $PINS O=n258 I=n323
XU162 INV1S $PINS O=n237 I=B[14]
XU163 INV1S $PINS O=n248 I=B[30]
XU164 INV1S $PINS O=n243 I=B[22]
XU165 INV1S $PINS O=n230 I=B[2]
XU166 INV1S $PINS O=n240 I=B[18]
XU167 INV1S $PINS O=n253 I=n340
XU168 INV1S $PINS O=n247 I=B[29]
XU169 INV1S $PINS O=n242 I=B[21]
XU170 INV1S $PINS O=n236 I=B[13]
XU171 INV1S $PINS O=n239 I=B[17]
XU172 INV1S $PINS O=n245 I=B[25]
XU173 INV1S $PINS O=n233 I=B[7]
XU174 INV1S $PINS O=n232 I=B[5]
XU175 INV1S $PINS O=n246 I=B[27]
XU176 INV1S $PINS O=n238 I=B[15]
XU177 INV1S $PINS O=n244 I=B[23]
XU178 INV1S $PINS O=n231 I=B[3]
XU179 INV1S $PINS O=n241 I=B[19]
XU180 INV1S $PINS O=n249 I=B[31]
XU181 INV1S $PINS O=n255 I=n321
XU182 INV1S $PINS O=n266 I=n312
XU183 INV1S $PINS O=n260 I=n330
XU184 INV1S $PINS O=n264 I=n301
XU185 INV1S $PINS O=n271 I=n288
XU186 INV1S $PINS O=n259 I=A[12]
XU187 INV1S $PINS O=n265 I=A[20]
XU188 INV1S $PINS O=n261 I=A[14]
XU189 INV1S $PINS O=n272 I=A[30]
XU190 INV1S $PINS O=n263 I=A[18]
XU191 INV1S $PINS O=n267 I=A[22]
XU192 INV1S $PINS O=n251 I=A[2]
XU193 INV1S $PINS O=n250 I=A[1]
XU194 INV1S $PINS O=n270 I=A[28]
XU195 INV1S $PINS O=n252 I=A[4]
XU196 INV1S $PINS O=n257 I=A[10]
XU197 INV1S $PINS O=n256 I=A[8]
XU198 INV1S $PINS O=n269 I=A[26]
XU199 INV1S $PINS O=n268 I=A[24]
XU200 INV1S $PINS O=n254 I=A[6]
XU201 INV1S $PINS O=n262 I=A[16]
XU202 OR2 $PINS O=GE_LT_GT_LE I1=A[32] I2=n273
XU203 AOI13HS $PINS O=n273 A1=n277 B1=n274 B2=n275 B3=n276
XU204 AOI22S $PINS O=n277 A1=n278 A2=n279 B1=n279 B2=n280
XU205 AOI22S $PINS O=n279 A1=n281 A2=n282 B1=n283 B2=n284
XU206 OAI112HS $PINS O=n284 A1=n285 B1=n286 C1=A[29] C2=n247
XU207 ND3 $PINS O=n285 I1=n287 I2=n270 I3=B[28]
XU208 ND2 $PINS O=n283 I1=n286 I2=n288
XU209 OA22 $PINS O=n286 A1=A[31] A2=n249 B1=n248 B2=n289
XU210 ND2 $PINS O=n289 I1=n290 I2=n272
XU212 MOAI1S $PINS O=n293 A1=A[25] A2=n245 B1=B[24] B2=n294
XU213 AN2 $PINS O=n294 I1=n295 I2=n268
XU214 MOAI1S $PINS O=n292 A1=A[27] A2=n246 B1=B[26] B2=n296
XU215 AN2 $PINS O=n296 I1=n297 I2=n269
XU216 AOI22S $PINS O=n278 A1=n298 A2=n299 B1=n300 B2=n264
XU217 AOI22S $PINS O=n300 A1=n302 A2=n303 B1=n303 B2=n304
XU218 OA22 $PINS O=n303 A1=A[19] A2=n241 B1=n240 B2=n305
XU219 ND2 $PINS O=n305 I1=n306 I2=n263
XU220 AOI13HS $PINS O=n302 A1=n308 B1=n307 B2=n262 B3=B[16]
XU221 NR2 $PINS O=n308 I1=A[17] I2=n239
XU222 OAI112HS $PINS O=n299 A1=n309 B1=n310 C1=A[21] C2=n242
XU223 ND3 $PINS O=n309 I1=n311 I2=n265 I3=B[20]
XU224 ND2 $PINS O=n298 I1=n310 I2=n312
XU225 OA22 $PINS O=n310 A1=A[23] A2=n244 B1=n243 B2=n313
XU226 ND2 $PINS O=n313 I1=n314 I2=n267
XU227 NR3 $PINS O=n276 I1=n304 I2=n301 I3=n280
XU228 ND3 $PINS O=n280 I1=n291 I2=n281 I3=n315
XU229 OA12 $PINS O=n315 A1=n295 B1=B[24] B2=n268
XU230 ND2 $PINS O=n295 I1=A[25] I2=n245
XU231 OA112 $PINS O=n281 A1=n287 B1=n271 C1=B[28] C2=n270
XU232 OAI12HS $PINS O=n288 A1=n290 B1=B[30] B2=n272
XU233 ND2 $PINS O=n290 I1=A[31] I2=n249
XU234 ND2 $PINS O=n287 I1=A[29] I2=n247
XU235 OA12 $PINS O=n291 A1=n297 B1=B[26] B2=n269
XU236 ND2 $PINS O=n297 I1=A[27] I2=n246
XU237 OAI112HS $PINS O=n301 A1=n311 B1=n266 C1=B[20] C2=n265
XU238 OAI12HS $PINS O=n312 A1=n314 B1=B[22] B2=n267
XU239 ND2 $PINS O=n314 I1=A[23] I2=n244
XU240 ND2 $PINS O=n311 I1=A[21] I2=n242
XU241 OAI12HS $PINS O=n304 A1=n306 B1=B[18] B2=n263
XU242 ND2 $PINS O=n306 I1=A[19] I2=n241
XU243 OA12 $PINS O=n275 A1=n307 B1=B[16] B2=n262
XU244 ND2 $PINS O=n307 I1=A[17] I2=n239
XU245 AOI13HS $PINS O=n274 A1=n318 B1=n316 B2=n317 B3=n255
XU246 AOI13HS $PINS O=n318 A1=n321 B1=n319 B2=n258 B3=n320
XU247 OA12 $PINS O=n320 A1=n322 B1=B[8] B2=n256
XU248 MOAI1S $PINS O=n321 A1=n323 A2=n324 B1=n325 B2=n326
XU249 OAI112HS $PINS O=n326 A1=n327 B1=n328 C1=A[13] C2=n236
XU250 ND3 $PINS O=n327 I1=n329 I2=n259 I3=B[12]
XU251 ND2 $PINS O=n325 I1=n328 I2=n330
XU252 OA22 $PINS O=n328 A1=A[15] A2=n238 B1=n237 B2=n331
XU253 ND2 $PINS O=n331 I1=n332 I2=n261
XU254 OAI22S $PINS O=n324 A1=n319 A2=n333 B1=n333 B2=n334
XU255 MOAI1S $PINS O=n334 A1=A[9] A2=n234 B1=B[8] B2=n335
XU256 AN2 $PINS O=n335 I1=n322 I2=n256
XU257 ND2 $PINS O=n322 I1=A[9] I2=n234
XU258 MOAI1S $PINS O=n333 A1=A[11] A2=n235 B1=B[10] B2=n336
XU259 AN2 $PINS O=n336 I1=n337 I2=n257
XU260 OA12 $PINS O=n319 A1=n337 B1=B[10] B2=n257
XU261 ND2 $PINS O=n337 I1=A[11] I2=n235
XU262 OAI112HS $PINS O=n323 A1=n329 B1=n260 C1=B[12] C2=n259
XU263 OAI12HS $PINS O=n330 A1=n332 B1=B[14] B2=n261
XU264 ND2 $PINS O=n332 I1=A[15] I2=n238
XU265 ND2 $PINS O=n329 I1=A[13] I2=n236
XU266 OAI22S $PINS O=n317 A1=n338 A2=n339 B1=n340 B2=n338
XU267 MOAI1S $PINS O=n339 A1=A[5] A2=n232 B1=B[4] B2=n341
XU268 AN2 $PINS O=n341 I1=n342 I2=n252
XU269 MOAI1S $PINS O=n338 A1=A[7] A2=n233 B1=B[6] B2=n343
XU270 AN2 $PINS O=n343 I1=n344 I2=n254
XU271 AO112 $PINS O=n316 A1=n253 B1=n347 C1=n345 C2=n346
XU272 OAI112HS $PINS O=n347 A1=n342 B1=n348 C1=B[4] C2=n252
XU273 ND2 $PINS O=n348 I1=n349 I2=n345
XU274 AOI22S $PINS O=n349 A1=FE_OCPN351_FE_OCPN344_FE_OFN86_n312 A2=n250
+ B1=n350 B2=B[0]
XU275 NR2 $PINS O=n350 I1=A[0] I2=n351
XU276 NR2 $PINS O=n351 I1=B[1] I2=n250
XU277 ND2 $PINS O=n342 I1=A[5] I2=n232
XU278 OA12 $PINS O=n340 A1=n344 B1=B[6] B2=n254
XU279 ND2 $PINS O=n344 I1=A[7] I2=n233
XU280 OAI12HS $PINS O=n346 A1=n352 B1=B[2] B2=n251
XU281 OA22 $PINS O=n345 A1=A[3] A2=n231 B1=n230 B2=n353
XU282 ND2 $PINS O=n353 I1=n352 I2=n251
XU283 ND2 $PINS O=n352 I1=A[3] I2=n231
.ENDS

.SUBCKT div_DW01_add_1 A[32] A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24]
+ A[23] A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12] A[11]
+ A[10] A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[32] B[31] B[30]
+ B[29] B[28] B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17]
+ B[16] B[15] B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3]
+ B[2] B[1] B[0] CI SUM[32] SUM[31] SUM[30] SUM[29] SUM[28] SUM[27] SUM[26]
+ SUM[25] SUM[24] SUM[23] SUM[22] SUM[21] SUM[20] SUM[19] SUM[18] SUM[17]
+ SUM[16] SUM[15] SUM[14] SUM[13] SUM[12] SUM[11] SUM[10] SUM[9] SUM[8] SUM[7]
+ SUM[6] SUM[5] SUM[4] SUM[3] SUM[2] SUM[1] SUM[0] CO FE_DBTN84_S_8
XFE_RC_2412_0 XOR2HS $PINS O=SUM[4] I1=FE_RN_522_0 I2=carry[4]
XFE_OCPC436_carry_27 BUF1S $PINS O=FE_OCPN436_carry_27 I=carry[27]
XFE_OCPC364_carry_25 BUF1S $PINS O=FE_OCPN364_carry_25 I=carry[25]
XFE_RC_2304_0 INV1S $PINS O=FE_RN_1560_0 I=FE_RN_1564_0
XFE_RC_2303_0 AOI12HS $PINS O=FE_RN_1561_0 A1=FE_RN_1560_0 B1=B[2] B2=A[2]
XFE_RC_2302_0 XNR2HS $PINS O=FE_RN_1562_0 I1=A[2] I2=B[2]
XFE_RC_2301_0 MXL2HS $PINS OB=SUM[2] S=carry[2] A=FE_RN_1562_0 B=FE_RN_1561_0
XFE_RC_2300_0 ND2 $PINS O=FE_RN_1563_0 I1=B[2] I2=A[2]
XFE_RC_2299_0 OR2 $PINS O=FE_RN_1564_0 I1=A[2] I2=B[2]
XFE_RC_2298_0 ND2 $PINS O=FE_RN_1565_0 I1=FE_RN_1564_0 I2=carry[2]
XFE_RC_2297_0 ND2 $PINS O=carry[3] I1=FE_RN_1565_0 I2=FE_RN_1563_0
XFE_RC_2296_0 ND3P $PINS O=carry[19] I1=n19 I2=n18 I3=n20
XFE_RC_2264_0 XOR2HS $PINS O=SUM[32] I1=n1 I2=carry[32]
XFE_OCPC227_carry_28 BUF1S $PINS O=FE_OCPN227_carry_28 I=carry[28]
XFE_RC_2119_0 AN2B1S $PINS O=FE_RN_1444_0 I1=A[8] B1=FE_DBTN84_S_8
XFE_RC_2118_0 AN2B1S $PINS O=FE_RN_1445_0 I1=FE_RN_1449_0 B1=FE_RN_1444_0
XFE_RC_2117_0 XNR2HS $PINS O=FE_RN_1446_0 I1=A[8] I2=B[8]
XFE_RC_2116_0 MXL2HS $PINS OB=SUM[8] S=carry[8] A=FE_RN_1446_0 B=FE_RN_1445_0
XFE_RC_2115_0 ND2 $PINS O=FE_RN_1447_0 I1=B[8] I2=A[8]
XFE_RC_2113_0 OR2B1S $PINS O=FE_RN_1449_0 I1=A[8] B1=FE_DBTN84_S_8
XFE_RC_2112_0 ND2 $PINS O=FE_RN_1450_0 I1=FE_RN_1449_0 I2=carry[8]
XFE_RC_2111_0 ND2 $PINS O=carry[9] I1=FE_RN_1450_0 I2=FE_RN_1447_0
XFE_RC_1901_0 INV1S $PINS O=FE_RN_1280_0 I=FE_RN_1284_0
XFE_RC_1900_0 AOI12HS $PINS O=FE_RN_1281_0 A1=FE_RN_1280_0 B1=B[11] B2=A[11]
XFE_RC_1899_0 XNR2HS $PINS O=FE_RN_1282_0 I1=A[11] I2=B[11]
XFE_RC_1898_0 MXL2HS $PINS OB=SUM[11] S=carry[11] A=FE_RN_1282_0 B=FE_RN_1281_0
XFE_RC_1897_0 INV1S $PINS O=FE_RN_1283_0 I=carry[11]
XFE_RC_1896_0 OR2S $PINS O=FE_RN_1284_0 I1=A[11] I2=B[11]
XFE_RC_1894_0 MOAI1 $PINS O=carry[12] A1=FE_RN_1280_0 A2=FE_RN_1283_0 B1=B[11]
+ B2=A[11]
XFE_RC_1707_0 ND2S $PINS O=FE_RN_1133_0 I1=B[12] I2=A[12]
XFE_RC_1706_0 AN2 $PINS O=FE_RN_1134_0 I1=FE_RN_1137_0 I2=FE_RN_1133_0
XFE_RC_1705_0 XNR2HS $PINS O=FE_RN_1135_0 I1=A[12] I2=B[12]
XFE_RC_1704_0 MXL2HS $PINS OB=SUM[12] S=carry[12] A=FE_RN_1135_0 B=FE_RN_1134_0
XFE_RC_1703_0 ND2S $PINS O=FE_RN_1136_0 I1=B[12] I2=A[12]
XFE_RC_1702_0 OR2S $PINS O=FE_RN_1137_0 I1=A[12] I2=B[12]
XFE_RC_1701_0 ND2 $PINS O=FE_RN_1138_0 I1=FE_RN_1137_0 I2=carry[12]
XFE_RC_1700_0 ND2P $PINS O=carry[13] I1=FE_RN_1138_0 I2=FE_RN_1136_0
XFE_RC_1461_0 INV1S $PINS O=FE_RN_951_0 I=FE_RN_955_0
XFE_RC_1460_0 AOI12HS $PINS O=FE_RN_952_0 A1=FE_RN_951_0 B1=B[3] B2=A[3]
XFE_RC_1459_0 XNR2HS $PINS O=FE_RN_953_0 I1=A[3] I2=B[3]
XFE_RC_1458_0 MXL2HS $PINS OB=SUM[3] S=carry[3] A=FE_RN_953_0 B=FE_RN_952_0
XFE_RC_1457_0 ND2 $PINS O=FE_RN_954_0 I1=B[3] I2=A[3]
XFE_RC_1456_0 OR2 $PINS O=FE_RN_955_0 I1=A[3] I2=B[3]
XFE_RC_1455_0 ND2 $PINS O=FE_RN_956_0 I1=FE_RN_955_0 I2=carry[3]
XFE_RC_1454_0 ND2P $PINS O=carry[4] I1=FE_RN_956_0 I2=FE_RN_954_0
XFE_RC_1235_0 ND2S $PINS O=FE_RN_787_0 I1=B[13] I2=A[13]
XFE_RC_1234_0 AN2 $PINS O=FE_RN_788_0 I1=FE_RN_791_0 I2=FE_RN_787_0
XFE_RC_1233_0 XNR2HS $PINS O=FE_RN_789_0 I1=A[13] I2=B[13]
XFE_RC_1232_0 MXL2HS $PINS OB=SUM[13] S=carry[13] A=FE_RN_789_0 B=FE_RN_788_0
XFE_RC_1231_0 ND2S $PINS O=FE_RN_790_0 I1=B[13] I2=A[13]
XFE_RC_1230_0 OR2S $PINS O=FE_RN_791_0 I1=A[13] I2=B[13]
XFE_RC_1229_0 ND2 $PINS O=FE_RN_792_0 I1=FE_RN_791_0 I2=carry[13]
XFE_RC_1228_0 ND2P $PINS O=carry[14] I1=FE_RN_792_0 I2=FE_RN_790_0
XFE_RC_1062_0 INV1S $PINS O=FE_RN_664_0 I=FE_RN_668_0
XFE_RC_1061_0 AOI12HS $PINS O=FE_RN_665_0 A1=FE_RN_664_0 B1=B[24] B2=A[24]
XFE_RC_1060_0 XNR2HS $PINS O=FE_RN_666_0 I1=A[24] I2=B[24]
XFE_RC_1059_0 MXL2HS $PINS OB=SUM[24] S=carry[24] A=FE_RN_666_0 B=FE_RN_665_0
XFE_RC_1058_0 INV1S $PINS O=FE_RN_667_0 I=carry[24]
XFE_RC_1057_0 OR2S $PINS O=FE_RN_668_0 I1=A[24] I2=B[24]
XFE_RC_1055_0 MOAI1 $PINS O=carry[25] A1=FE_RN_664_0 A2=FE_RN_667_0 B1=B[24]
+ B2=A[24]
XFE_RC_870_0 XOR2HS $PINS O=FE_RN_522_0 I1=A[4] I2=B[4]
XFE_RC_867_0 ND2 $PINS O=FE_RN_524_0 I1=B[4] I2=A[4]
XFE_RC_866_0 OR2S $PINS O=FE_RN_525_0 I1=A[4] I2=B[4]
XFE_RC_865_0 ND2 $PINS O=FE_RN_526_0 I1=carry[4] I2=FE_RN_525_0
XFE_RC_864_0 ND2P $PINS O=carry[5] I1=FE_RN_526_0 I2=FE_RN_524_0
XFE_RC_685_0 ND2S $PINS O=FE_RN_388_0 I1=B[14] I2=A[14]
XFE_RC_684_0 AN2 $PINS O=FE_RN_389_0 I1=FE_RN_392_0 I2=FE_RN_388_0
XFE_RC_683_0 XNR2HS $PINS O=FE_RN_390_0 I1=A[14] I2=B[14]
XFE_RC_682_0 MXL2HS $PINS OB=SUM[14] S=carry[14] A=FE_RN_390_0 B=FE_RN_389_0
XFE_RC_681_0 ND2S $PINS O=FE_RN_391_0 I1=B[14] I2=A[14]
XFE_RC_680_0 OR2S $PINS O=FE_RN_392_0 I1=A[14] I2=B[14]
XFE_RC_679_0 ND2 $PINS O=FE_RN_393_0 I1=FE_RN_392_0 I2=carry[14]
XFE_RC_678_0 ND2P $PINS O=carry[15] I1=FE_RN_393_0 I2=FE_RN_391_0
XFE_RC_519_0 ND3P $PINS O=carry[28] I1=n12 I2=n11 I3=n10
XFE_RC_518_0 ND3P $PINS O=carry[16] I1=n32 I2=n33 I3=n31
XFE_RC_502_0 ND2S $PINS O=FE_RN_259_0 I1=B[25] I2=A[25]
XFE_RC_501_0 AN2 $PINS O=FE_RN_260_0 I1=FE_RN_263_0 I2=FE_RN_259_0
XFE_RC_500_0 XNR2HS $PINS O=FE_RN_261_0 I1=A[25] I2=B[25]
XFE_RC_499_0 MXL2HS $PINS OB=SUM[25] S=FE_OCPN364_carry_25 A=FE_RN_261_0
+ B=FE_RN_260_0
XFE_RC_498_0 ND2S $PINS O=FE_RN_262_0 I1=B[25] I2=A[25]
XFE_RC_497_0 OR2S $PINS O=FE_RN_263_0 I1=A[25] I2=B[25]
XFE_RC_496_0 ND2 $PINS O=FE_RN_264_0 I1=FE_RN_263_0 I2=carry[25]
XFE_RC_495_0 ND2P $PINS O=carry[26] I1=FE_RN_264_0 I2=FE_RN_262_0
XFE_RC_441_0 INV1S $PINS O=FE_RN_219_0 I=n17
XFE_RC_440_0 ND3P $PINS O=carry[17] I1=n35 I2=n36 I3=FE_RN_219_0
XFE_RC_431_0 ND3P $PINS O=carry[7] I1=n27 I2=n26 I3=n25
XFE_RC_413_0 ND3P $PINS O=carry[20] I1=n39 I2=n38 I3=n37
XFE_OFC241_div_out_0 INV1S $PINS O=n54 I=A[0]
XU1_23 FA1 $PINS S=SUM[23] CO=carry[24] A=A[23] B=B[23] CI=carry[23]
XU1_22 FA1 $PINS S=SUM[22] CO=carry[23] A=A[22] B=B[22] CI=carry[22]
XU1_21 FA1 $PINS S=SUM[21] CO=carry[22] A=A[21] B=B[21] CI=carry[21]
XU1_10 FA1 $PINS S=SUM[10] CO=carry[11] A=A[10] B=B[10] CI=carry[10]
XU1_9 FA1 $PINS S=SUM[9] CO=carry[10] A=A[9] B=B[9] CI=carry[9]
XU1_1 FA1 $PINS S=SUM[1] CO=carry[2] A=A[1] B=B[1] CI=n55
XU1 XOR2HS $PINS O=SUM[31] I1=carry[31] I2=n50
XU3 ND2P $PINS O=n18 I1=carry[18] I2=A[18]
XU4 ND2 $PINS O=n14 I1=A[28] I2=B[28]
XU5 ND2P $PINS O=carry[29] I1=n15 I2=n3
XU6 INV2CK $PINS O=n3 I=n2
XU8 ND3P $PINS O=carry[18] I1=n4 I2=n5 I3=n6
XU9 XOR3 $PINS O=SUM[29] I1=A[29] I2=B[29] I3=carry[29]
XU11 XOR3 $PINS O=SUM[7] I1=A[7] I2=B[7] I3=carry[7]
XU12 XOR3 $PINS O=SUM[18] I1=A[18] I2=B[18] I3=carry[18]
XU13 XOR3 $PINS O=SUM[30] I1=A[30] I2=B[30] I3=carry[30]
XU14 XOR2HS $PINS O=n1 I1=A[32] I2=B[32]
XU15 ND2P $PINS O=n2 I1=n16 I2=n14
XU16 ND2S $PINS O=n15 I1=A[28] I2=carry[28]
XU17 ND2 $PINS O=n16 I1=B[28] I2=carry[28]
XU18 ND2 $PINS O=n44 I1=carry[29] I2=A[29]
XU19 ND2 $PINS O=n45 I1=carry[29] I2=B[29]
XU20 ND2 $PINS O=n19 I1=carry[18] I2=B[18]
XU21 ND2P $PINS O=n29 I1=carry[7] I2=B[7]
XU23 ND2 $PINS O=n21 I1=A[5] I2=B[5]
XU25 ND2 $PINS O=n37 I1=A[19] I2=B[19]
XU26 ND2 $PINS O=n10 I1=A[27] I2=B[27]
XU27 ND3P $PINS O=carry[31] I1=n48 I2=n47 I3=n49
XU28 ND2 $PINS O=n48 I1=carry[30] I2=B[30]
XU29 ND2 $PINS O=n47 I1=carry[30] I2=A[30]
XU30 ND2 $PINS O=n31 I1=A[15] I2=B[15]
XU31 XOR3 $PINS O=SUM[5] I1=A[5] I2=B[5] I3=carry[5]
XU32 XOR3 $PINS O=SUM[15] I1=A[15] I2=B[15] I3=carry[15]
XU33 XOR3 $PINS O=SUM[19] I1=A[19] I2=B[19] I3=carry[19]
XU34 ND3 $PINS O=carry[21] I1=n43 I2=n42 I3=n41
XU35 ND2 $PINS O=n42 I1=A[20] I2=carry[20]
XU36 XOR3 $PINS O=SUM[27] I1=A[27] I2=B[27] I3=FE_OCPN436_carry_27
XU37 XOR3 $PINS O=SUM[17] I1=A[17] I2=B[17] I3=carry[17]
XU38 ND2 $PINS O=n4 I1=carry[17] I2=A[17]
XU39 ND2 $PINS O=n5 I1=carry[17] I2=B[17]
XU40 ND2 $PINS O=n6 I1=A[17] I2=B[17]
XU41 XOR3 $PINS O=SUM[26] I1=A[26] I2=B[26] I3=carry[26]
XU42 ND2 $PINS O=n7 I1=carry[26] I2=A[26]
XU43 ND2 $PINS O=n8 I1=carry[26] I2=B[26]
XU44 ND2 $PINS O=n9 I1=A[26] I2=B[26]
XU45 ND3P $PINS O=carry[27] I1=n7 I2=n8 I3=n9
XU46 ND2P $PINS O=n11 I1=A[27] I2=carry[27]
XU47 ND2 $PINS O=n12 I1=B[27] I2=carry[27]
XU49 XOR2HS $PINS O=n13 I1=A[28] I2=B[28]
XU50 XOR2HS $PINS O=SUM[28] I1=n13 I2=FE_OCPN227_carry_28
XU52 AN2 $PINS O=n17 I1=A[16] I2=B[16]
XU53 ND2S $PINS O=n20 I1=A[18] I2=B[18]
XU54 ND2P $PINS O=n28 I1=carry[7] I2=A[7]
XU55 ND2 $PINS O=n22 I1=A[5] I2=carry[5]
XU56 ND2 $PINS O=n23 I1=B[5] I2=carry[5]
XU57 ND3P $PINS O=carry[6] I1=n22 I2=n23 I3=n21
XU58 XOR2HS $PINS O=n24 I1=A[6] I2=B[6]
XU59 XOR2HS $PINS O=SUM[6] I1=n24 I2=carry[6]
XU60 ND2S $PINS O=n25 I1=A[6] I2=B[6]
XU61 ND2 $PINS O=n26 I1=A[6] I2=carry[6]
XU62 ND2 $PINS O=n27 I1=B[6] I2=carry[6]
XU63 ND2S $PINS O=n30 I1=A[7] I2=B[7]
XU64 ND3P $PINS O=carry[8] I1=n28 I2=n29 I3=n30
XU65 ND2 $PINS O=n32 I1=A[15] I2=carry[15]
XU66 ND2 $PINS O=n33 I1=B[15] I2=carry[15]
XU68 XOR2HS $PINS O=n34 I1=A[16] I2=B[16]
XU69 XOR2HS $PINS O=SUM[16] I1=n34 I2=carry[16]
XU70 ND2 $PINS O=n35 I1=A[16] I2=carry[16]
XU71 ND2 $PINS O=n36 I1=B[16] I2=carry[16]
XU72 ND2 $PINS O=n38 I1=carry[19] I2=A[19]
XU73 ND2 $PINS O=n39 I1=B[19] I2=carry[19]
XU74 XOR2HS $PINS O=n40 I1=A[20] I2=B[20]
XU75 XOR2HS $PINS O=SUM[20] I1=n40 I2=carry[20]
XU76 ND2S $PINS O=n41 I1=A[20] I2=B[20]
XU77 ND2 $PINS O=n43 I1=B[20] I2=carry[20]
XU78 ND2S $PINS O=n46 I1=A[29] I2=B[29]
XU79 ND3P $PINS O=carry[30] I1=n44 I2=n45 I3=n46
XU80 ND2 $PINS O=n51 I1=carry[31] I2=A[31]
XU81 ND2S $PINS O=n49 I1=A[30] I2=B[30]
XU82 XOR2HS $PINS O=n50 I1=A[31] I2=B[31]
XU83 ND2 $PINS O=n52 I1=carry[31] I2=B[31]
XU84 ND2S $PINS O=n53 I1=A[31] I2=B[31]
XU85 ND3 $PINS O=carry[32] I1=n51 I2=n52 I3=n53
XU86 AN2B1 $PINS O=n55 I1=B[0] B1=n54
XU87 XOR2HS $PINS O=SUM[0] I1=B[0] I2=A[0]
.ENDS

.SUBCKT div_DW_cmp_4 A[31] A[30] A[29] A[28] A[27] A[26] A[25] A[24] A[23]
+ A[22] A[21] A[20] A[19] A[18] A[17] A[16] A[15] A[14] A[13] A[12] A[11] A[10]
+ A[9] A[8] A[7] A[6] A[5] A[4] A[3] A[2] A[1] A[0] B[31] B[30] B[29] B[28]
+ B[27] B[26] B[25] B[24] B[23] B[22] B[21] B[20] B[19] B[18] B[17] B[16] B[15]
+ B[14] B[13] B[12] B[11] B[10] B[9] B[8] B[7] B[6] B[5] B[4] B[3] B[2] B[1]
+ B[0] TC GE_LT GE_GT_EQ GE_LT_GT_LE EQ_NE p1
XFE_RC_2397_0 AO12 $PINS O=n288 A1=n297 B1=n296 B2=n298
XU157 OA12S $PINS O=n309 A1=n311 B1=A[8] B2=n243
XU158 MAOI1S $PINS O=n333 A1=A[2] A2=n227 B1=B[3] B2=n262
XU159 ND2S $PINS O=n330 I1=B[5] I2=n261
XU160 ND2S $PINS O=n332 I1=B[7] I2=n260
XU161 ND2S $PINS O=n340 I1=B[3] I2=n262
XU162 ND2S $PINS O=n311 I1=B[9] I2=n259
XU163 INV1S $PINS O=n238 I=n310
XU164 INV1S $PINS O=n244 I=n328
XU165 INV1S $PINS O=n239 I=n312
XU166 MAOI1 $PINS O=n317 A1=A[14] A2=n226 B1=B[15] B2=n256
XU167 AN2 $PINS O=n226 I1=n320 I2=n240
XU168 AN2 $PINS O=n227 I1=n340 I2=n247
XU169 INV1S $PINS O=n247 I=B[2]
XU170 INV1S $PINS O=n257 I=A[13]
XU171 INV1S $PINS O=n240 I=B[14]
XU172 INV1S $PINS O=n258 I=A[11]
XU173 INV1S $PINS O=n259 I=A[9]
XU174 INV1S $PINS O=n256 I=A[15]
XU175 INV1S $PINS O=n262 I=A[3]
XU176 INV1S $PINS O=n243 I=B[8]
XU177 INV1S $PINS O=n242 I=B[10]
XU178 INV1S $PINS O=n235 I=n279
XU179 MAOI1 $PINS O=n292 A1=A[30] A2=n228 B1=B[31] B2=A[31]
XU180 AN2 $PINS O=n228 I1=n295 I2=n229
XU181 INV1S $PINS O=n241 I=B[12]
XU182 INV1S $PINS O=n237 I=B[16]
XU183 INV1S $PINS O=n248 I=B[1]
XU184 INV1S $PINS O=n230 I=B[28]
XU185 INV1S $PINS O=n255 I=A[17]
XU186 INV1S $PINS O=n249 I=A[29]
XU187 INV1S $PINS O=n245 I=B[6]
XU188 INV1S $PINS O=n246 I=B[4]
XU189 INV1S $PINS O=n229 I=B[30]
XU190 INV1S $PINS O=n234 I=B[20]
XU191 INV1S $PINS O=n254 I=A[19]
XU192 INV1S $PINS O=n250 I=A[27]
XU193 INV1S $PINS O=n251 I=A[25]
XU194 INV1S $PINS O=n261 I=A[5]
XU195 INV1S $PINS O=n260 I=A[7]
XU196 INV1S $PINS O=n252 I=A[23]
XU197 INV1S $PINS O=n253 I=A[21]
XU198 INV1S $PINS O=n231 I=B[26]
XU199 INV1S $PINS O=n232 I=B[24]
XU200 INV1S $PINS O=n236 I=B[18]
XU201 INV1S $PINS O=n233 I=B[22]
XU203 MOAI1S $PINS O=GE_LT_GT_LE A1=n264 A2=n265 B1=n266 B2=n267
XU204 ND3 $PINS O=n267 I1=n268 I2=n269 I3=n270
XU205 OAI22S $PINS O=n269 A1=n271 A2=n272 B1=n272 B2=n273
XU206 MOAI1S $PINS O=n273 A1=B[21] A2=n253 B1=A[20] B2=n274
XU207 AN2 $PINS O=n274 I1=n275 I2=n234
XU208 MOAI1S $PINS O=n272 A1=B[23] A2=n252 B1=A[22] B2=n276
XU209 AN2 $PINS O=n276 I1=n277 I2=n233
XU210 OAI112HS $PINS O=n268 A1=n280 B1=n281 C1=n278 C2=n279
XU211 OAI112HS $PINS O=n280 A1=n282 B1=n235 C1=B[17] C2=n255
XU212 ND3 $PINS O=n282 I1=n283 I2=n237 I3=A[16]
XU213 MOAI1S $PINS O=n279 A1=B[19] A2=n254 B1=A[18] B2=n284
XU214 AN2 $PINS O=n284 I1=n285 I2=n236
XU215 ND2 $PINS O=n266 I1=n270 I2=n286
XU216 AOI22S $PINS O=n270 A1=n287 A2=n288 B1=n289 B2=n290
XU217 OAI112HS $PINS O=n290 A1=n291 B1=n292 C1=B[29] C2=n249
XU218 ND3 $PINS O=n291 I1=n293 I2=n230 I3=A[28]
XU219 OR2B1S $PINS O=n289 I1=n294 B1=n292
XU221 MOAI1S $PINS O=n298 A1=B[25] A2=n251 B1=A[24] B2=n299
XU222 AN2 $PINS O=n299 I1=n300 I2=n232
XU223 MOAI1S $PINS O=n297 A1=B[27] A2=n250 B1=A[26] B2=n301
XU224 AN2 $PINS O=n301 I1=n302 I2=n231
XU225 OR3B2 $PINS O=n265 I1=n286 B1=n281 B2=n278
XU226 OA12 $PINS O=n278 A1=n285 B1=A[18] B2=n236
XU227 ND2 $PINS O=n285 I1=B[19] I2=n254
XU228 OA112 $PINS O=n281 A1=n275 B1=n271 C1=p1 C2=n234
XU229 OA12 $PINS O=n271 A1=n277 B1=A[22] B2=n233
XU230 ND2 $PINS O=n277 I1=B[23] I2=n252
XU231 ND2 $PINS O=n275 I1=B[21] I2=n253
XU232 ND3 $PINS O=n286 I1=n296 I2=n287 I3=n303
XU233 OA12 $PINS O=n303 A1=n300 B1=A[24] B2=n232
XU234 ND2 $PINS O=n300 I1=B[25] I2=n251
XU235 OA112 $PINS O=n287 A1=n293 B1=n294 C1=A[28] C2=n230
XU236 OA12 $PINS O=n294 A1=n295 B1=A[30] B2=n229
XU237 ND2 $PINS O=n295 I1=B[31] I2=A[31]
XU238 ND2 $PINS O=n293 I1=B[29] I2=n249
XU239 OA12 $PINS O=n296 A1=n302 B1=A[26] B2=n231
XU240 ND2 $PINS O=n302 I1=B[27] I2=n250
XU241 OAI112HS $PINS O=n264 A1=n283 B1=n304 C1=A[16] C2=n237
XU242 AOI13HS $PINS O=n304 A1=n307 B1=n305 B2=n306 B3=n238
XU243 AOI13HS $PINS O=n307 A1=n310 B1=n308 B2=n239 B3=n309
XU244 MOAI1S $PINS O=n310 A1=n312 A2=n313 B1=n314 B2=n315
XU245 OAI112HS $PINS O=n315 A1=n316 B1=n317 C1=B[13] C2=n257
XU246 ND3 $PINS O=n316 I1=n318 I2=n241 I3=A[12]
XU247 OR2B1S $PINS O=n314 I1=n319 B1=n317
XU248 OAI22S $PINS O=n313 A1=n308 A2=n321 B1=n321 B2=n322
XU249 MOAI1S $PINS O=n322 A1=B[9] A2=n259 B1=A[8] B2=n323
XU250 AN2 $PINS O=n323 I1=n311 I2=n243
XU251 MOAI1S $PINS O=n321 A1=B[11] A2=n258 B1=A[10] B2=n324
XU252 AN2 $PINS O=n324 I1=n325 I2=n242
XU253 OA12 $PINS O=n308 A1=n325 B1=A[10] B2=n242
XU254 ND2 $PINS O=n325 I1=B[11] I2=n258
XU255 OAI112HS $PINS O=n312 A1=n318 B1=n319 C1=A[12] C2=n241
XU256 OA12 $PINS O=n319 A1=n320 B1=A[14] B2=n240
XU257 ND2 $PINS O=n320 I1=B[15] I2=n256
XU258 ND2 $PINS O=n318 I1=B[13] I2=n257
XU259 OAI22S $PINS O=n306 A1=n326 A2=n327 B1=n244 B2=n326
XU260 MOAI1S $PINS O=n327 A1=B[5] A2=n261 B1=A[4] B2=n329
XU261 AN2 $PINS O=n329 I1=n330 I2=n246
XU262 MOAI1S $PINS O=n326 A1=B[7] A2=n260 B1=A[6] B2=n331
XU263 AN2 $PINS O=n331 I1=n332 I2=n245
XU264 AO112 $PINS O=n305 A1=n328 B1=n335 C1=n333 C2=n334
XU265 OAI112HS $PINS O=n335 A1=n330 B1=n336 C1=A[4] C2=n246
XU266 ND2 $PINS O=n336 I1=n337 I2=n333
XU267 AOI22S $PINS O=n337 A1=A[1] A2=n248 B1=n338 B2=A[0]
XU268 NR2 $PINS O=n338 I1=B[0] I2=n339
XU269 NR2 $PINS O=n339 I1=A[1] I2=n248
XU270 OAI12HS $PINS O=n328 A1=n332 B1=A[6] B2=n245
XU271 OAI12HS $PINS O=n334 A1=n340 B1=A[2] B2=n247
XU272 ND2 $PINS O=n283 I1=B[17] I2=n255
.ENDS

.SUBCKT div i_rst div_in_0[31] div_in_0[30] div_in_0[29] div_in_0[28]
+ div_in_0[27] div_in_0[26] div_in_0[25] div_in_0[24] div_in_0[23] div_in_0[22]
+ div_in_0[21] div_in_0[20] div_in_0[19] div_in_0[18] div_in_0[17] div_in_0[16]
+ div_in_0[15] div_in_0[14] div_in_0[13] div_in_0[12] div_in_0[11] div_in_0[10]
+ div_in_0[9] div_in_0[8] div_in_0[7] div_in_0[6] div_in_0[5] div_in_0[4]
+ div_in_0[3] div_in_0[2] div_in_0[1] div_in_0[0] div_in_1[31] div_in_1[30]
+ div_in_1[29] div_in_1[28] div_in_1[27] div_in_1[26] div_in_1[25] div_in_1[24]
+ div_in_1[23] div_in_1[22] div_in_1[21] div_in_1[20] div_in_1[19] div_in_1[18]
+ div_in_1[17] div_in_1[16] div_in_1[15] div_in_1[14] div_in_1[13] div_in_1[12]
+ div_in_1[11] div_in_1[10] div_in_1[9] div_in_1[8] div_in_1[7] div_in_1[6]
+ div_in_1[5] div_in_1[4] div_in_1[3] div_in_1[2] div_in_1[1] div_in_1[0]
+ prime[31] prime[30] prime[29] prime[28] prime[27] prime[26] prime[25]
+ prime[24] prime[23] prime[22] prime[21] prime[20] prime[19] prime[18]
+ prime[17] prime[16] prime[15] prime[14] prime[13] prime[12] prime[11]
+ prime[10] prime[9] prime[8] prime[7] prime[6] prime[5] prime[4] prime[3]
+ prime[2] prime[1] prime[0] sel_div div_out[31] div_out[30] div_out[29]
+ div_out[28] div_out[27] div_out[26] div_out[25] div_out[24] div_out[23]
+ div_out[22] div_out[21] div_out[20] div_out[19] div_out[18] div_out[17]
+ div_out[16] div_out[15] div_out[14] div_out[13] div_out[12] div_out[11]
+ div_out[10] div_out[9] div_out[8] div_out[7] div_out[6] div_out[5] div_out[4]
+ div_out[3] div_out[2] div_out[1] div_out[0] done_div
+ FE_OFN39_FE_DBTN1_i_i_rst FE_OFN9_FE_DBTN1_i_i_rst FE_OFN5_FE_DBTN1_i_i_rst
+ FE_OFN2_FE_DBTN1_i_i_rst FE_OFN0_FE_DBTN1_i_i_rst FE_OFN52_raw_prime_30
+ FE_OFN56_raw_prime_29 FE_OFN62_raw_prime_27 FE_OFN66_raw_prime_26
+ FE_OFN70_raw_prime_25 FE_OFN76_raw_prime_23 FE_OFN80_raw_prime_22
+ FE_OFN84_raw_prime_21 FE_OFN90_raw_prime_19 FE_OFN94_raw_prime_18
+ FE_OFN98_raw_prime_17 FE_OFN102_raw_prime_16 FE_OFN115_raw_prime_12
+ FE_OFN144_raw_prime_8 FE_OFN163_n FE_OFN338_n310 FE_OCPN177_FE_OFN86_n312
+ FE_OFN195_FE_OFN56_raw_prime_6 FE_OFN199_FE_OFN55_raw_prime_7
+ FE_OFN203_FE_OFN53_raw_prime_9 FE_OFN208_FE_OFN52_raw_prime_10
+ FE_OFN211_FE_OFN51_raw_prime_11 FE_OFN219_FE_OFN49_raw_prime_13
+ FE_OFN233_FE_OFN42_raw_prime_20 FE_OFN245_FE_OFN38_raw_prime_24
+ FE_OFN254_FE_OFN36_raw_prime_26 FE_OFN262_FE_OFN34_raw_prime_28
+ FE_OFN274_FE_OFN31_raw_prime_31 FE_OFN303_FE_OFN5_FE_DBTN1_i_i_rst
+ FE_OFN307_FE_OFN3_FE_DBTN1_i_i_rst FE_OFN306_FE_OFN3_FE_DBTN1_i_i_rst
+ FE_OFN309_FE_OFN2_FE_DBTN1_i_i_rst FE_OFN308_FE_OFN2_FE_DBTN1_i_i_rst
+ FE_OFN313_FE_OFN1_FE_DBTN1_i_i_rst FE_OFN312_FE_OFN1_FE_DBTN1_i_i_rst
+ FE_OFN319_n FE_OFN320_n FE_OFN326_n i_clk_clone5 i_clk_clone4 i_clk_clone3
+ i_clk_clone2 i_clk_clone1 i_clk FE_OCPN350_FE_OCPN344_FE_OFN86_n312
XFE_PHC1601_V_17 BUF1CK $PINS O=FE_PHN1601_V_17 I=V[17]
XFE_PHC1537_state_0 BUF1CK $PINS O=FE_PHN1537_state_0 I=FE_PHN1249_state_0
XFE_PHC1535_loop_num_7 BUF1CK $PINS O=FE_PHN1535_loop_num_7 I=loop_num[7]
XFE_PHC1519_loop_num_0 BUF1CK $PINS O=FE_PHN1519_loop_num_0 I=loop_num[0]
XFE_PHC1437_n347 DELA $PINS O=FE_PHN1437_n347 I=n347
XFE_PHC1434_n352 BUF1S $PINS O=FE_PHN1434_n352 I=n352
XFE_PHC1429_n662 BUF1S $PINS O=FE_PHN1429_n662 I=n662
XFE_PHC1423_n350 DELA $PINS O=FE_PHN1423_n350 I=n350
XFE_PHC1419_n583 DELA $PINS O=FE_PHN1419_n583 I=n583
XFE_PHC1414_n354 DELA $PINS O=n354 I=FE_PHN1414_n354
XFE_PHC1413_n584 DELA $PINS O=FE_PHN1413_n584 I=n584
XFE_PHC1411_n585 DELA $PINS O=FE_PHN1411_n585 I=n585
XFE_PHC1404_n356 DELA $PINS O=FE_PHN1404_n356 I=n356
XFE_PHC1402_n586 DELA $PINS O=n586 I=FE_PHN1402_n586
XFE_PHC1393_n658 BUF1CK $PINS O=FE_PHN1393_n658 I=n658
XFE_PHC1378_n657 BUF1CK $PINS O=FE_PHN1378_n657 I=n657
XFE_PHC1335_U_3 BUF1S $PINS O=U[3] I=FE_PHN1335_U_3
XFE_PHC1334_V_2 BUF1S $PINS O=V[2] I=FE_PHN1334_V_2
XFE_PHC1333_U_2 BUF1S $PINS O=FE_PHN1333_U_2 I=U[2]
XFE_PHC1331_V_7 BUF1CK $PINS O=V[7] I=FE_PHN1331_V_7
XFE_PHC1329_U_4 BUF1S $PINS O=U[4] I=FE_PHN1329_U_4
XFE_PHC1327_U_6 BUF1S $PINS O=FE_PHN1327_U_6 I=U[6]
XFE_PHC1326_U_7 BUF1S $PINS O=U[7] I=FE_PHN1326_U_7
XFE_PHC1324_V_4 BUF1S $PINS O=V[4] I=FE_PHN1324_V_4
XFE_PHC1322_V_8 BUF1S $PINS O=FE_PHN1322_V_8 I=V[8]
XFE_PHC1319_U_8 BUF1S $PINS O=U[8] I=FE_PHN1319_U_8
XFE_PHC1314_U_5 BUF1S $PINS O=U[5] I=FE_PHN1314_U_5
XFE_PHC1312_V_9 BUF1CK $PINS O=FE_PHN1312_V_9 I=V[9]
XFE_PHC1310_V_10 BUF1S $PINS O=FE_PHN1310_V_10 I=V[10]
XFE_PHC1308_U_10 BUF1S $PINS O=U[10] I=FE_PHN1308_U_10
XFE_PHC1305_V_11 BUF1CK $PINS O=FE_PHN1305_V_11 I=V[11]
XFE_PHC1298_U_9 BUF1S $PINS O=U[9] I=FE_PHN1298_U_9
XFE_PHC1293_U_11 BUF1S $PINS O=U[11] I=FE_PHN1293_U_11
XFE_PHC1290_U_12 BUF1CK $PINS O=U[12] I=FE_PHN1290_U_12
XFE_PHC1282_V_13 BUF1CK $PINS O=V[13] I=FE_PHN1282_V_13
XFE_PHC1277_V_15 BUF1CK $PINS O=FE_PHN1277_V_15 I=V[15]
XFE_PHC1276_V_23 BUF1CK $PINS O=FE_PHN1276_V_23 I=V[23]
XFE_PHC1275_U_13 BUF1S $PINS O=U[13] I=FE_PHN1275_U_13
XFE_PHC1274_U_14 BUF1S $PINS O=U[14] I=FE_PHN1274_U_14
XFE_PHC1273_U_15 BUF1S $PINS O=U[15] I=FE_PHN1273_U_15
XFE_PHC1271_V_29 BUF1CK $PINS O=V[29] I=FE_PHN1271_V_29
XFE_PHC1270_V_17 BUF1CK $PINS O=V[17] I=FE_PHN1270_V_17
XFE_PHC1269_V_25 BUF1CK $PINS O=V[25] I=FE_PHN1269_V_25
XFE_PHC1268_V_30 BUF1S $PINS O=V[30] I=FE_PHN1268_V_30
XFE_PHC1267_V_24 BUF1CK $PINS O=FE_PHN1267_V_24 I=V[24]
XFE_PHC1263_V_19 BUF1S $PINS O=V[19] I=FE_PHN1263_V_19
XFE_PHC1260_U_26 BUF1CK $PINS O=FE_PHN1260_U_26 I=U[26]
XFE_PHC1259_V_16 BUF1S $PINS O=FE_PHN1259_V_16 I=V[16]
XFE_PHC1258_U_22 BUF1S $PINS O=FE_PHN1258_U_22 I=U[22]
XFE_PHC1257_U_23 BUF1S $PINS O=U[23] I=FE_PHN1257_U_23
XFE_PHC1254_U_25 BUF1S $PINS O=U[25] I=FE_PHN1254_U_25
XFE_PHC1253_U_29 BUF1S $PINS O=U[29] I=FE_PHN1253_U_29
XFE_PHC1250_V_22 BUF1S $PINS O=FE_PHN1250_V_22 I=V[22]
XFE_PHC1249_state_0 BUF1S $PINS O=FE_PHN1249_state_0 I=state[0]
XFE_PHC1248_V_18 BUF1S $PINS O=V[18] I=FE_PHN1248_V_18
XFE_PHC1247_U_19 BUF1S $PINS O=FE_PHN1247_U_19 I=U[19]
XFE_PHC1246_U_21 BUF1S $PINS O=FE_PHN1246_U_21 I=U[21]
XFE_PHC1245_V_20 BUF1S $PINS O=V[20] I=FE_PHN1245_V_20
XFE_PHC1244_U_24 BUF1S $PINS O=FE_PHN1244_U_24 I=U[24]
XFE_PHC1237_U_18 BUF1S $PINS O=FE_PHN1237_U_18 I=U[18]
XFE_PHC1233_U_20 BUF1S $PINS O=FE_PHN1233_U_20 I=U[20]
XFE_PHC1231_V_1 BUF1CK $PINS O=FE_PHN1231_V_1 I=V[1]
XFE_PHC1224_U_17 BUF1S $PINS O=U[17] I=FE_PHN1224_U_17
XFE_PHC1219_V_6 BUF1CK $PINS O=FE_PHN1219_V_6 I=V[6]
XFE_PHC1215_V_5 BUF1CK $PINS O=FE_PHN1215_V_5 I=V[5]
XFE_PHC1213_V_14 BUF1CK $PINS O=FE_PHN1213_V_14 I=V[14]
XFE_PHC1212_V_12 BUF1CK $PINS O=FE_PHN1212_V_12 I=V[12]
XFE_PHC1211_V_21 BUF1CK $PINS O=FE_PHN1211_V_21 I=V[21]
XFE_PHC1176_i_5 BUF1CK $PINS O=i[5] I=FE_PHN1176_i_5
XFE_PHC1175_n762 BUF1CK $PINS O=FE_PHN1175_n762 I=n762
XFE_PHC1172_n760 BUF1CK $PINS O=FE_PHN1172_n760 I=n760
XFE_PHC1160_i_6 BUF1CK $PINS O=i[6] I=FE_PHN1160_i_6
XFE_PHC1155_i_7 BUF1CK $PINS O=i[7] I=FE_PHN1155_i_7
XFE_PHC1151_i_8 BUF1CK $PINS O=i[8] I=FE_PHN1151_i_8
XFE_PHC1138_N37 BUF1S $PINS O=FE_PHN1138_N37 I=N37
XFE_PHC1136_N38 BUF1S $PINS O=FE_PHN1136_N38 I=N38
XFE_PHC1123_N39 BUF1S $PINS O=FE_PHN1123_N39 I=N39
XFE_PHC1113_N41 BUF1S $PINS O=FE_PHN1113_N41 I=N41
XFE_PHC1108_N40 BUF1S $PINS O=FE_PHN1108_N40 I=N40
XFE_PHC1104_div_out_1 BUF1CK $PINS O=FE_PHN1104_div_out_1 I=div_out[1]
XFE_PHC1073_V_26 BUF1CK $PINS O=FE_PHN1073_V_26 I=V[26]
XFE_PHC1072_V_27 BUF1CK $PINS O=FE_PHN1072_V_27 I=V[27]
XFE_PHC1057_U_0 BUF1CK $PINS O=FE_PHN1057_U_0 I=U[0]
XFE_PHC1055_U_28 BUF1CK $PINS O=FE_PHN1055_U_28 I=U[28]
XFE_PHC1001_i_9 BUF1CK $PINS O=FE_PHN1001_i_9 I=i[9]
XFE_PHC988_V_31 BUF1CK $PINS O=FE_PHN988_V_31 I=V[31]
XFE_PHC940_U_16 BUF1CK $PINS O=FE_PHN940_U_16 I=U[16]
XFE_PHC840_V_28 BUF1CK $PINS O=FE_PHN840_V_28 I=V[28]
XFE_PHC756_U_31 BUF1S $PINS O=FE_PHN756_U_31 I=U[31]
XFE_PHC754_U_30 BUF1CK $PINS O=FE_PHN754_U_30 I=U[30]
XFE_PHC751_U_27 BUF1CK $PINS O=FE_PHN751_U_27 I=U[27]
XFE_PHC747_U_1 BUF1CK $PINS O=FE_PHN747_U_1 I=U[1]
XFE_OCPC659_div_out_0 BUF1 $PINS O=div_out[0] I=FE_OCPN664_div_out_0
XFE_OCPC656_V_0 BUF1 $PINS O=FE_OCPN661_V_0 I=V[0]
XFE_OFC612_n29 BUF1 $PINS O=FE_OFN645_n29 I=n29
XFE_OFC611_n397 BUF1 $PINS O=FE_OFN644_n397 I=n397
XFE_OFC607_FE_DBTN91_n35 BUF1 $PINS O=FE_OFN640_n I=FE_OFN639_n
XFE_OFC606_FE_DBTN91_n35 BUF1 $PINS O=FE_OFN639_n I=FE_OFN82_FE_DBTN91_n35
XFE_OFC605_FE_DBTN91_n35 BUF1 $PINS O=FE_OFN638_n I=FE_OFN82_FE_DBTN91_n35
XFE_OFC604_n12 BUF1 $PINS O=FE_OFN637_n12 I=n12
XFE_OFC603_n11 BUF1 $PINS O=FE_OFN636_n11 I=n11
XFE_OFC602_n371 BUF1 $PINS O=FE_OFN635_n371 I=n371
XFE_OFC601_n371 BUF1 $PINS O=FE_OFN634_n371 I=n371
XFE_OFC600_n371 BUF1 $PINS O=FE_OFN633_n371 I=n371
XFE_OFC584_FE_DBTN91_n35 INV1S $PINS O=FE_OFN617_FE_DBTN91_n35
+ I=FE_OFN615_FE_DBTN91_n35
XFE_OFC583_FE_DBTN91_n35 INV1S $PINS O=FE_OFN616_FE_DBTN91_n35
+ I=FE_OFN615_FE_DBTN91_n35
XFE_OFC582_FE_DBTN91_n35 INV1S $PINS O=FE_OFN615_FE_DBTN91_n35 I=FE_DBTN91_n35
XFE_OFC534_n720 BUF1 $PINS O=FE_OFN567_n720 I=n720
XFE_OFC533_n35 BUF2CK $PINS O=FE_OFN566_n35 I=n35
XFE_OFC532_n13 BUF1 $PINS O=FE_OFN565_n13 I=n13
XFE_OFC531_n369 BUF1 $PINS O=FE_OFN564_n369 I=n369
XFE_OFC530_n218 BUF1 $PINS O=FE_OFN563_n218 I=n218
XFE_OFC529_n212 BUF2CK $PINS O=FE_OFN562_n212 I=n212
XFE_OFC528_n104 BUF2CK $PINS O=FE_OFN561_n104 I=n104
XFE_OFC527_done_div_n BUF1 $PINS O=FE_OFN560_done_div_n I=done_div_n
XFE_OFC450_FE_DBTN90_n36 BUF1 $PINS O=FE_OFN483_FE_DBTN90_n36 I=FE_DBTN90_n36
XFE_OFC449_FE_DBTN94_n37 BUF1 $PINS O=FE_OFN482_FE_DBTN94_n37 I=FE_DBTN94_n37
XFE_OFC441_FE_OFN3_FE_DBTN1_i_i_rst BUF1 $PINS
+ O=FE_OFN474_FE_OFN3_FE_DBTN1_i_i_rst I=FE_OFN2_FE_DBTN1_i_i_rst
XFE_OFC333_FE_OFN77_n10 BUF1 $PINS O=FE_OFN366_FE_OFN77_n10 I=n10
XFE_OFC332_FE_OFN78_n14 BUF2CK $PINS O=FE_OFN365_FE_OFN78_n14 I=n14
XFE_OFC331_FE_OFN79_n15 BUF2CK $PINS O=FE_OFN364_FE_OFN79_n15 I=FE_OFN79_n15
XFE_OFC330_FE_OFN80_n30 BUF1 $PINS O=FE_OFN363_FE_OFN80_n30 I=n30
XFE_RC_2263_0 AO22 $PINS O=FE_RN_1552_0 A1=FE_OFN483_FE_DBTN90_n36
+ A2=div_out[30] B1=FE_OFN363_FE_OFN80_n30 B2=div_out[31]
XFE_RC_2262_0 AOI12HS $PINS O=n26 A1=FE_RN_1552_0 B1=N668
+ B2=FE_OFN560_done_div_n
XFE_RC_2024_0 OR2 $PINS O=FE_RN_1376_0 I1=FE_DBTN142_div_out_31 I2=n719
XFE_RC_2023_0 ND2 $PINS O=FE_RN_1377_0 I1=N603 I2=FE_OFN563_n218
XFE_RC_2022_0 ND2S $PINS O=n224 I1=FE_RN_1377_0 I2=FE_RN_1376_0
XFE_RC_1238_0 INV1S $PINS O=FE_RN_793_0 I=FE_DBTN93_U_31
XFE_RC_1237_0 INV1S $PINS O=FE_RN_794_0 I=n32
XFE_RC_1236_0 AOI22H $PINS O=n455 A1=FE_RN_794_0 A2=FE_RN_793_0 B1=N78 B2=n13
XFE_RC_1139_0 INV1S $PINS O=FE_RN_724_0 I=FE_DBTN92_V_31
XFE_RC_1138_0 INV1S $PINS O=FE_RN_725_0 I=n34
XFE_RC_1137_0 AOI22S $PINS O=n385 A1=FE_RN_725_0 A2=FE_RN_724_0 B1=N142 B2=n12
XFE_RC_191_0 INV1S $PINS O=FE_RN_67_0 I=n40
XFE_RC_190_0 INV1S $PINS O=FE_RN_68_0 I=FE_OFN82_FE_DBTN91_n35
XFE_RC_189_0 MOAI1H $PINS O=n512 A1=n100 A2=FE_OFN566_n35 B1=FE_RN_68_0
+ B2=FE_RN_67_0
XFE_RC_2_0 OR2 $PINS O=FE_RN_0_0 I1=FE_DBTN142_div_out_31 I2=FE_DBTN91_n35
XFE_RC_1_0 ND2P $PINS O=FE_RN_1_0 I1=n213 I2=FE_DBTN91_n35
XFE_RC_0_0 ND2P $PINS O=n546 I1=FE_RN_1_0 I2=FE_RN_0_0
XFE_OFC303_div_out_5 INV2 $PINS O=div_out[5] I=FE_DBTN129_div_out_5
XFE_OFC301_div_out_5 INV2 $PINS O=FE_DBTN129_div_out_5 I=FE_OFN99_div_out_5
XFE_OFC237_div_out_3 BUF1 $PINS O=div_out[3] I=FE_OFN109_div_out_3
XFE_OFC236_div_out_3 INV1S $PINS O=FE_DBTN128_div_out_3 I=FE_OFN109_div_out_3
XFE_OFC235_div_out_4 BUF1 $PINS O=div_out[4] I=FE_OFN108_div_out_4
XFE_OFC228_div_out_6 INV2 $PINS O=div_out[6] I=FE_OFN104_div_out_6
XFE_OFC227_div_out_6 INV1S $PINS O=FE_OFN104_div_out_6 I=FE_OFN103_div_out_6
XFE_OFC225_div_out_7 INV1S $PINS O=FE_DBTN130_div_out_7 I=div_out[7]
XFE_OFC80_FE_DBTN91_n35 BUF1 $PINS O=FE_OFN82_FE_DBTN91_n35
+ I=FE_OFN616_FE_DBTN91_n35
XFE_OFC77_n15 BUF1CK $PINS O=FE_OFN79_n15 I=n15
XFE_DBTC142_div_out_31 INV1S $PINS O=FE_DBTN142_div_out_31 I=div_out[31]
XFE_DBTC141_div_out_29 INV1S $PINS O=FE_DBTN141_div_out_29 I=div_out[29]
XFE_DBTC140_div_out_27 INV1S $PINS O=FE_DBTN140_div_out_27 I=div_out[27]
XFE_DBTC139_div_out_25 INV1S $PINS O=FE_DBTN139_div_out_25 I=div_out[25]
XFE_DBTC138_div_out_23 INV1S $PINS O=FE_DBTN138_div_out_23 I=div_out[23]
XFE_DBTC137_div_out_21 INV1S $PINS O=FE_DBTN137_div_out_21 I=div_out[21]
XFE_DBTC136_div_out_19 INV1S $PINS O=FE_DBTN136_div_out_19 I=div_out[19]
XFE_DBTC135_div_out_17 INV1S $PINS O=FE_DBTN135_div_out_17 I=div_out[17]
XFE_DBTC134_div_out_15 INV1S $PINS O=FE_DBTN134_div_out_15 I=div_out[15]
XFE_DBTC133_div_out_13 INV1S $PINS O=FE_DBTN133_div_out_13 I=div_out[13]
XFE_DBTC132_div_out_11 INV1S $PINS O=FE_DBTN132_div_out_11 I=div_out[11]
XFE_DBTC131_div_out_9 INV1S $PINS O=FE_DBTN131_div_out_9 I=div_out[9]
XFE_DBTC94_n37 INV1S $PINS O=FE_DBTN94_n37 I=n37
XFE_DBTC93_U_31 INV1S $PINS O=FE_DBTN93_U_31 I=U[31]
XFE_DBTC92_V_31 INV1S $PINS O=FE_DBTN92_V_31 I=V[31]
XFE_DBTC91_n35 INV1S $PINS O=FE_DBTN91_n35 I=FE_OFN566_n35
XFE_DBTC90_n36 INV1S $PINS O=FE_DBTN90_n36 I=n36
XFE_DBTC89_S_0 INV1S $PINS O=FE_DBTN89_S_0 I=S[0]
XFE_DBTC88_S_1 INV1S $PINS O=FE_DBTN88_S_1 I=S[1]
XFE_DBTC87_S_2 INV1S $PINS O=FE_DBTN87_S_2 I=S[2]
XFE_DBTC86_S_4 INV1S $PINS O=FE_DBTN86_S_4 I=S[4]
XFE_DBTC85_S_6 INV1S $PINS O=FE_DBTN85_S_6 I=S[6]
XFE_DBTC84_S_8 INV1S $PINS O=FE_DBTN84_S_8 I=S[8]
XFE_DBTC83_S_10 INV1S $PINS O=FE_DBTN83_S_10 I=S[10]
XFE_DBTC82_S_12 INV1S $PINS O=FE_DBTN82_S_12 I=S[12]
XFE_DBTC81_S_14 INV1S $PINS O=FE_DBTN81_S_14 I=S[14]
XFE_DBTC80_S_16 INV1S $PINS O=FE_DBTN80_S_16 I=S[16]
XFE_DBTC79_S_18 INV1S $PINS O=FE_DBTN79_S_18 I=S[18]
XFE_DBTC78_S_20 INV1S $PINS O=FE_DBTN78_S_20 I=S[20]
XFE_DBTC77_S_22 INV1S $PINS O=FE_DBTN77_S_22 I=S[22]
XFE_DBTC76_S_24 INV1S $PINS O=FE_DBTN76_S_24 I=S[24]
XFE_DBTC75_S_26 INV1S $PINS O=FE_DBTN75_S_26 I=S[26]
XFE_DBTC74_S_28 INV1S $PINS O=FE_DBTN74_S_28 I=S[28]
XFE_DBTC73_S_30 INV1S $PINS O=FE_DBTN73_S_30 I=S[30]
Xstate_reg[1] JKFRBN $PINS Q=state[1] QB=n51 J=FE_PHN1537_state_0 K=n458
+ CK=i_clk RB=FE_OFN306_FE_OFN3_FE_DBTN1_i_i_rst
XU157 AOI22S $PINS O=n216 A1=N110 A2=FE_OFN364_FE_OFN79_n15 B1=N353
+ B2=FE_OFN562_n212
XU158 AOI22H $PINS O=n215 A1=R[32] A2=n217 B1=N604 B2=FE_OFN563_n218
XU480 OA112 $PINS O=n107 A1=n108 B1=n109 C1=FE_OFN567_n720 C2=FE_DBTN73_S_30
XU481 AO222 $PINS O=n203 A1=N357 A2=n104 B1=N79 B2=n14 C1=div_in_0[0]
+ C2=FE_DBTN94_n37
XU485 AN3B2S $PINS O=n221 I1=n222 B1=n223 B2=n224
XU486 AO222 $PINS O=n223 A1=div_out[30] A2=FE_OFN363_FE_OFN80_n30
+ B1=div_out[29] B2=FE_OFN483_FE_DBTN90_n36 C1=N667 C2=FE_OFN560_done_div_n
XU487 OR3B2 $PINS O=n225 I1=n226 B1=n227 B2=n228
XU488 AO222S $PINS O=n226 A1=div_out[29] A2=FE_OFN363_FE_OFN80_n30
+ B1=div_out[28] B2=FE_OFN483_FE_DBTN90_n36 C1=N666 C2=FE_OFN560_done_div_n
XU489 AN3B2S $PINS O=n229 I1=n230 B1=n231 B2=n232
XU490 AO222 $PINS O=n231 A1=div_out[28] A2=FE_OFN363_FE_OFN80_n30
+ B1=div_out[27] B2=FE_OFN483_FE_DBTN90_n36 C1=N665 C2=FE_OFN560_done_div_n
XU491 OR3B2 $PINS O=n233 I1=n234 B1=n235 B2=n236
XU492 AO222 $PINS O=n234 A1=div_out[27] A2=FE_OFN363_FE_OFN80_n30
+ B1=div_out[26] B2=FE_OFN483_FE_DBTN90_n36 C1=N664 C2=FE_OFN560_done_div_n
XU493 AN3B2S $PINS O=n237 I1=n238 B1=n239 B2=n240
XU494 AO222 $PINS O=n239 A1=div_out[26] A2=FE_OFN363_FE_OFN80_n30
+ B1=div_out[25] B2=FE_OFN483_FE_DBTN90_n36 C1=N663 C2=FE_OFN560_done_div_n
XU495 OR3B2 $PINS O=n241 I1=n242 B1=n243 B2=n244
XU496 AO222 $PINS O=n242 A1=div_out[25] A2=FE_OFN363_FE_OFN80_n30
+ B1=div_out[24] B2=FE_OFN483_FE_DBTN90_n36 C1=N662 C2=FE_OFN560_done_div_n
XU497 AN3B2S $PINS O=n245 I1=n246 B1=n247 B2=n248
XU498 AO222 $PINS O=n247 A1=div_out[24] A2=FE_OFN363_FE_OFN80_n30
+ B1=div_out[23] B2=FE_OFN483_FE_DBTN90_n36 C1=N661 C2=FE_OFN560_done_div_n
XU499 OR3B2 $PINS O=n249 I1=n250 B1=n251 B2=n252
XU500 AO222 $PINS O=n250 A1=div_out[23] A2=FE_OFN363_FE_OFN80_n30
+ B1=div_out[22] B2=FE_OFN483_FE_DBTN90_n36 C1=N660 C2=FE_OFN560_done_div_n
XU501 AN3B2S $PINS O=n253 I1=n254 B1=n255 B2=n256
XU502 AO222 $PINS O=n255 A1=div_out[22] A2=FE_OFN363_FE_OFN80_n30
+ B1=div_out[21] B2=FE_OFN483_FE_DBTN90_n36 C1=N659 C2=FE_OFN560_done_div_n
XU503 OR3B2 $PINS O=n257 I1=n258 B1=n259 B2=n260
XU504 AO222 $PINS O=n258 A1=div_out[21] A2=FE_OFN363_FE_OFN80_n30
+ B1=div_out[20] B2=FE_OFN483_FE_DBTN90_n36 C1=N658 C2=FE_OFN560_done_div_n
XU505 AN3B2S $PINS O=n261 I1=n262 B1=n263 B2=n264
XU506 AO222 $PINS O=n263 A1=div_out[20] A2=FE_OFN363_FE_OFN80_n30
+ B1=div_out[19] B2=FE_OFN483_FE_DBTN90_n36 C1=N657 C2=FE_OFN560_done_div_n
XU507 OR3B2 $PINS O=n265 I1=n266 B1=n267 B2=n268
XU508 AO222 $PINS O=n266 A1=div_out[19] A2=FE_OFN363_FE_OFN80_n30
+ B1=div_out[18] B2=FE_OFN483_FE_DBTN90_n36 C1=N656 C2=FE_OFN560_done_div_n
XU509 AN3B2S $PINS O=n269 I1=n270 B1=n271 B2=n272
XU510 AO222 $PINS O=n271 A1=div_out[18] A2=FE_OFN363_FE_OFN80_n30
+ B1=div_out[17] B2=FE_OFN483_FE_DBTN90_n36 C1=N655 C2=FE_OFN560_done_div_n
XU511 OR3B2 $PINS O=n273 I1=n274 B1=n275 B2=n276
XU512 AO222 $PINS O=n274 A1=div_out[17] A2=FE_OFN363_FE_OFN80_n30
+ B1=div_out[16] B2=FE_OFN483_FE_DBTN90_n36 C1=N654 C2=FE_OFN560_done_div_n
XU513 AN3B2S $PINS O=n277 I1=n278 B1=n279 B2=n280
XU514 AO222 $PINS O=n279 A1=div_out[16] A2=FE_OFN363_FE_OFN80_n30
+ B1=div_out[15] B2=FE_OFN483_FE_DBTN90_n36 C1=N653 C2=FE_OFN560_done_div_n
XU515 OR3B2 $PINS O=n281 I1=n282 B1=n283 B2=n284
XU516 AO222 $PINS O=n282 A1=div_out[15] A2=FE_OFN363_FE_OFN80_n30
+ B1=div_out[14] B2=FE_OFN483_FE_DBTN90_n36 C1=N652 C2=FE_OFN560_done_div_n
XU517 AN3B2S $PINS O=n285 I1=n286 B1=n287 B2=n288
XU518 AO222 $PINS O=n287 A1=div_out[14] A2=FE_OFN363_FE_OFN80_n30
+ B1=div_out[13] B2=FE_OFN483_FE_DBTN90_n36 C1=N651 C2=FE_OFN560_done_div_n
XU519 OR3B2 $PINS O=n289 I1=n290 B1=n291 B2=n292
XU520 AO222 $PINS O=n290 A1=div_out[13] A2=FE_OFN363_FE_OFN80_n30
+ B1=div_out[12] B2=FE_OFN483_FE_DBTN90_n36 C1=N650 C2=FE_OFN560_done_div_n
XU521 AN3B2S $PINS O=n293 I1=n294 B1=n295 B2=n296
XU522 AO222 $PINS O=n295 A1=div_out[12] A2=n30 B1=div_out[11] B2=FE_DBTN90_n36
+ C1=N649 C2=done_div_n
XU523 OR3B2 $PINS O=n297 I1=n298 B1=n299 B2=n300
XU524 AO222 $PINS O=n298 A1=div_out[11] A2=n30 B1=div_out[10] B2=FE_DBTN90_n36
+ C1=N648 C2=done_div_n
XU525 AN3B2S $PINS O=n301 I1=n302 B1=n303 B2=n304
XU526 AO222 $PINS O=n303 A1=div_out[10] A2=n30 B1=div_out[9] B2=FE_DBTN90_n36
+ C1=N647 C2=done_div_n
XU527 OR3B2 $PINS O=n305 I1=n306 B1=n307 B2=n308
XU528 AO222 $PINS O=n306 A1=div_out[9] A2=n30 B1=div_out[8] B2=FE_DBTN90_n36
+ C1=N646 C2=done_div_n
XU529 AN3B2S $PINS O=n309 I1=n310 B1=n311 B2=n312
XU530 AO222 $PINS O=n311 A1=div_out[8] A2=n30 B1=div_out[7] B2=FE_DBTN90_n36
+ C1=N645 C2=done_div_n
XU531 OR3B2 $PINS O=n313 I1=n314 B1=n315 B2=n316
XU532 AO222 $PINS O=n314 A1=div_out[7] A2=n30 B1=div_out[6] B2=FE_DBTN90_n36
+ C1=N644 C2=done_div_n
XU533 AN3B2S $PINS O=n317 I1=n318 B1=n319 B2=n320
XU534 AO222 $PINS O=n319 A1=div_out[6] A2=n30 B1=FE_OFN99_div_out_5
+ B2=FE_DBTN90_n36 C1=N643 C2=done_div_n
XU535 OR3B2 $PINS O=n321 I1=n322 B1=n323 B2=n324
XU537 AN3B2S $PINS O=n325 I1=n326 B1=n327 B2=n328
XU538 AO222 $PINS O=n327 A1=FE_OFN108_div_out_4 A2=n30 B1=FE_OFN109_div_out_3
+ B2=FE_DBTN90_n36 C1=N641 C2=done_div_n
XU539 OR3B2 $PINS O=n329 I1=n330 B1=n331 B2=n332
XU540 AO222 $PINS O=n330 A1=FE_OFN109_div_out_3 A2=n30 B1=div_out[2]
+ B2=FE_DBTN90_n36 C1=N640 C2=done_div_n
XU541 AN3B2S $PINS O=n333 I1=n334 B1=n335 B2=n336
XU543 AO22 $PINS O=n576 A1=n337 A2=FE_OFN640_n B1=n35 B2=FE_PHN1104_div_out_1
XU544 OR3B2 $PINS O=n337 I1=n338 B1=n339 B2=n340
XU547 AN2B1S $PINS O=n218 I1=FE_OCPN664_div_out_0 B1=n342
XU548 ND2 $PINS O=n341 I1=n343 I2=n344
XU549 ND2 $PINS O=n342 I1=N569 I2=n9
XU550 ND2 $PINS O=n578 I1=FE_PHN1437_n347 I2=n348
XU551 ND2 $PINS O=n579 I1=FE_PHN1423_n350 I2=n351
XU552 ND2 $PINS O=n580 I1=FE_PHN1434_n352 I2=n353
XU553 ND2 $PINS O=n581 I1=n354 I2=n355
XU554 ND2 $PINS O=n582 I1=FE_PHN1404_n356 I2=n357
XU555 ND2 $PINS O=n583 I1=n358 I2=n359
XU556 ND2 $PINS O=n584 I1=n360 I2=n361
XU557 ND2 $PINS O=n585 I1=n362 I2=n363
XU558 ND2 $PINS O=FE_PHN1402_n586 I1=n364 I2=n365
XU559 ND2 $PINS O=n587 I1=n366 I2=n367
XU560 ND2 $PINS O=n588 I1=n372 I2=n373
XU561 ND2 $PINS O=n589 I1=n374 I2=n375
XU562 ND2 $PINS O=n590 I1=n376 I2=n377
XU563 ND2 $PINS O=n591 I1=n378 I2=n379
XU564 ND2 $PINS O=n592 I1=n380 I2=n381
XU565 ND2 $PINS O=n593 I1=n382 I2=n383
XU566 ND2 $PINS O=n594 I1=n384 I2=n385
XU567 ND2 $PINS O=n595 I1=n389 I2=n390
XU568 ND2 $PINS O=n596 I1=n395 I2=n396
XU569 ND2 $PINS O=n597 I1=n398 I2=n399
XU570 ND2 $PINS O=n598 I1=n400 I2=n401
XU571 ND2 $PINS O=n599 I1=n402 I2=n403
XU572 ND2 $PINS O=n600 I1=n404 I2=n405
XU573 ND2 $PINS O=n601 I1=n406 I2=n407
XU574 ND2 $PINS O=n602 I1=n408 I2=n409
XU575 ND2 $PINS O=n603 I1=n410 I2=n411
XU576 ND2 $PINS O=n604 I1=n412 I2=n413
XU577 ND2 $PINS O=n605 I1=n414 I2=n415
XU578 ND2 $PINS O=n606 I1=n416 I2=n417
XU579 ND2 $PINS O=n607 I1=n418 I2=n419
XU580 ND2 $PINS O=n608 I1=n420 I2=n421
XU581 ND2 $PINS O=n609 I1=n422 I2=n423
XU582 ND2 $PINS O=n610 I1=n424 I2=n425
XU583 ND2 $PINS O=n611 I1=n426 I2=n427
XU584 ND2 $PINS O=n612 I1=n428 I2=n429
XU585 ND2 $PINS O=n613 I1=n430 I2=n431
XU586 ND2 $PINS O=n614 I1=n432 I2=n433
XU587 ND2 $PINS O=n615 I1=n434 I2=n435
XU588 ND2 $PINS O=n616 I1=n436 I2=n437
XU589 ND2 $PINS O=n617 I1=n438 I2=n439
XU590 ND2 $PINS O=n618 I1=n440 I2=n441
XU591 ND2 $PINS O=n619 I1=n442 I2=n443
XU592 ND2 $PINS O=n620 I1=n444 I2=n445
XU593 ND2 $PINS O=n621 I1=n446 I2=n447
XU594 ND2 $PINS O=n622 I1=n448 I2=n449
XU595 ND2 $PINS O=n623 I1=n450 I2=n451
XU596 ND2 $PINS O=n624 I1=n452 I2=n453
XU597 ND2P $PINS O=n625 I1=n454 I2=n455
XU598 AO22 $PINS O=n626 A1=n456 A2=FE_PHN1001_i_9 B1=N30 B2=n457
XU599 AO22 $PINS O=n627 A1=n456 A2=i[7] B1=N28 B2=n457
XU600 AO22 $PINS O=n628 A1=n456 A2=i[6] B1=N27 B2=n457
XU601 AO22 $PINS O=n629 A1=n456 A2=i[5] B1=N26 B2=n457
XU602 AO22 $PINS O=n630 A1=n456 A2=FE_PHN1113_N41 B1=N25 B2=n457
XU603 AO22 $PINS O=n631 A1=n456 A2=FE_PHN1108_N40 B1=N24 B2=n457
XU604 AO22 $PINS O=n632 A1=n456 A2=FE_PHN1123_N39 B1=N23 B2=n457
XU605 AO22 $PINS O=n633 A1=n456 A2=FE_PHN1136_N38 B1=N22 B2=n457
XU606 AO22 $PINS O=n634 A1=n456 A2=FE_PHN1138_N37 B1=N21 B2=n457
XU607 AO22 $PINS O=n635 A1=n456 A2=i[8] B1=N29 B2=n457
XU609 AO22 $PINS O=n637 A1=n11 A2=FE_PHN988_V_31 B1=div_in_1[31]
+ B2=FE_OFN634_n371
XU610 ND2 $PINS O=n638 I1=n462 I2=n463
XU611 ND2 $PINS O=n639 I1=n464 I2=n465
XU612 ND2 $PINS O=n640 I1=n466 I2=n467
XU613 ND2 $PINS O=n641 I1=n468 I2=n469
XU614 ND2 $PINS O=n642 I1=n470 I2=n471
XU615 ND2 $PINS O=n643 I1=n472 I2=n473
XU616 ND2 $PINS O=n644 I1=n474 I2=n475
XU617 ND2 $PINS O=n645 I1=n476 I2=n477
XU618 ND2 $PINS O=n646 I1=n478 I2=n479
XU619 ND2 $PINS O=n647 I1=n480 I2=n481
XU620 ND2 $PINS O=n648 I1=n482 I2=n483
XU621 ND2 $PINS O=n649 I1=n484 I2=n485
XU622 ND2 $PINS O=n650 I1=n486 I2=n487
XU623 ND2 $PINS O=n651 I1=n488 I2=n489
XU624 ND2 $PINS O=n652 I1=n490 I2=n491
XU625 ND2 $PINS O=n653 I1=n492 I2=n493
XU626 ND2 $PINS O=n654 I1=n494 I2=n495
XU627 ND2 $PINS O=n655 I1=n496 I2=n497
XU628 ND2 $PINS O=n656 I1=n498 I2=n499
XU629 ND2 $PINS O=n657 I1=n500 I2=n501
XU630 ND2 $PINS O=n658 I1=n502 I2=n503
XU631 ND2 $PINS O=n659 I1=n504 I2=n505
XU632 AO22 $PINS O=n660 A1=n397 A2=FE_PHN756_U_31 B1=prime[31]
+ B2=FE_OFN635_n371
XU633 ND2 $PINS O=n397 I1=n388 I2=n36
XU634 ND2 $PINS O=n661 I1=n506 I2=n507
XU635 OR2B1S $PINS O=n206 I1=FE_OCPN661_V_0 B1=U[0]
XU636 OR3B2 $PINS O=n204 I1=N32 B1=U[0] B2=FE_OCPN661_V_0
XU637 ND2 $PINS O=n387 I1=n388 I2=n508
XU639 ND2 $PINS O=n662 I1=n510 I2=n511
XU640 ND2 $PINS O=n460 I1=N31 I2=n508
Xsub_3447 div_DW01_sub_0 $PINS A[32]=n16 A[31]=FE_OFN274_FE_OFN31_raw_prime_31
+ A[30]=FE_OFN52_raw_prime_30 A[29]=FE_OFN56_raw_prime_29
+ A[28]=FE_OFN262_FE_OFN34_raw_prime_28 A[27]=FE_OFN62_raw_prime_27
+ A[26]=FE_OFN66_raw_prime_26 A[25]=FE_OFN70_raw_prime_25
+ A[24]=FE_OFN245_FE_OFN38_raw_prime_24 A[23]=FE_OFN76_raw_prime_23
+ A[22]=FE_OFN80_raw_prime_22 A[21]=FE_OFN84_raw_prime_21
+ A[20]=FE_OFN233_FE_OFN42_raw_prime_20 A[19]=FE_OFN90_raw_prime_19
+ A[18]=FE_OFN94_raw_prime_18 A[17]=FE_OFN98_raw_prime_17
+ A[16]=FE_OFN102_raw_prime_16 A[15]=FE_OFN326_n A[14]=FE_OFN320_n
+ A[13]=FE_OFN219_FE_OFN49_raw_prime_13 A[12]=FE_OFN115_raw_prime_12
+ A[11]=FE_OFN211_FE_OFN51_raw_prime_11 A[10]=FE_OFN208_FE_OFN52_raw_prime_10
+ A[9]=FE_OFN203_FE_OFN53_raw_prime_9 A[8]=prime[8]
+ A[7]=FE_OFN199_FE_OFN55_raw_prime_7 A[6]=FE_OFN195_FE_OFN56_raw_prime_6
+ A[5]=prime[5] A[4]=FE_OFN319_n A[3]=prime[3] A[2]=prime[2]
+ A[1]=FE_OCPN177_FE_OFN86_n312 A[0]=prime[0] B[32]=R[32]
+ B[31]=FE_DBTN142_div_out_31 B[30]=div_out[30] B[29]=FE_DBTN141_div_out_29
+ B[28]=div_out[28] B[27]=FE_DBTN140_div_out_27 B[26]=div_out[26]
+ B[25]=FE_DBTN139_div_out_25 B[24]=div_out[24] B[23]=FE_DBTN138_div_out_23
+ B[22]=div_out[22] B[21]=FE_DBTN137_div_out_21 B[20]=div_out[20]
+ B[19]=FE_DBTN136_div_out_19 B[18]=div_out[18] B[17]=FE_DBTN135_div_out_17
+ B[16]=div_out[16] B[15]=FE_DBTN134_div_out_15 B[14]=div_out[14]
+ B[13]=FE_DBTN133_div_out_13 B[12]=div_out[12] B[11]=FE_DBTN132_div_out_11
+ B[10]=div_out[10] B[9]=FE_DBTN131_div_out_9 B[8]=div_out[8]
+ B[7]=FE_DBTN130_div_out_7 B[6]=FE_OFN104_div_out_6 B[5]=FE_DBTN129_div_out_5
+ B[4]=FE_OFN108_div_out_4 B[3]=FE_DBTN128_div_out_3 B[2]=div_out[2]
+ B[1]=div_out[1] B[0]=FE_OCPN664_div_out_0 CI=n16 DIFF[32]=N669 DIFF[31]=N668
+ DIFF[30]=N667 DIFF[29]=N666 DIFF[28]=N665 DIFF[27]=N664 DIFF[26]=N663
+ DIFF[25]=N662 DIFF[24]=N661 DIFF[23]=N660 DIFF[22]=N659 DIFF[21]=N658
+ DIFF[20]=N657 DIFF[19]=N656 DIFF[18]=N655 DIFF[17]=N654 DIFF[16]=N653
+ DIFF[15]=N652 DIFF[14]=N651 DIFF[13]=N650 DIFF[12]=N649 DIFF[11]=N648
+ DIFF[10]=N647 DIFF[9]=N646 DIFF[8]=N645 DIFF[7]=N644 DIFF[6]=N643 DIFF[5]=N642
+ DIFF[4]=N641 DIFF[3]=N640 DIFF[2]=N639 DIFF[1]=N638 DIFF[0]=N637
+ FE_OFN255_FE_OFN36_raw_prime_26=FE_OFN254_FE_OFN36_raw_prime_26
Xadd_3440 div_DW01_add_0 $PINS A[32]=R[32] A[31]=div_out[31] A[30]=div_out[30]
+ A[29]=div_out[29] A[28]=div_out[28] A[27]=div_out[27] A[26]=div_out[26]
+ A[25]=div_out[25] A[24]=div_out[24] A[23]=div_out[23] A[22]=div_out[22]
+ A[21]=div_out[21] A[20]=div_out[20] A[19]=div_out[19] A[18]=div_out[18]
+ A[17]=div_out[17] A[16]=div_out[16] A[15]=div_out[15] A[14]=div_out[14]
+ A[13]=div_out[13] A[12]=div_out[12] A[11]=div_out[11] A[10]=div_out[10]
+ A[9]=div_out[9] A[8]=div_out[8] A[7]=div_out[7] A[6]=div_out[6] A[5]=div_out[5]
+ A[4]=FE_OFN108_div_out_4 A[3]=FE_OFN109_div_out_3 A[2]=div_out[2]
+ A[1]=div_out[1] A[0]=FE_OCPN664_div_out_0 B[32]=n16
+ B[31]=FE_OFN274_FE_OFN31_raw_prime_31 B[30]=FE_OFN52_raw_prime_30
+ B[29]=FE_OFN56_raw_prime_29 B[28]=FE_OFN262_FE_OFN34_raw_prime_28
+ B[27]=FE_OFN62_raw_prime_27 B[26]=FE_OFN254_FE_OFN36_raw_prime_26
+ B[25]=FE_OFN70_raw_prime_25 B[24]=prime[24] B[23]=FE_OFN76_raw_prime_23
+ B[22]=FE_OFN80_raw_prime_22 B[21]=FE_OFN84_raw_prime_21
+ B[20]=FE_OFN233_FE_OFN42_raw_prime_20 B[19]=FE_OFN90_raw_prime_19
+ B[18]=FE_OFN94_raw_prime_18 B[17]=FE_OFN98_raw_prime_17
+ B[16]=FE_OFN102_raw_prime_16 B[15]=FE_OFN326_n B[14]=FE_OFN320_n
+ B[13]=FE_OFN219_FE_OFN49_raw_prime_13 B[12]=FE_OFN115_raw_prime_12
+ B[11]=FE_OFN211_FE_OFN51_raw_prime_11 B[10]=FE_OFN208_FE_OFN52_raw_prime_10
+ B[9]=FE_OFN203_FE_OFN53_raw_prime_9 B[8]=prime[8]
+ B[7]=FE_OFN199_FE_OFN55_raw_prime_7 B[6]=FE_OFN195_FE_OFN56_raw_prime_6
+ B[5]=prime[5] B[4]=FE_OFN319_n B[3]=prime[3] B[2]=prime[2]
+ B[1]=FE_OCPN177_FE_OFN86_n312 B[0]=prime[0] CI=n16 SUM[32]=N604 SUM[31]=N603
+ SUM[30]=N602 SUM[29]=N601 SUM[28]=N600 SUM[27]=N599 SUM[26]=N598 SUM[25]=N597
+ SUM[24]=N596 SUM[23]=N595 SUM[22]=N594 SUM[21]=N593 SUM[20]=N592 SUM[19]=N591
+ SUM[18]=N590 SUM[17]=N589 SUM[16]=N588 SUM[15]=N587 SUM[14]=N586 SUM[13]=N585
+ SUM[12]=N584 SUM[11]=N583 SUM[10]=N582 SUM[9]=N581 SUM[8]=N580 SUM[7]=N579
+ SUM[6]=N578 SUM[5]=N577 SUM[4]=N576 SUM[3]=N575 SUM[2]=N574 SUM[1]=N573
+ SUM[0]=SYNOPSYS_UNCONNECTED__0
+ FE_OFN246_FE_OFN38_raw_prime_24=FE_OFN245_FE_OFN38_raw_prime_24
Xsub_3411 div_DW01_sub_1 $PINS A[32]=R[32] A[31]=div_out[31] A[30]=div_out[30]
+ A[29]=div_out[29] A[28]=div_out[28] A[27]=div_out[27] A[26]=div_out[26]
+ A[25]=div_out[25] A[24]=div_out[24] A[23]=div_out[23] A[22]=div_out[22]
+ A[21]=div_out[21] A[20]=div_out[20] A[19]=div_out[19] A[18]=div_out[18]
+ A[17]=div_out[17] A[16]=div_out[16] A[15]=div_out[15] A[14]=div_out[14]
+ A[13]=div_out[13] A[12]=div_out[12] A[11]=div_out[11] A[10]=div_out[10]
+ A[9]=div_out[9] A[8]=div_out[8] A[7]=div_out[7] A[6]=FE_OFN103_div_out_6
+ A[5]=FE_OFN99_div_out_5 A[4]=FE_OFN108_div_out_4 A[3]=FE_OFN109_div_out_3
+ A[2]=div_out[2] A[1]=div_out[1] A[0]=FE_OCPN664_div_out_0 B[32]=n16
+ B[31]=FE_OFN274_FE_OFN31_raw_prime_31 B[30]=FE_OFN52_raw_prime_30
+ B[29]=FE_OFN56_raw_prime_29 B[28]=FE_OFN262_FE_OFN34_raw_prime_28
+ B[27]=FE_OFN62_raw_prime_27 B[26]=FE_OFN254_FE_OFN36_raw_prime_26
+ B[25]=FE_OFN70_raw_prime_25 B[24]=FE_OFN245_FE_OFN38_raw_prime_24
+ B[23]=FE_OFN76_raw_prime_23 B[22]=FE_OFN80_raw_prime_22
+ B[21]=FE_OFN84_raw_prime_21 B[20]=FE_OFN233_FE_OFN42_raw_prime_20
+ B[19]=FE_OFN90_raw_prime_19 B[18]=FE_OFN94_raw_prime_18
+ B[17]=FE_OFN98_raw_prime_17 B[16]=FE_OFN102_raw_prime_16 B[15]=FE_OFN326_n
+ B[14]=FE_OFN320_n B[13]=FE_OFN219_FE_OFN49_raw_prime_13
+ B[12]=FE_OFN115_raw_prime_12 B[11]=FE_OFN211_FE_OFN51_raw_prime_11
+ B[10]=FE_OFN208_FE_OFN52_raw_prime_10 B[9]=FE_OFN203_FE_OFN53_raw_prime_9
+ B[8]=prime[8] B[7]=FE_OFN199_FE_OFN55_raw_prime_7
+ B[6]=FE_OFN195_FE_OFN56_raw_prime_6 B[5]=prime[5] B[4]=FE_OFN319_n
+ B[3]=prime[3] B[2]=FE_OFN163_n B[1]=prime[1] B[0]=prime[0] CI=n16 DIFF[32]=N354
+ DIFF[31]=N353 DIFF[30]=N352 DIFF[29]=N351 DIFF[28]=N350 DIFF[27]=N349
+ DIFF[26]=N348 DIFF[25]=N347 DIFF[24]=N346 DIFF[23]=N345 DIFF[22]=N344
+ DIFF[21]=N343 DIFF[20]=N342 DIFF[19]=N341 DIFF[18]=N340 DIFF[17]=N339
+ DIFF[16]=N338 DIFF[15]=N337 DIFF[14]=N336 DIFF[13]=N335 DIFF[12]=N334
+ DIFF[11]=N333 DIFF[10]=N332 DIFF[9]=N331 DIFF[8]=N330 DIFF[7]=N329 DIFF[6]=N328
+ DIFF[5]=N327 DIFF[4]=N326 DIFF[3]=N325 DIFF[2]=N324 DIFF[1]=N323 DIFF[0]=N322
+ FE_OCPN172_FE_OCPN339_n310=FE_OFN338_n310
Xsub_3396 div_DW01_sub_2 $PINS A[31]=V[31] A[30]=V[30] A[29]=V[29] A[28]=V[28]
+ A[27]=V[27] A[26]=V[26] A[25]=V[25] A[24]=FE_PHN1267_V_24 A[23]=FE_PHN1276_V_23
+ A[22]=FE_PHN1250_V_22 A[21]=FE_PHN1211_V_21 A[20]=V[20] A[19]=V[19] A[18]=V[18]
+ A[17]=V[17] A[16]=FE_PHN1259_V_16 A[15]=FE_PHN1277_V_15 A[14]=V[14] A[13]=V[13]
+ A[12]=V[12] A[11]=FE_PHN1305_V_11 A[10]=FE_PHN1310_V_10 A[9]=FE_PHN1312_V_9
+ A[8]=FE_PHN1322_V_8 A[7]=V[7] A[6]=V[6] A[5]=V[5] A[4]=V[4] A[3]=V[3] A[2]=V[2]
+ A[1]=V[1] A[0]=V[0] B[31]=FE_DBTN93_U_31 B[30]=U[30] B[29]=U[29] B[28]=U[28]
+ B[27]=U[27] B[26]=FE_PHN1260_U_26 B[25]=U[25] B[24]=FE_PHN1244_U_24 B[23]=U[23]
+ B[22]=FE_PHN1258_U_22 B[21]=FE_PHN1246_U_21 B[20]=FE_PHN1233_U_20
+ B[19]=FE_PHN1247_U_19 B[18]=FE_PHN1237_U_18 B[17]=U[17] B[16]=U[16] B[15]=U[15]
+ B[14]=U[14] B[13]=U[13] B[12]=U[12] B[11]=U[11] B[10]=U[10] B[9]=U[9] B[8]=U[8]
+ B[7]=U[7] B[6]=FE_PHN1327_U_6 B[5]=U[5] B[4]=U[4] B[3]=U[3] B[2]=FE_PHN1333_U_2
+ B[1]=U[1] B[0]=U[0] CI=n16 DIFF[31]=N142 DIFF[30]=N141 DIFF[29]=N140
+ DIFF[28]=N139 DIFF[27]=N138 DIFF[26]=N137 DIFF[25]=N136 DIFF[24]=N135
+ DIFF[23]=N134 DIFF[22]=N133 DIFF[21]=N132 DIFF[20]=N131 DIFF[19]=N130
+ DIFF[18]=N129 DIFF[17]=N128 DIFF[16]=N127 DIFF[15]=N126 DIFF[14]=N125
+ DIFF[13]=N124 DIFF[12]=N123 DIFF[11]=N122 DIFF[10]=N121 DIFF[9]=N120
+ DIFF[8]=N119 DIFF[7]=N118 DIFF[6]=N117 DIFF[5]=N116 DIFF[4]=N115 DIFF[3]=N114
+ DIFF[2]=N113 DIFF[1]=N112 DIFF[0]=SYNOPSYS_UNCONNECTED__1
Xsub_3391 div_DW01_sub_3 $PINS A[31]=U[31] A[30]=U[30] A[29]=U[29] A[28]=U[28]
+ A[27]=U[27] A[26]=FE_PHN1260_U_26 A[25]=U[25] A[24]=FE_PHN1244_U_24 A[23]=U[23]
+ A[22]=FE_PHN1258_U_22 A[21]=U[21] A[20]=FE_PHN1233_U_20 A[19]=FE_PHN1247_U_19
+ A[18]=FE_PHN1237_U_18 A[17]=U[17] A[16]=U[16] A[15]=U[15] A[14]=U[14]
+ A[13]=U[13] A[12]=U[12] A[11]=U[11] A[10]=U[10] A[9]=U[9] A[8]=U[8] A[7]=U[7]
+ A[6]=FE_PHN1327_U_6 A[5]=U[5] A[4]=U[4] A[3]=U[3] A[2]=FE_PHN1333_U_2 A[1]=U[1]
+ A[0]=U[0] B[31]=FE_DBTN92_V_31 B[30]=V[30] B[29]=V[29] B[28]=V[28] B[27]=V[27]
+ B[26]=V[26] B[25]=V[25] B[24]=FE_PHN1267_V_24 B[23]=FE_PHN1276_V_23
+ B[22]=FE_PHN1250_V_22 B[21]=V[21] B[20]=V[20] B[19]=V[19] B[18]=V[18]
+ B[17]=V[17] B[16]=FE_PHN1259_V_16 B[15]=FE_PHN1277_V_15 B[14]=V[14] B[13]=V[13]
+ B[12]=V[12] B[11]=FE_PHN1305_V_11 B[10]=FE_PHN1310_V_10 B[9]=FE_PHN1312_V_9
+ B[8]=FE_PHN1322_V_8 B[7]=V[7] B[6]=V[6] B[5]=V[5] B[4]=V[4] B[3]=V[3] B[2]=V[2]
+ B[1]=V[1] B[0]=V[0] CI=n16 DIFF[31]=N78 DIFF[30]=N77 DIFF[29]=N76 DIFF[28]=N75
+ DIFF[27]=N74 DIFF[26]=N73 DIFF[25]=N72 DIFF[24]=N71 DIFF[23]=N70 DIFF[22]=N69
+ DIFF[21]=N68 DIFF[20]=N67 DIFF[19]=N66 DIFF[18]=N65 DIFF[17]=N64 DIFF[16]=N63
+ DIFF[15]=N62 DIFF[14]=N61 DIFF[13]=N60 DIFF[12]=N59 DIFF[11]=N58 DIFF[10]=N57
+ DIFF[9]=N56 DIFF[8]=N55 DIFF[7]=N54 DIFF[6]=N53 DIFF[5]=N52 DIFF[4]=N51
+ DIFF[3]=N50 DIFF[2]=N49 DIFF[1]=N48 DIFF[0]=SYNOPSYS_UNCONNECTED__2
+ p1=FE_PHN1055_U_28 p2=FE_PHN1246_U_21
Xadd_3373 div_DW01_inc_0 $PINS A[9]=FE_PHN1001_i_9 A[8]=i[8] A[7]=i[7]
+ A[6]=i[6] A[5]=i[5] A[4]=FE_PHN1113_N41 A[3]=FE_PHN1108_N40 A[2]=FE_PHN1123_N39
+ A[1]=FE_PHN1136_N38 A[0]=FE_PHN1138_N37 SUM[9]=N30 SUM[8]=N29 SUM[7]=N28
+ SUM[6]=N27 SUM[5]=N26 SUM[4]=N25 SUM[3]=N24 SUM[2]=N23 SUM[1]=N22 SUM[0]=N21
Xr354 div_DW01_sub_5 $PINS A[32]=S[32] A[31]=S[31] A[30]=S[30] A[29]=S[29]
+ A[28]=S[28] A[27]=S[27] A[26]=S[26] A[25]=S[25] A[24]=S[24] A[23]=S[23]
+ A[22]=S[22] A[21]=S[21] A[20]=S[20] A[19]=S[19] A[18]=S[18] A[17]=S[17]
+ A[16]=S[16] A[15]=S[15] A[14]=S[14] A[13]=S[13] A[12]=S[12] A[11]=S[11]
+ A[10]=S[10] A[9]=S[9] A[8]=S[8] A[7]=S[7] A[6]=S[6] A[5]=S[5] A[4]=S[4]
+ A[3]=S[3] A[2]=S[2] A[1]=S[1] A[0]=S[0] B[32]=n16
+ B[31]=FE_OFN274_FE_OFN31_raw_prime_31 B[30]=FE_OFN52_raw_prime_30
+ B[29]=FE_OFN56_raw_prime_29 B[28]=FE_OFN262_FE_OFN34_raw_prime_28
+ B[27]=FE_OFN62_raw_prime_27 B[26]=FE_OFN254_FE_OFN36_raw_prime_26
+ B[25]=FE_OFN70_raw_prime_25 B[24]=FE_OFN245_FE_OFN38_raw_prime_24
+ B[23]=FE_OFN76_raw_prime_23 B[22]=FE_OFN80_raw_prime_22
+ B[21]=FE_OFN84_raw_prime_21 B[20]=FE_OFN233_FE_OFN42_raw_prime_20
+ B[19]=FE_OFN90_raw_prime_19 B[18]=FE_OFN94_raw_prime_18
+ B[17]=FE_OFN98_raw_prime_17 B[16]=FE_OFN102_raw_prime_16 B[15]=FE_OFN326_n
+ B[14]=FE_OFN320_n B[13]=FE_OFN219_FE_OFN49_raw_prime_13
+ B[12]=FE_OFN115_raw_prime_12 B[11]=FE_OFN211_FE_OFN51_raw_prime_11
+ B[10]=FE_OFN208_FE_OFN52_raw_prime_10 B[9]=FE_OFN203_FE_OFN53_raw_prime_9
+ B[8]=prime[8] B[7]=FE_OFN199_FE_OFN55_raw_prime_7
+ B[6]=FE_OFN195_FE_OFN56_raw_prime_6 B[5]=prime[5] B[4]=FE_OFN319_n
+ B[3]=prime[3] B[2]=FE_OFN163_n B[1]=prime[1] B[0]=prime[0] CI=n16 DIFF[32]=N389
+ DIFF[31]=N388 DIFF[30]=N387 DIFF[29]=N386 DIFF[28]=N385 DIFF[27]=N384
+ DIFF[26]=N383 DIFF[25]=N382 DIFF[24]=N381 DIFF[23]=N380 DIFF[22]=N379
+ DIFF[21]=N378 DIFF[20]=N377 DIFF[19]=N376 DIFF[18]=N375 DIFF[17]=N374
+ DIFF[16]=N373 DIFF[15]=N372 DIFF[14]=N371 DIFF[13]=N370 DIFF[12]=N369
+ DIFF[11]=N368 DIFF[10]=N367 DIFF[9]=N366 DIFF[8]=N365 DIFF[7]=N364 DIFF[6]=N363
+ DIFF[5]=N362 DIFF[4]=N361 DIFF[3]=N360 DIFF[2]=N359 DIFF[1]=N358 DIFF[0]=N357
+ p1=FE_DBTN89_S_0 FE_DBTN85_S_6=FE_DBTN85_S_6
+ FE_OCPN173_FE_OCPN339_n310=FE_OFN338_n310
Xr353 div_DW_cmp_1 $PINS A[32]=S[32] A[31]=S[31] A[30]=FE_DBTN73_S_30
+ A[29]=S[29] A[28]=FE_DBTN74_S_28 A[27]=S[27] A[26]=FE_DBTN75_S_26 A[25]=S[25]
+ A[24]=FE_DBTN76_S_24 A[23]=S[23] A[22]=FE_DBTN77_S_22 A[21]=S[21]
+ A[20]=FE_DBTN78_S_20 A[19]=S[19] A[18]=FE_DBTN79_S_18 A[17]=S[17]
+ A[16]=FE_DBTN80_S_16 A[15]=S[15] A[14]=FE_DBTN81_S_14 A[13]=S[13]
+ A[12]=FE_DBTN82_S_12 A[11]=S[11] A[10]=FE_DBTN83_S_10 A[9]=S[9]
+ A[8]=FE_DBTN84_S_8 A[7]=S[7] A[6]=FE_DBTN85_S_6 A[5]=S[5] A[4]=FE_DBTN86_S_4
+ A[3]=S[3] A[2]=FE_DBTN87_S_2 A[1]=FE_DBTN88_S_1 A[0]=S[0] B[32]=n16
+ B[31]=FE_OFN274_FE_OFN31_raw_prime_31 B[30]=FE_OFN52_raw_prime_30
+ B[29]=FE_OFN56_raw_prime_29 B[28]=FE_OFN262_FE_OFN34_raw_prime_28
+ B[27]=FE_OFN62_raw_prime_27 B[26]=FE_OFN254_FE_OFN36_raw_prime_26
+ B[25]=FE_OFN70_raw_prime_25 B[24]=FE_OFN245_FE_OFN38_raw_prime_24
+ B[23]=FE_OFN76_raw_prime_23 B[22]=FE_OFN80_raw_prime_22
+ B[21]=FE_OFN84_raw_prime_21 B[20]=FE_OFN233_FE_OFN42_raw_prime_20
+ B[19]=FE_OFN90_raw_prime_19 B[18]=FE_OFN94_raw_prime_18
+ B[17]=FE_OFN98_raw_prime_17 B[16]=FE_OFN102_raw_prime_16 B[15]=FE_OFN326_n
+ B[14]=FE_OFN320_n B[13]=FE_OFN219_FE_OFN49_raw_prime_13
+ B[12]=FE_OFN115_raw_prime_12 B[11]=FE_OFN211_FE_OFN51_raw_prime_11
+ B[10]=FE_OFN208_FE_OFN52_raw_prime_10 B[9]=FE_OFN203_FE_OFN53_raw_prime_9
+ B[8]=prime[8] B[7]=FE_OFN199_FE_OFN55_raw_prime_7
+ B[6]=FE_OFN195_FE_OFN56_raw_prime_6 B[5]=prime[5] B[4]=FE_OFN319_n
+ B[3]=prime[3] B[2]=prime[2] B[1]=FE_OCPN350_FE_OCPN344_FE_OFN86_n312
+ B[0]=FE_OFN338_n310 TC=n16 GE_LT=n17 GE_GT_EQ=n17 GE_LT_GT_LE=N355
Xgte_3410 div_DW_cmp_2 $PINS A[32]=R[32] A[31]=div_out[31] A[30]=div_out[30]
+ A[29]=div_out[29] A[28]=div_out[28] A[27]=div_out[27] A[26]=div_out[26]
+ A[25]=div_out[25] A[24]=div_out[24] A[23]=div_out[23] A[22]=div_out[22]
+ A[21]=div_out[21] A[20]=div_out[20] A[19]=div_out[19] A[18]=div_out[18]
+ A[17]=div_out[17] A[16]=div_out[16] A[15]=div_out[15] A[14]=div_out[14]
+ A[13]=div_out[13] A[12]=div_out[12] A[11]=div_out[11] A[10]=div_out[10]
+ A[9]=div_out[9] A[8]=div_out[8] A[7]=div_out[7] A[6]=div_out[6] A[5]=div_out[5]
+ A[4]=div_out[4] A[3]=div_out[3] A[2]=div_out[2] A[1]=div_out[1] A[0]=div_out[0]
+ B[32]=n16 B[31]=FE_OFN274_FE_OFN31_raw_prime_31 B[30]=FE_OFN52_raw_prime_30
+ B[29]=FE_OFN56_raw_prime_29 B[28]=FE_OFN262_FE_OFN34_raw_prime_28
+ B[27]=FE_OFN62_raw_prime_27 B[26]=FE_OFN254_FE_OFN36_raw_prime_26
+ B[25]=FE_OFN70_raw_prime_25 B[24]=FE_OFN245_FE_OFN38_raw_prime_24
+ B[23]=FE_OFN76_raw_prime_23 B[22]=FE_OFN80_raw_prime_22
+ B[21]=FE_OFN84_raw_prime_21 B[20]=FE_OFN233_FE_OFN42_raw_prime_20
+ B[19]=FE_OFN90_raw_prime_19 B[18]=FE_OFN94_raw_prime_18
+ B[17]=FE_OFN98_raw_prime_17 B[16]=FE_OFN102_raw_prime_16 B[15]=FE_OFN326_n
+ B[14]=FE_OFN320_n B[13]=FE_OFN219_FE_OFN49_raw_prime_13
+ B[12]=FE_OFN115_raw_prime_12 B[11]=FE_OFN211_FE_OFN51_raw_prime_11
+ B[10]=FE_OFN208_FE_OFN52_raw_prime_10 B[9]=FE_OFN203_FE_OFN53_raw_prime_9
+ B[8]=prime[8] B[7]=FE_OFN199_FE_OFN55_raw_prime_7
+ B[6]=FE_OFN195_FE_OFN56_raw_prime_6 B[5]=prime[5] B[4]=FE_OFN319_n
+ B[3]=prime[3] B[2]=prime[2] B[1]=FE_OCPN177_FE_OFN86_n312 B[0]=FE_OFN338_n310
+ TC=n16 GE_LT=n17 GE_GT_EQ=n17 GE_LT_GT_LE=N319
+ FE_OCPN351_FE_OCPN344_FE_OFN86_n312=FE_OCPN350_FE_OCPN344_FE_OFN86_n312
Xr349 div_DW01_add_1 $PINS A[32]=R[32] A[31]=div_out[31] A[30]=div_out[30]
+ A[29]=div_out[29] A[28]=div_out[28] A[27]=div_out[27] A[26]=div_out[26]
+ A[25]=div_out[25] A[24]=div_out[24] A[23]=div_out[23] A[22]=div_out[22]
+ A[21]=div_out[21] A[20]=div_out[20] A[19]=div_out[19] A[18]=div_out[18]
+ A[17]=div_out[17] A[16]=div_out[16] A[15]=div_out[15] A[14]=div_out[14]
+ A[13]=div_out[13] A[12]=div_out[12] A[11]=div_out[11] A[10]=div_out[10]
+ A[9]=div_out[9] A[8]=div_out[8] A[7]=div_out[7] A[6]=div_out[6] A[5]=div_out[5]
+ A[4]=FE_OFN108_div_out_4 A[3]=div_out[3] A[2]=div_out[2] A[1]=div_out[1]
+ A[0]=FE_OCPN664_div_out_0 B[32]=S[32] B[31]=S[31] B[30]=S[30] B[29]=S[29]
+ B[28]=S[28] B[27]=S[27] B[26]=S[26] B[25]=S[25] B[24]=S[24] B[23]=S[23]
+ B[22]=S[22] B[21]=S[21] B[20]=S[20] B[19]=S[19] B[18]=S[18] B[17]=S[17]
+ B[16]=S[16] B[15]=S[15] B[14]=S[14] B[13]=S[13] B[12]=S[12] B[11]=S[11]
+ B[10]=S[10] B[9]=S[9] B[8]=S[8] B[7]=S[7] B[6]=S[6] B[5]=S[5] B[4]=S[4]
+ B[3]=S[3] B[2]=S[2] B[1]=S[1] B[0]=S[0] CI=n16 SUM[32]=N111 SUM[31]=N110
+ SUM[30]=N109 SUM[29]=N108 SUM[28]=N107 SUM[27]=N106 SUM[26]=N105 SUM[25]=N104
+ SUM[24]=N103 SUM[23]=N102 SUM[22]=N101 SUM[21]=N100 SUM[20]=N99 SUM[19]=N98
+ SUM[18]=N97 SUM[17]=N96 SUM[16]=N95 SUM[15]=N94 SUM[14]=N93 SUM[13]=N92
+ SUM[12]=N91 SUM[11]=N90 SUM[10]=N89 SUM[9]=N88 SUM[8]=N87 SUM[7]=N86 SUM[6]=N85
+ SUM[5]=N84 SUM[4]=N83 SUM[3]=N82 SUM[2]=N81 SUM[1]=N80 SUM[0]=N79
+ FE_DBTN84_S_8=FE_DBTN84_S_8
Xgt_3390 div_DW_cmp_4 $PINS A[31]=FE_DBTN93_U_31 A[30]=U[30] A[29]=U[29]
+ A[28]=U[28] A[27]=U[27] A[26]=FE_PHN1260_U_26 A[25]=U[25] A[24]=FE_PHN1244_U_24
+ A[23]=U[23] A[22]=FE_PHN1258_U_22 A[21]=FE_PHN1246_U_21 A[20]=U[20]
+ A[19]=FE_PHN1247_U_19 A[18]=FE_PHN1237_U_18 A[17]=U[17] A[16]=U[16] A[15]=U[15]
+ A[14]=U[14] A[13]=U[13] A[12]=U[12] A[11]=U[11] A[10]=U[10] A[9]=U[9] A[8]=U[8]
+ A[7]=U[7] A[6]=FE_PHN1327_U_6 A[5]=U[5] A[4]=U[4] A[3]=U[3] A[2]=FE_PHN1333_U_2
+ A[1]=U[1] A[0]=U[0] B[31]=V[31] B[30]=V[30] B[29]=V[29] B[28]=V[28] B[27]=V[27]
+ B[26]=V[26] B[25]=V[25] B[24]=FE_PHN1267_V_24 B[23]=FE_PHN1276_V_23
+ B[22]=FE_PHN1250_V_22 B[21]=V[21] B[20]=V[20] B[19]=V[19] B[18]=V[18]
+ B[17]=V[17] B[16]=FE_PHN1259_V_16 B[15]=FE_PHN1277_V_15 B[14]=V[14] B[13]=V[13]
+ B[12]=V[12] B[11]=FE_PHN1305_V_11 B[10]=FE_PHN1310_V_10 B[9]=FE_PHN1312_V_9
+ B[8]=FE_PHN1322_V_8 B[7]=V[7] B[6]=V[6] B[5]=V[5] B[4]=V[4] B[3]=V[3] B[2]=V[2]
+ B[1]=V[1] B[0]=FE_OCPN661_V_0 TC=n16 GE_LT=n16 GE_GT_EQ=n17 GE_LT_GT_LE=N32
+ p1=FE_PHN1233_U_20
XR_reg[31] QDFFRBN $PINS Q=div_out[31] D=n546 CK=i_clk_clone5
+ RB=FE_OFN0_FE_DBTN1_i_i_rst
Xi_reg[9] QDFFRBN $PINS Q=i[9] D=n626 CK=i_clk RB=FE_OFN2_FE_DBTN1_i_i_rst
Xi_reg[3] QDFFRBN $PINS Q=N40 D=n631 CK=i_clk
+ RB=FE_OFN474_FE_OFN3_FE_DBTN1_i_i_rst
Xi_reg[4] QDFFRBN $PINS Q=N41 D=n630 CK=i_clk
+ RB=FE_OFN474_FE_OFN3_FE_DBTN1_i_i_rst
Xi_reg[8] QDFFRBN $PINS Q=FE_PHN1151_i_8 D=n635 CK=i_clk
+ RB=FE_OFN2_FE_DBTN1_i_i_rst
Xi_reg[6] QDFFRBN $PINS Q=FE_PHN1160_i_6 D=n628 CK=i_clk
+ RB=FE_OFN2_FE_DBTN1_i_i_rst
Xi_reg[7] QDFFRBN $PINS Q=FE_PHN1155_i_7 D=n627 CK=i_clk
+ RB=FE_OFN2_FE_DBTN1_i_i_rst
Xi_reg[5] QDFFRBN $PINS Q=FE_PHN1176_i_5 D=n629 CK=i_clk
+ RB=FE_OFN474_FE_OFN3_FE_DBTN1_i_i_rst
Xloop_num_reg[9] QDFFRBN $PINS Q=loop_num[9] D=n578 CK=i_clk
+ RB=FE_OFN312_FE_OFN1_FE_DBTN1_i_i_rst
Xloop_num_reg[3] QDFFRBN $PINS Q=loop_num[3] D=FE_PHN1413_n584 CK=i_clk
+ RB=FE_OFN306_FE_OFN3_FE_DBTN1_i_i_rst
Xloop_num_reg[6] QDFFRBN $PINS Q=loop_num[6] D=n581 CK=i_clk
+ RB=FE_OFN312_FE_OFN1_FE_DBTN1_i_i_rst
Xloop_num_reg[4] QDFFRBN $PINS Q=loop_num[4] D=FE_PHN1419_n583 CK=i_clk
+ RB=FE_OFN2_FE_DBTN1_i_i_rst
Xloop_num_reg[2] QDFFRBN $PINS Q=loop_num[2] D=FE_PHN1411_n585 CK=i_clk
+ RB=FE_OFN306_FE_OFN3_FE_DBTN1_i_i_rst
Xloop_num_reg[7] QDFFRBN $PINS Q=loop_num[7] D=n580 CK=i_clk
+ RB=FE_OFN312_FE_OFN1_FE_DBTN1_i_i_rst
Xloop_num_reg[5] QDFFRBN $PINS Q=loop_num[5] D=n582 CK=i_clk
+ RB=FE_OFN312_FE_OFN1_FE_DBTN1_i_i_rst
Xloop_num_reg[8] QDFFRBN $PINS Q=loop_num[8] D=n579 CK=i_clk
+ RB=FE_OFN312_FE_OFN1_FE_DBTN1_i_i_rst
Xi_reg[1] QDFFRBN $PINS Q=N38 D=n633 CK=i_clk
+ RB=FE_OFN474_FE_OFN3_FE_DBTN1_i_i_rst
Xi_reg[2] QDFFRBN $PINS Q=N39 D=n632 CK=i_clk
+ RB=FE_OFN474_FE_OFN3_FE_DBTN1_i_i_rst
Xi_reg[0] QDFFRBN $PINS Q=N37 D=n634 CK=i_clk
+ RB=FE_OFN474_FE_OFN3_FE_DBTN1_i_i_rst
XS_reg[28] QDFFRBN $PINS Q=S[28] D=n516 CK=i_clk_clone5
+ RB=FE_OFN309_FE_OFN2_FE_DBTN1_i_i_rst
Xdone_div_reg QDFFRBN $PINS Q=done_div D=done_div_n CK=i_clk
+ RB=FE_OFN307_FE_OFN3_FE_DBTN1_i_i_rst
XR_reg[24] QDFFRBN $PINS Q=div_out[24] D=n553 CK=i_clk_clone5
+ RB=FE_OFN309_FE_OFN2_FE_DBTN1_i_i_rst
XR_reg[26] QDFFRBN $PINS Q=div_out[26] D=n551 CK=i_clk_clone5
+ RB=FE_OFN309_FE_OFN2_FE_DBTN1_i_i_rst
XR_reg[28] QDFFRBN $PINS Q=div_out[28] D=n549 CK=i_clk_clone5
+ RB=FE_OFN309_FE_OFN2_FE_DBTN1_i_i_rst
XR_reg[30] QDFFRBN $PINS Q=div_out[30] D=n547 CK=i_clk_clone5
+ RB=FE_OFN0_FE_DBTN1_i_i_rst
Xloop_num_reg[1] QDFFRBN $PINS Q=loop_num[1] D=n586 CK=i_clk
+ RB=FE_OFN306_FE_OFN3_FE_DBTN1_i_i_rst
Xloop_num_reg[0] QDFFRBN $PINS Q=loop_num[0] D=FE_PHN1429_n662 CK=i_clk
+ RB=FE_OFN306_FE_OFN3_FE_DBTN1_i_i_rst
Xstate_reg[0] QDFFRBN $PINS Q=state[0] D=n636 CK=i_clk
+ RB=FE_OFN306_FE_OFN3_FE_DBTN1_i_i_rst
XU_reg[31] QDFFRBN $PINS Q=U[31] D=n660 CK=i_clk_clone2
+ RB=FE_OFN307_FE_OFN3_FE_DBTN1_i_i_rst
XU_reg[29] QDFFRBN $PINS Q=FE_PHN1253_U_29 D=n624 CK=i_clk_clone2
+ RB=FE_OFN9_FE_DBTN1_i_i_rst
XU_reg[27] QDFFRBN $PINS Q=U[27] D=n622 CK=i_clk_clone3
+ RB=FE_OFN303_FE_OFN5_FE_DBTN1_i_i_rst
XU_reg[25] QDFFRBN $PINS Q=FE_PHN1254_U_25 D=n620 CK=i_clk_clone3
+ RB=FE_OFN303_FE_OFN5_FE_DBTN1_i_i_rst
XS_reg[24] QDFFRBN $PINS Q=S[24] D=n520 CK=i_clk_clone5
+ RB=FE_OFN309_FE_OFN2_FE_DBTN1_i_i_rst
XS_reg[26] QDFFRBN $PINS Q=S[26] D=n518 CK=i_clk_clone5
+ RB=FE_OFN309_FE_OFN2_FE_DBTN1_i_i_rst
XS_reg[25] QDFFRBN $PINS Q=S[25] D=n519 CK=i_clk_clone5
+ RB=FE_OFN309_FE_OFN2_FE_DBTN1_i_i_rst
XS_reg[27] QDFFRBN $PINS Q=S[27] D=n517 CK=i_clk_clone5
+ RB=FE_OFN309_FE_OFN2_FE_DBTN1_i_i_rst
XS_reg[23] QDFFRBN $PINS Q=S[23] D=n521 CK=i_clk_clone5
+ RB=FE_OFN309_FE_OFN2_FE_DBTN1_i_i_rst
XU_reg[30] QDFFRBN $PINS Q=U[30] D=n625 CK=i_clk_clone2
+ RB=FE_OFN307_FE_OFN3_FE_DBTN1_i_i_rst
XR_reg[25] QDFFRBN $PINS Q=div_out[25] D=n552 CK=i_clk_clone5
+ RB=FE_OFN309_FE_OFN2_FE_DBTN1_i_i_rst
XR_reg[27] QDFFRBN $PINS Q=div_out[27] D=n550 CK=i_clk_clone5
+ RB=FE_OFN309_FE_OFN2_FE_DBTN1_i_i_rst
XR_reg[20] QDFFRBN $PINS Q=div_out[20] D=n557 CK=i_clk_clone5
+ RB=FE_OFN308_FE_OFN2_FE_DBTN1_i_i_rst
XR_reg[22] QDFFRBN $PINS Q=div_out[22] D=n555 CK=i_clk_clone5
+ RB=FE_OFN308_FE_OFN2_FE_DBTN1_i_i_rst
XU_reg[21] QDFFRBN $PINS Q=U[21] D=n616 CK=i_clk_clone3
+ RB=FE_OFN39_FE_DBTN1_i_i_rst
XU_reg[19] QDFFRBN $PINS Q=U[19] D=n614 CK=i_clk_clone4
+ RB=FE_OFN5_FE_DBTN1_i_i_rst
XS_reg[20] QDFFRBN $PINS Q=S[20] D=n524 CK=i_clk_clone1
+ RB=FE_OFN0_FE_DBTN1_i_i_rst
XS_reg[22] QDFFRBN $PINS Q=S[22] D=n522 CK=i_clk_clone5
+ RB=FE_OFN309_FE_OFN2_FE_DBTN1_i_i_rst
XU_reg[20] QDFFRBN $PINS Q=U[20] D=n615 CK=i_clk_clone4
+ RB=FE_OFN5_FE_DBTN1_i_i_rst
XS_reg[21] QDFFRBN $PINS Q=S[21] D=n523 CK=i_clk_clone5
+ RB=FE_OFN309_FE_OFN2_FE_DBTN1_i_i_rst
XV_reg[31] QDFFRBN $PINS Q=V[31] D=n637 CK=i_clk_clone2
+ RB=FE_OFN9_FE_DBTN1_i_i_rst
XV_reg[22] QDFFRBN $PINS Q=V[22] D=n638 CK=i_clk_clone3
+ RB=FE_OFN39_FE_DBTN1_i_i_rst
XV_reg[20] QDFFRBN $PINS Q=FE_PHN1245_V_20 D=n640 CK=i_clk_clone3
+ RB=FE_OFN303_FE_OFN5_FE_DBTN1_i_i_rst
XV_reg[26] QDFFRBN $PINS Q=V[26] D=n590 CK=i_clk_clone2
+ RB=FE_OFN303_FE_OFN5_FE_DBTN1_i_i_rst
XV_reg[24] QDFFRBN $PINS Q=V[24] D=n588 CK=i_clk_clone2
+ RB=FE_OFN303_FE_OFN5_FE_DBTN1_i_i_rst
XV_reg[28] QDFFRBN $PINS Q=V[28] D=n592 CK=i_clk_clone2
+ RB=FE_OFN9_FE_DBTN1_i_i_rst
XV_reg[30] QDFFRBN $PINS Q=FE_PHN1268_V_30 D=n594 CK=i_clk_clone2
+ RB=FE_OFN9_FE_DBTN1_i_i_rst
XV_reg[21] QDFFRBN $PINS Q=V[21] D=n639 CK=i_clk_clone3
+ RB=FE_OFN39_FE_DBTN1_i_i_rst
XV_reg[19] QDFFRBN $PINS Q=FE_PHN1263_V_19 D=n641 CK=i_clk_clone2
+ RB=FE_OFN303_FE_OFN5_FE_DBTN1_i_i_rst
XV_reg[23] QDFFRBN $PINS Q=V[23] D=n587 CK=i_clk_clone2
+ RB=FE_OFN303_FE_OFN5_FE_DBTN1_i_i_rst
XR_reg[23] QDFFRBN $PINS Q=div_out[23] D=n554 CK=i_clk_clone5
+ RB=FE_OFN308_FE_OFN2_FE_DBTN1_i_i_rst
XR_reg[21] QDFFRBN $PINS Q=div_out[21] D=n556 CK=i_clk_clone5
+ RB=FE_OFN308_FE_OFN2_FE_DBTN1_i_i_rst
XR_reg[18] QDFFRBN $PINS Q=div_out[18] D=n559 CK=i_clk_clone1
+ RB=FE_OFN0_FE_DBTN1_i_i_rst
XU_reg[17] QDFFRBN $PINS Q=FE_PHN1224_U_17 D=n612 CK=i_clk_clone4
+ RB=FE_OFN5_FE_DBTN1_i_i_rst
XS_reg[18] QDFFRBN $PINS Q=S[18] D=n526 CK=i_clk_clone1
+ RB=FE_OFN308_FE_OFN2_FE_DBTN1_i_i_rst
XU_reg[18] QDFFRBN $PINS Q=U[18] D=n613 CK=i_clk_clone4
+ RB=FE_OFN5_FE_DBTN1_i_i_rst
XS_reg[19] QDFFRBN $PINS Q=S[19] D=n525 CK=i_clk_clone1
+ RB=FE_OFN308_FE_OFN2_FE_DBTN1_i_i_rst
XS_reg[17] QDFFRBN $PINS Q=S[17] D=n527 CK=i_clk_clone1
+ RB=FE_OFN308_FE_OFN2_FE_DBTN1_i_i_rst
XV_reg[18] QDFFRBN $PINS Q=FE_PHN1248_V_18 D=n642 CK=i_clk_clone2
+ RB=FE_OFN9_FE_DBTN1_i_i_rst
XR_reg[19] QDFFRBN $PINS Q=div_out[19] D=n558 CK=i_clk_clone1
+ RB=FE_OFN308_FE_OFN2_FE_DBTN1_i_i_rst
XR_reg[17] QDFFRBN $PINS Q=div_out[17] D=n560 CK=i_clk_clone1
+ RB=FE_OFN0_FE_DBTN1_i_i_rst
XR_reg[14] QDFFRBN $PINS Q=div_out[14] D=n563 CK=i_clk_clone1
+ RB=FE_OFN312_FE_OFN1_FE_DBTN1_i_i_rst
XR_reg[16] QDFFRBN $PINS Q=div_out[16] D=n561 CK=i_clk_clone1
+ RB=FE_OFN0_FE_DBTN1_i_i_rst
XS_reg[14] QDFFRBN $PINS Q=S[14] D=n530 CK=i_clk_clone1
+ RB=FE_OFN313_FE_OFN1_FE_DBTN1_i_i_rst
XS_reg[16] QDFFRBN $PINS Q=S[16] D=n528 CK=i_clk_clone1
+ RB=FE_OFN0_FE_DBTN1_i_i_rst
XS_reg[15] QDFFRBN $PINS Q=S[15] D=n529 CK=i_clk_clone1
+ RB=FE_OFN0_FE_DBTN1_i_i_rst
XS_reg[13] QDFFRBN $PINS Q=S[13] D=n531 CK=i_clk_clone1
+ RB=FE_OFN313_FE_OFN1_FE_DBTN1_i_i_rst
XR_reg[15] QDFFRBN $PINS Q=div_out[15] D=n562 CK=i_clk_clone1
+ RB=FE_OFN312_FE_OFN1_FE_DBTN1_i_i_rst
XR_reg[13] QDFFRBN $PINS Q=div_out[13] D=n564 CK=i_clk_clone1
+ RB=FE_OFN312_FE_OFN1_FE_DBTN1_i_i_rst
XR_reg[10] QDFFRBN $PINS Q=div_out[10] D=n567 CK=i_clk_clone1
+ RB=FE_OFN312_FE_OFN1_FE_DBTN1_i_i_rst
XR_reg[12] QDFFRBN $PINS Q=div_out[12] D=n565 CK=i_clk_clone1 RB=i_rst
XU_reg[9] QDFFRBN $PINS Q=FE_PHN1298_U_9 D=n604 CK=i_clk_clone4
+ RB=FE_OFN474_FE_OFN3_FE_DBTN1_i_i_rst
XS_reg[10] QDFFRBN $PINS Q=S[10] D=n534 CK=i_clk_clone1
+ RB=FE_OFN313_FE_OFN1_FE_DBTN1_i_i_rst
XS_reg[12] QDFFRBN $PINS Q=S[12] D=n532 CK=i_clk_clone1
+ RB=FE_OFN313_FE_OFN1_FE_DBTN1_i_i_rst
XU_reg[10] QDFFRBN $PINS Q=FE_PHN1308_U_10 D=n605 CK=i_clk_clone4
+ RB=FE_OFN474_FE_OFN3_FE_DBTN1_i_i_rst
XS_reg[11] QDFFRBN $PINS Q=S[11] D=n533 CK=i_clk_clone1
+ RB=FE_OFN313_FE_OFN1_FE_DBTN1_i_i_rst
XR_reg[11] QDFFRBN $PINS Q=div_out[11] D=n566 CK=i_clk_clone1
+ RB=FE_OFN312_FE_OFN1_FE_DBTN1_i_i_rst
XR_reg[8] QDFFRBN $PINS Q=div_out[8] D=n569 CK=i_clk_clone1
+ RB=FE_OFN312_FE_OFN1_FE_DBTN1_i_i_rst
XU_reg[7] QDFFRBN $PINS Q=FE_PHN1326_U_7 D=n602 CK=i_clk_clone4
+ RB=FE_OFN474_FE_OFN3_FE_DBTN1_i_i_rst
XS_reg[6] QDFFRBN $PINS Q=S[6] D=n538 CK=i_clk_clone1
+ RB=FE_OFN313_FE_OFN1_FE_DBTN1_i_i_rst
XS_reg[8] QDFFRBN $PINS Q=S[8] D=n536 CK=i_clk_clone1
+ RB=FE_OFN313_FE_OFN1_FE_DBTN1_i_i_rst
XS_reg[7] QDFFRBN $PINS Q=S[7] D=n537 CK=i_clk_clone1
+ RB=FE_OFN313_FE_OFN1_FE_DBTN1_i_i_rst
XS_reg[9] QDFFRBN $PINS Q=S[9] D=n535 CK=i_clk_clone1
+ RB=FE_OFN313_FE_OFN1_FE_DBTN1_i_i_rst
XR_reg[7] QDFFRBN $PINS Q=div_out[7] D=n570 CK=i_clk_clone1
+ RB=FE_OFN312_FE_OFN1_FE_DBTN1_i_i_rst
XR_reg[9] QDFFRBN $PINS Q=div_out[9] D=n568 CK=i_clk_clone1
+ RB=FE_OFN312_FE_OFN1_FE_DBTN1_i_i_rst
XR_reg[4] QDFFRBP $PINS Q=FE_OFN108_div_out_4 D=n573 CK=i_clk
+ RB=FE_OFN312_FE_OFN1_FE_DBTN1_i_i_rst
XR_reg[6] QDFFRBN $PINS Q=FE_OFN103_div_out_6 D=n571 CK=i_clk_clone1
+ RB=FE_OFN312_FE_OFN1_FE_DBTN1_i_i_rst
XS_reg[4] QDFFRBN $PINS Q=S[4] D=n540 CK=i_clk
+ RB=FE_OFN313_FE_OFN1_FE_DBTN1_i_i_rst
XS_reg[2] QDFFRBN $PINS Q=S[2] D=n542 CK=i_clk
+ RB=FE_OFN313_FE_OFN1_FE_DBTN1_i_i_rst
XS_reg[5] QDFFRBN $PINS Q=S[5] D=n539 CK=i_clk
+ RB=FE_OFN313_FE_OFN1_FE_DBTN1_i_i_rst
XR_reg[5] QDFFRBP $PINS Q=FE_OFN99_div_out_5 D=n572 CK=i_clk_clone1
+ RB=FE_OFN312_FE_OFN1_FE_DBTN1_i_i_rst
XV_reg[13] QDFFRBN $PINS Q=FE_PHN1282_V_13 D=n647 CK=i_clk_clone2
+ RB=FE_OFN306_FE_OFN3_FE_DBTN1_i_i_rst
XV_reg[0] QDFFRBP $PINS Q=V[0] D=n661 CK=i_clk_clone2
+ RB=FE_OFN306_FE_OFN3_FE_DBTN1_i_i_rst
XV_reg[12] QDFFRBN $PINS Q=V[12] D=n648 CK=i_clk_clone2
+ RB=FE_OFN306_FE_OFN3_FE_DBTN1_i_i_rst
XU_reg[16] QDFFRBN $PINS Q=U[16] D=n611 CK=i_clk_clone4
+ RB=FE_OFN5_FE_DBTN1_i_i_rst
XV_reg[17] QDFFRBN $PINS Q=FE_PHN1270_V_17 D=n643 CK=i_clk_clone2
+ RB=FE_OFN9_FE_DBTN1_i_i_rst
XV_reg[29] QDFFRBN $PINS Q=FE_PHN1271_V_29 D=n593 CK=i_clk_clone2
+ RB=FE_OFN9_FE_DBTN1_i_i_rst
XU_reg[15] QDFFRBN $PINS Q=FE_PHN1273_U_15 D=n610 CK=i_clk_clone4
+ RB=FE_OFN474_FE_OFN3_FE_DBTN1_i_i_rst
XV_reg[16] QDFFRBN $PINS Q=V[16] D=n644 CK=i_clk_clone2
+ RB=FE_OFN9_FE_DBTN1_i_i_rst
XU_reg[28] QDFFRBN $PINS Q=U[28] D=n623 CK=i_clk_clone2
+ RB=FE_OFN9_FE_DBTN1_i_i_rst
XV_reg[11] QDFFRBN $PINS Q=V[11] D=n649 CK=i_clk_clone2
+ RB=FE_OFN306_FE_OFN3_FE_DBTN1_i_i_rst
XV_reg[27] QDFFRBN $PINS Q=V[27] D=n591 CK=i_clk_clone2
+ RB=FE_OFN303_FE_OFN5_FE_DBTN1_i_i_rst
XU_reg[26] QDFFRBN $PINS Q=U[26] D=n621 CK=i_clk_clone2
+ RB=FE_OFN303_FE_OFN5_FE_DBTN1_i_i_rst
XV_reg[10] QDFFRBN $PINS Q=V[10] D=n650 CK=i_clk_clone2
+ RB=FE_OFN307_FE_OFN3_FE_DBTN1_i_i_rst
XU_reg[14] QDFFRBN $PINS Q=FE_PHN1274_U_14 D=n609 CK=i_clk_clone4
+ RB=FE_OFN474_FE_OFN3_FE_DBTN1_i_i_rst
XV_reg[15] QDFFRBN $PINS Q=V[15] D=n645 CK=i_clk_clone2
+ RB=FE_OFN9_FE_DBTN1_i_i_rst
XS_reg[32] QDFFRBS $PINS Q=S[32] D=n512 CK=i_clk_clone5
+ RB=FE_OFN0_FE_DBTN1_i_i_rst
XU_reg[13] QDFFRBN $PINS Q=FE_PHN1275_U_13 D=n608 CK=i_clk_clone4
+ RB=FE_OFN474_FE_OFN3_FE_DBTN1_i_i_rst
XU_reg[24] QDFFRBN $PINS Q=U[24] D=n619 CK=i_clk_clone3
+ RB=FE_OFN39_FE_DBTN1_i_i_rst
XV_reg[9] QDFFRBN $PINS Q=V[9] D=n651 CK=i_clk_clone2
+ RB=FE_OFN306_FE_OFN3_FE_DBTN1_i_i_rst
XV_reg[14] QDFFRBN $PINS Q=V[14] D=n646 CK=i_clk_clone2
+ RB=FE_OFN306_FE_OFN3_FE_DBTN1_i_i_rst
XU_reg[23] QDFFRBN $PINS Q=FE_PHN1257_U_23 D=n618 CK=i_clk_clone3
+ RB=FE_OFN39_FE_DBTN1_i_i_rst
XU_reg[8] QDFFRBN $PINS Q=FE_PHN1319_U_8 D=n603 CK=i_clk_clone4
+ RB=FE_OFN474_FE_OFN3_FE_DBTN1_i_i_rst
XU_reg[12] QDFFRBN $PINS Q=FE_PHN1290_U_12 D=n607 CK=i_clk_clone4
+ RB=FE_OFN474_FE_OFN3_FE_DBTN1_i_i_rst
XS_reg[3] QDFFRBN $PINS Q=S[3] D=n541 CK=i_clk
+ RB=FE_OFN313_FE_OFN1_FE_DBTN1_i_i_rst
XU_reg[11] QDFFRBN $PINS Q=FE_PHN1293_U_11 D=n606 CK=i_clk_clone4
+ RB=FE_OFN474_FE_OFN3_FE_DBTN1_i_i_rst
XU_reg[22] QDFFRBN $PINS Q=U[22] D=n617 CK=i_clk_clone3
+ RB=FE_OFN39_FE_DBTN1_i_i_rst
XV_reg[8] QDFFRBN $PINS Q=V[8] D=n652 CK=i_clk_clone2
+ RB=FE_OFN306_FE_OFN3_FE_DBTN1_i_i_rst
XV_reg[25] QDFFRBN $PINS Q=FE_PHN1269_V_25 D=n589 CK=i_clk_clone2
+ RB=FE_OFN303_FE_OFN5_FE_DBTN1_i_i_rst
XR_reg[2] QDFFRBP $PINS Q=div_out[2] D=n575 CK=i_clk
+ RB=FE_OFN312_FE_OFN1_FE_DBTN1_i_i_rst
XR_reg[3] QDFFRBN $PINS Q=FE_OFN109_div_out_3 D=n574 CK=i_clk
+ RB=FE_OFN312_FE_OFN1_FE_DBTN1_i_i_rst
XR_reg[0] QDFFRBP $PINS Q=FE_OCPN664_div_out_0 D=n577 CK=i_clk
+ RB=FE_OFN306_FE_OFN3_FE_DBTN1_i_i_rst
XS_reg[1] QDFFRBN $PINS Q=S[1] D=n543 CK=i_clk
+ RB=FE_OFN307_FE_OFN3_FE_DBTN1_i_i_rst
XV_reg[7] QDFFRBN $PINS Q=FE_PHN1331_V_7 D=n653 CK=i_clk_clone2
+ RB=FE_OFN306_FE_OFN3_FE_DBTN1_i_i_rst
XU_reg[5] QDFFRBN $PINS Q=FE_PHN1314_U_5 D=n600 CK=i_clk
+ RB=FE_OFN474_FE_OFN3_FE_DBTN1_i_i_rst
XU_reg[6] QDFFRBN $PINS Q=U[6] D=n601 CK=i_clk
+ RB=FE_OFN474_FE_OFN3_FE_DBTN1_i_i_rst
XV_reg[6] QDFFRBN $PINS Q=V[6] D=n654 CK=i_clk_clone2
+ RB=FE_OFN306_FE_OFN3_FE_DBTN1_i_i_rst
XV_reg[5] QDFFRBN $PINS Q=V[5] D=n655 CK=i_clk_clone2
+ RB=FE_OFN307_FE_OFN3_FE_DBTN1_i_i_rst
XU_reg[3] QDFFRBN $PINS Q=FE_PHN1335_U_3 D=n598 CK=i_clk
+ RB=FE_OFN474_FE_OFN3_FE_DBTN1_i_i_rst
XU_reg[4] QDFFRBN $PINS Q=FE_PHN1329_U_4 D=n599 CK=i_clk
+ RB=FE_OFN474_FE_OFN3_FE_DBTN1_i_i_rst
XV_reg[4] QDFFRBN $PINS Q=FE_PHN1324_V_4 D=n656 CK=i_clk_clone2
+ RB=FE_OFN307_FE_OFN3_FE_DBTN1_i_i_rst
XV_reg[2] QDFFRBN $PINS Q=FE_PHN1334_V_2 D=FE_PHN1393_n658 CK=i_clk_clone2
+ RB=FE_OFN9_FE_DBTN1_i_i_rst
XU_reg[0] QDFFRBP $PINS Q=U[0] D=n595 CK=i_clk
+ RB=FE_OFN306_FE_OFN3_FE_DBTN1_i_i_rst
XU_reg[2] QDFFRBN $PINS Q=U[2] D=n597 CK=i_clk
+ RB=FE_OFN474_FE_OFN3_FE_DBTN1_i_i_rst
XV_reg[3] QDFFRBN $PINS Q=V[3] D=FE_PHN1378_n657 CK=i_clk_clone2
+ RB=FE_OFN307_FE_OFN3_FE_DBTN1_i_i_rst
XS_reg[31] QDFFRBN $PINS Q=S[31] D=n513 CK=i_clk_clone5
+ RB=FE_OFN309_FE_OFN2_FE_DBTN1_i_i_rst
XS_reg[30] QDFFRBN $PINS Q=S[30] D=n514 CK=i_clk_clone5
+ RB=FE_OFN309_FE_OFN2_FE_DBTN1_i_i_rst
XS_reg[29] QDFFRBN $PINS Q=S[29] D=n515 CK=i_clk_clone5
+ RB=FE_OFN309_FE_OFN2_FE_DBTN1_i_i_rst
XR_reg[29] QDFFRBN $PINS Q=div_out[29] D=n548 CK=i_clk_clone5
+ RB=FE_OFN309_FE_OFN2_FE_DBTN1_i_i_rst
XR_reg[1] QDFFRBP $PINS Q=div_out[1] D=n576 CK=i_clk
+ RB=FE_OFN312_FE_OFN1_FE_DBTN1_i_i_rst
XV_reg[1] QDFFRBN $PINS Q=V[1] D=n659 CK=i_clk_clone2
+ RB=FE_OFN307_FE_OFN3_FE_DBTN1_i_i_rst
XU_reg[1] QDFFRBP $PINS Q=U[1] D=n596 CK=i_clk
+ RB=FE_OFN306_FE_OFN3_FE_DBTN1_i_i_rst
XR_reg[32] QDFFRBS $PINS Q=R[32] D=n545 CK=i_clk_clone5
+ RB=FE_OFN0_FE_DBTN1_i_i_rst
XS_reg[0] QDFFRBN $PINS Q=S[0] D=n544 CK=i_clk
+ RB=FE_OFN306_FE_OFN3_FE_DBTN1_i_i_rst
XU3 ND2 $PINS O=n19 I1=n26 I2=n216
XU4 ND2P $PINS O=n209 I1=n42 I2=n41
XU5 AO222S $PINS O=n335 A1=div_out[2] A2=n30 B1=div_out[1] B2=FE_DBTN90_n36
+ C1=N639 C2=done_div_n
XU7 NR2P $PINS O=n207 I1=n210 I2=n209
XU8 ND2P $PINS O=n41 I1=N111 I2=FE_OFN364_FE_OFN79_n15
XU9 MOAI1H $PINS O=n545 A1=n207 A2=FE_OFN566_n35 B1=n208 B2=R[32]
XU14 ND2P $PINS O=n42 I1=N354 I2=FE_OFN562_n212
XU17 MOAI1H $PINS O=n210 A1=n36 A2=FE_DBTN142_div_out_31 B1=N669
+ B2=FE_OFN560_done_div_n
XU20 MOAI1 $PINS O=n513 A1=FE_OFN566_n35 A2=n107 B1=FE_OFN566_n35 B2=S[31]
XU25 NR2P $PINS O=n100 I1=n43 I2=n44
XU26 AO222S $PINS O=n338 A1=div_out[1] A2=n30 B1=FE_OCPN664_div_out_0
+ B2=FE_DBTN90_n36 C1=N638 C2=done_div_n
XU43 MOAI1S $PINS O=n514 A1=FE_OFN617_FE_DBTN91_n35 A2=FE_DBTN73_S_30
+ B1=FE_OFN617_FE_DBTN91_n35 B2=n112
XU46 MOAI1S $PINS O=n549 A1=n229 A2=FE_OFN566_n35 B1=FE_OFN566_n35
+ B2=div_out[28]
XU49 NR2 $PINS O=n9 I1=n51 I2=n723
XU50 OAI22S $PINS O=n10 A1=N355 A2=n38 B1=n721 B2=n206
XU51 ND2 $PINS O=n11 I1=n388 I2=n720
XU52 NR2 $PINS O=n12 I1=n387 I2=n204
XU53 NR2P $PINS O=n13 I1=n387 I2=n345
XU54 NR2 $PINS O=n14 I1=n204 I2=n721
XU55 NR2 $PINS O=n15 I1=n345 I2=n721
XU56 NR2 $PINS O=n18 I1=n721 I2=N31
XU57 INV2 $PINS O=n20 I=n19
XU58 AO222S $PINS O=n577 A1=FE_OCPN664_div_out_0 A2=n208 B1=FE_OFN640_n B2=n341
+ C1=N573 C2=n218
XU59 ND2S $PINS O=n21 I1=N111 I2=FE_OFN365_FE_OFN78_n14
XU60 ND2 $PINS O=n44 I1=n21 I2=n22
XU62 ND2P $PINS O=n213 I1=n215 I2=n20
XU64 ND2S $PINS O=n22 I1=N389 I2=FE_OFN561_n104
XU65 AOI22S $PINS O=n451 A1=N76 A2=n13 B1=U[29] B2=n29
XU68 INV1S $PINS O=n34 I=FE_OFN564_n369
XU70 INV1S $PINS O=n32 I=n29
XU73 MOAI1 $PINS O=n547 A1=n221 A2=FE_OFN566_n35 B1=FE_OFN566_n35
+ B2=div_out[30]
XU74 NR2 $PINS O=n29 I1=n387 I2=U[0]
XU75 OAI22S $PINS O=n30 A1=N319 A2=n38 B1=U[0] B2=n721
XU76 AO222S $PINS O=n322 A1=div_out[5] A2=n30 B1=FE_OFN108_div_out_4
+ B2=FE_DBTN90_n36 C1=N642 C2=done_div_n
XU103 OAI12HS $PINS O=n35 A1=n460 B1=n37 B2=sel_div
XU107 AN2 $PINS O=n371 I1=n388 I2=FE_DBTN94_n37
XU108 OR2 $PINS O=n208 I1=FE_OFN363_FE_OFN80_n30 I2=n35
XU110 INV1S $PINS O=n720 I=n105
XU116 OR2 $PINS O=n36 I1=n721 I2=n393
XU120 ND2 $PINS O=n456 I1=n38 I2=n460
XU121 NR2 $PINS O=n457 I1=n456 I2=n721
XU122 INV1S $PINS O=n722 I=n460
XU131 MOAI1S $PINS O=n548 A1=FE_OFN617_FE_DBTN91_n35 A2=FE_DBTN141_div_out_29
+ B1=n225 B2=FE_OFN617_FE_DBTN91_n35
XU132 AOI22S $PINS O=n227 A1=n217 A2=div_out[30] B1=N602 B2=FE_OFN563_n218
XU133 MOAI1S $PINS O=n552 A1=FE_OFN617_FE_DBTN91_n35 A2=FE_DBTN139_div_out_25
+ B1=n241 B2=FE_OFN617_FE_DBTN91_n35
XU134 AOI22S $PINS O=n243 A1=n217 A2=div_out[26] B1=N598 B2=FE_OFN563_n218
XU135 MOAI1S $PINS O=n550 A1=FE_OFN617_FE_DBTN91_n35 A2=FE_DBTN140_div_out_27
+ B1=n233 B2=FE_OFN617_FE_DBTN91_n35
XU136 AOI22S $PINS O=n235 A1=n217 A2=div_out[28] B1=N600 B2=FE_OFN563_n218
XU137 MOAI1S $PINS O=n232 A1=n719 A2=FE_DBTN141_div_out_29 B1=N601
+ B2=FE_OFN563_n218
XU138 MOAI1S $PINS O=n240 A1=n719 A2=FE_DBTN140_div_out_27 B1=N599
+ B2=FE_OFN563_n218
XU141 MOAI1S $PINS O=n554 A1=FE_OFN616_FE_DBTN91_n35 A2=FE_DBTN138_div_out_23
+ B1=n249 B2=FE_OFN616_FE_DBTN91_n35
XU142 AOI22S $PINS O=n252 A1=N102 A2=FE_OFN364_FE_OFN79_n15 B1=N345
+ B2=FE_OFN562_n212
XU143 AOI22S $PINS O=n251 A1=n217 A2=div_out[24] B1=N596 B2=FE_OFN563_n218
XU144 MOAI1S $PINS O=n248 A1=n719 A2=FE_DBTN139_div_out_25 B1=N597
+ B2=FE_OFN563_n218
XU145 MOAI1S $PINS O=n256 A1=n719 A2=FE_DBTN138_div_out_23 B1=N595
+ B2=FE_OFN563_n218
XU149 MOAI1S $PINS O=n556 A1=FE_OFN616_FE_DBTN91_n35 A2=FE_DBTN137_div_out_21
+ B1=n257 B2=FE_OFN616_FE_DBTN91_n35
XU150 AOI22S $PINS O=n259 A1=n217 A2=div_out[22] B1=N594 B2=FE_OFN563_n218
XU151 MOAI1S $PINS O=n558 A1=FE_OFN616_FE_DBTN91_n35 A2=FE_DBTN136_div_out_19
+ B1=n265 B2=FE_OFN616_FE_DBTN91_n35
XU152 AOI22S $PINS O=n267 A1=n217 A2=div_out[20] B1=N592 B2=FE_OFN563_n218
XU153 MOAI1S $PINS O=n264 A1=n719 A2=FE_DBTN137_div_out_21 B1=N593
+ B2=FE_OFN563_n218
XU154 MOAI1S $PINS O=n272 A1=n719 A2=FE_DBTN136_div_out_19 B1=N591
+ B2=FE_OFN563_n218
XU155 OAI12HS $PINS O=n370 A1=n388 B1=n386 B2=n387
XU156 NR2 $PINS O=n388 I1=n35 I2=n205
XU159 NR2 $PINS O=n369 I1=n387 I2=n206
XU161 MOAI1S $PINS O=n560 A1=FE_OFN82_FE_DBTN91_n35 A2=FE_DBTN135_div_out_17
+ B1=n273 B2=FE_OFN82_FE_DBTN91_n35
XU162 AOI22S $PINS O=n276 A1=N96 A2=FE_OFN364_FE_OFN79_n15 B1=N339
+ B2=FE_OFN562_n212
XU163 AOI22S $PINS O=n275 A1=n217 A2=div_out[18] B1=N590 B2=FE_OFN563_n218
XU164 MOAI1S $PINS O=n562 A1=FE_OFN638_n A2=FE_DBTN134_div_out_15 B1=n281
+ B2=FE_OFN638_n
XU165 AOI22S $PINS O=n284 A1=N94 A2=FE_OFN364_FE_OFN79_n15 B1=N337
+ B2=FE_OFN562_n212
XU166 AOI22S $PINS O=n283 A1=n217 A2=div_out[16] B1=N588 B2=FE_OFN563_n218
XU167 MOAI1S $PINS O=n280 A1=n719 A2=FE_DBTN135_div_out_17 B1=N589
+ B2=FE_OFN563_n218
XU172 MOAI1S $PINS O=n564 A1=FE_OFN638_n A2=FE_DBTN133_div_out_13 B1=n289
+ B2=FE_OFN638_n
XU173 AOI22S $PINS O=n292 A1=N92 A2=FE_OFN364_FE_OFN79_n15 B1=N335
+ B2=FE_OFN562_n212
XU174 AOI22S $PINS O=n291 A1=n217 A2=div_out[14] B1=N586 B2=FE_OFN563_n218
XU175 MOAI1S $PINS O=n288 A1=n719 A2=FE_DBTN134_div_out_15 B1=N587
+ B2=FE_OFN563_n218
XU176 MOAI1S $PINS O=n296 A1=n719 A2=FE_DBTN133_div_out_13 B1=N585
+ B2=FE_OFN563_n218
XU177 AOI22S $PINS O=n340 A1=N80 A2=FE_OFN79_n15 B1=N323 B2=n212
XU178 AOI22S $PINS O=n310 A1=N87 A2=FE_OFN79_n15 B1=N330 B2=n212
XU179 AOI22S $PINS O=n318 A1=N85 A2=FE_OFN79_n15 B1=N328 B2=n212
XU180 AOI22S $PINS O=n326 A1=N83 A2=FE_OFN79_n15 B1=N326 B2=n212
XU181 AOI22S $PINS O=n334 A1=N81 A2=FE_OFN79_n15 B1=N324 B2=n212
XU185 MOAI1S $PINS O=n636 A1=n723 A2=n458 B1=n458 B2=n459
XU186 OR2 $PINS O=n459 I1=FE_DBTN94_n37 I2=n456
XU187 NR2 $PINS O=n105 I1=n721 I2=n386
XU188 MOAI1S $PINS O=n574 A1=FE_OFN638_n A2=FE_DBTN128_div_out_3 B1=n329
+ B2=FE_OFN638_n
XU189 AOI22S $PINS O=n331 A1=n217 A2=FE_OFN108_div_out_4 B1=N576 B2=n218
XU190 AOI22S $PINS O=n332 A1=N82 A2=FE_OFN79_n15 B1=N325 B2=n212
XU191 MOAI1S $PINS O=n566 A1=FE_OFN638_n A2=FE_DBTN132_div_out_11 B1=n297
+ B2=FE_OFN638_n
XU192 AOI22S $PINS O=n300 A1=N90 A2=FE_OFN79_n15 B1=N333 B2=n212
XU193 AOI22S $PINS O=n299 A1=n217 A2=div_out[12] B1=N584 B2=n218
XU194 MOAI1S $PINS O=n568 A1=FE_OFN638_n A2=FE_DBTN131_div_out_9 B1=n305
+ B2=FE_OFN638_n
XU195 AOI22S $PINS O=n308 A1=N88 A2=FE_OFN79_n15 B1=N331 B2=n212
XU196 AOI22S $PINS O=n307 A1=n217 A2=div_out[10] B1=N582 B2=n218
XU197 MOAI1S $PINS O=n570 A1=FE_OFN638_n A2=FE_DBTN130_div_out_7 B1=n313
+ B2=FE_OFN638_n
XU198 AOI22S $PINS O=n315 A1=n217 A2=div_out[8] B1=N580 B2=n218
XU199 AOI22S $PINS O=n316 A1=N86 A2=FE_OFN79_n15 B1=N329 B2=n212
XU200 MOAI1S $PINS O=n572 A1=FE_OFN638_n A2=FE_DBTN129_div_out_5 B1=n321
+ B2=FE_OFN638_n
XU201 AOI22S $PINS O=n323 A1=n217 A2=div_out[6] B1=N578 B2=n218
XU202 AOI22S $PINS O=n324 A1=N84 A2=FE_OFN79_n15 B1=N327 B2=n212
XU203 MOAI1S $PINS O=n304 A1=n719 A2=FE_DBTN132_div_out_11 B1=N583 B2=n218
XU204 AN2 $PINS O=n393 I1=n206 I2=n204
XU206 AN2 $PINS O=n212 I1=N319 I2=n205
XU212 INV1S $PINS O=n689 I=n717
XU213 INV1S $PINS O=n693 I=n685
XU214 INV1S $PINS O=n690 I=n682
XU215 INV1S $PINS O=n692 I=n684
XU216 INV1S $PINS O=n694 I=n686
XU217 INV1S $PINS O=n691 I=n683
XU218 INV1S $PINS O=n721 I=n508
XU219 INV1S $PINS O=n719 I=n217
XU220 AN2 $PINS O=done_div_n I1=n9 I2=n718
XU221 INV1S $PINS O=n718 I=N569
XU224 INV1S $PINS O=n40 I=S[32]
XU225 AOI22S $PINS O=n109 A1=S[31] A2=FE_OFN366_FE_OFN77_n10 B1=div_in_0[31]
+ B2=FE_OFN482_FE_DBTN94_n37
XU226 AOI22S $PINS O=n108 A1=N110 A2=FE_OFN365_FE_OFN78_n14 B1=N388
+ B2=FE_OFN561_n104
XU227 AOI22S $PINS O=n382 A1=V[29] A2=n370 B1=div_in_1[29] B2=FE_OFN634_n371
XU228 AOI22S $PINS O=n383 A1=N141 A2=n12 B1=V[30] B2=FE_OFN564_n369
XU229 AOI22S $PINS O=n378 A1=FE_PHN1072_V_27 A2=n370 B1=div_in_1[27]
+ B2=FE_OFN634_n371
XU230 AOI22S $PINS O=n379 A1=N139 A2=n12 B1=FE_PHN840_V_28 B2=FE_OFN564_n369
XU231 AOI22S $PINS O=n384 A1=V[30] A2=n370 B1=div_in_1[30] B2=FE_OFN634_n371
XU232 AOI22S $PINS O=n380 A1=FE_PHN840_V_28 A2=n370 B1=div_in_1[28]
+ B2=FE_OFN634_n371
XU233 AOI22S $PINS O=n381 A1=N140 A2=n12 B1=V[29] B2=FE_OFN564_n369
XU234 MOAI1S $PINS O=n551 A1=n237 A2=FE_OFN566_n35 B1=FE_OFN566_n35
+ B2=div_out[26]
XU235 MOAI1S $PINS O=n515 A1=FE_OFN617_FE_DBTN91_n35 A2=n768
+ B1=FE_OFN617_FE_DBTN91_n35 B2=n115
XU236 OAI112HS $PINS O=n115 A1=n116 B1=n117 C1=FE_OFN567_n720 C2=FE_DBTN74_S_28
XU237 AOI22S $PINS O=n117 A1=S[29] A2=FE_OFN366_FE_OFN77_n10 B1=div_in_0[29]
+ B2=FE_OFN482_FE_DBTN94_n37
XU238 AOI22S $PINS O=n116 A1=N108 A2=FE_OFN365_FE_OFN78_n14 B1=N386
+ B2=FE_OFN561_n104
XU239 MOAI1S $PINS O=n517 A1=FE_OFN617_FE_DBTN91_n35 A2=n766
+ B1=FE_OFN617_FE_DBTN91_n35 B2=n121
XU240 AOI22S $PINS O=n123 A1=S[27] A2=FE_OFN366_FE_OFN77_n10 B1=div_in_0[27]
+ B2=FE_OFN482_FE_DBTN94_n37
XU241 MOAI1S $PINS O=n516 A1=FE_OFN617_FE_DBTN91_n35 A2=FE_DBTN74_S_28
+ B1=FE_OFN617_FE_DBTN91_n35 B2=n118
XU242 OAI112HS $PINS O=n118 A1=n119 B1=n120 C1=FE_OFN567_n720 C2=n766
XU243 AOI22S $PINS O=n120 A1=S[28] A2=FE_OFN366_FE_OFN77_n10 B1=div_in_0[28]
+ B2=FE_OFN482_FE_DBTN94_n37
XU244 MOAI1S $PINS O=n518 A1=FE_OFN617_FE_DBTN91_n35 A2=FE_DBTN75_S_26
+ B1=FE_OFN617_FE_DBTN91_n35 B2=n124
XU245 OAI112HS $PINS O=n124 A1=n125 B1=n126 C1=FE_OFN567_n720 C2=n764
XU246 AOI22S $PINS O=n126 A1=S[26] A2=FE_OFN366_FE_OFN77_n10 B1=div_in_0[26]
+ B2=FE_OFN482_FE_DBTN94_n37
XU247 AOI22S $PINS O=n125 A1=N105 A2=FE_OFN365_FE_OFN78_n14 B1=N383
+ B2=FE_OFN561_n104
XU248 OAI112HS $PINS O=n112 A1=n113 B1=n114 C1=FE_OFN567_n720 C2=n768
XU249 AOI22S $PINS O=n114 A1=S[30] A2=FE_OFN366_FE_OFN77_n10 B1=div_in_0[30]
+ B2=FE_OFN482_FE_DBTN94_n37
XU250 AOI22S $PINS O=n113 A1=N109 A2=FE_OFN365_FE_OFN78_n14 B1=N387
+ B2=FE_OFN561_n104
XU251 AOI22S $PINS O=n452 A1=prime[29] A2=FE_OFN635_n371 B1=U[29] B2=n397
XU252 AOI22S $PINS O=n453 A1=N77 A2=n13 B1=FE_PHN754_U_30 B2=n29
XU253 AOI22S $PINS O=n454 A1=prime[30] A2=FE_OFN635_n371 B1=FE_PHN754_U_30
+ B2=n397
XU254 AOI22S $PINS O=n446 A1=prime[26] A2=FE_OFN635_n371 B1=FE_PHN1260_U_26
+ B2=n397
XU255 AOI22S $PINS O=n447 A1=N74 A2=n13 B1=FE_PHN751_U_27 B2=n29
XU256 AOI22S $PINS O=n448 A1=prime[27] A2=FE_OFN635_n371 B1=FE_PHN751_U_27
+ B2=n397
XU257 AOI22S $PINS O=n449 A1=N75 A2=n13 B1=FE_PHN1055_U_28 B2=n29
XU258 AOI22S $PINS O=n450 A1=prime[28] A2=FE_OFN635_n371 B1=FE_PHN1055_U_28
+ B2=n397
XU259 AOI22S $PINS O=n366 A1=FE_PHN1276_V_23 A2=n370 B1=div_in_1[23]
+ B2=FE_OFN634_n371
XU260 AOI22S $PINS O=n367 A1=N135 A2=n12 B1=FE_PHN1267_V_24 B2=FE_OFN564_n369
XU261 AOI22S $PINS O=n374 A1=V[25] A2=n370 B1=div_in_1[25] B2=FE_OFN634_n371
XU262 AOI22S $PINS O=n375 A1=N137 A2=n12 B1=FE_PHN1073_V_26 B2=FE_OFN564_n369
XU263 AOI22S $PINS O=n372 A1=FE_PHN1267_V_24 A2=n370 B1=div_in_1[24]
+ B2=FE_OFN634_n371
XU264 AOI22S $PINS O=n373 A1=N136 A2=n12 B1=V[25] B2=FE_OFN564_n369
XU265 AOI22S $PINS O=n376 A1=FE_PHN1073_V_26 A2=n370 B1=div_in_1[26]
+ B2=FE_OFN634_n371
XU266 AOI22S $PINS O=n377 A1=N138 A2=n12 B1=FE_PHN1072_V_27 B2=FE_OFN564_n369
XU267 MOAI1S $PINS O=n553 A1=n245 A2=FE_OFN566_n35 B1=FE_OFN566_n35
+ B2=div_out[24]
XU268 AOI22S $PINS O=n246 A1=N103 A2=FE_OFN364_FE_OFN79_n15 B1=N346
+ B2=FE_OFN562_n212
XU269 MOAI1S $PINS O=n555 A1=n253 A2=FE_OFN566_n35 B1=FE_OFN566_n35
+ B2=div_out[22]
XU270 MOAI1S $PINS O=n521 A1=FE_OFN616_FE_DBTN91_n35 A2=FE_PHN1175_n762
+ B1=FE_OFN616_FE_DBTN91_n35 B2=n133
XU271 AOI22S $PINS O=n135 A1=S[23] A2=FE_OFN366_FE_OFN77_n10 B1=div_in_0[23]
+ B2=FE_OFN482_FE_DBTN94_n37
XU272 MOAI1S $PINS O=n519 A1=FE_OFN617_FE_DBTN91_n35 A2=n764
+ B1=FE_OFN617_FE_DBTN91_n35 B2=n127
XU273 OAI112HS $PINS O=n127 A1=n128 B1=n129 C1=FE_OFN567_n720 C2=FE_DBTN76_S_24
XU274 AOI22S $PINS O=n129 A1=S[25] A2=FE_OFN366_FE_OFN77_n10 B1=div_in_0[25]
+ B2=FE_OFN482_FE_DBTN94_n37
XU275 AOI22S $PINS O=n128 A1=N104 A2=FE_OFN365_FE_OFN78_n14 B1=N382
+ B2=FE_OFN561_n104
XU276 MOAI1S $PINS O=n520 A1=FE_OFN616_FE_DBTN91_n35 A2=FE_DBTN76_S_24
+ B1=FE_OFN616_FE_DBTN91_n35 B2=n130
XU277 OAI112HS $PINS O=n130 A1=n131 B1=n132 C1=FE_OFN567_n720 C2=n762
XU278 AOI22S $PINS O=n132 A1=S[24] A2=FE_OFN366_FE_OFN77_n10 B1=div_in_0[24]
+ B2=FE_OFN482_FE_DBTN94_n37
XU279 AOI22S $PINS O=n440 A1=prime[23] A2=FE_OFN635_n371 B1=U[23] B2=n397
XU280 AOI22S $PINS O=n441 A1=N71 A2=n13 B1=FE_PHN1244_U_24 B2=n29
XU281 AOI22S $PINS O=n442 A1=prime[24] A2=FE_OFN635_n371 B1=FE_PHN1244_U_24
+ B2=n397
XU282 AOI22S $PINS O=n443 A1=N72 A2=n13 B1=U[25] B2=n29
XU283 AOI22S $PINS O=n444 A1=prime[25] A2=FE_OFN635_n371 B1=U[25] B2=n397
XU284 AOI22S $PINS O=n445 A1=N73 A2=n13 B1=FE_PHN1260_U_26 B2=n29
XU285 AOI22S $PINS O=n464 A1=div_in_1[21] A2=FE_OFN635_n371 B1=FE_PHN1211_V_21
+ B2=FE_OFN636_n11
XU286 AOI22S $PINS O=n465 A1=N133 A2=FE_OFN637_n12 B1=FE_PHN1250_V_22
+ B2=FE_OFN564_n369
XU287 AOI22S $PINS O=n466 A1=div_in_1[20] A2=FE_OFN635_n371 B1=V[20]
+ B2=FE_OFN636_n11
XU288 AOI22S $PINS O=n467 A1=N132 A2=FE_OFN637_n12 B1=FE_PHN1211_V_21
+ B2=FE_OFN564_n369
XU289 AOI22S $PINS O=n462 A1=div_in_1[22] A2=FE_OFN635_n371 B1=FE_PHN1250_V_22
+ B2=FE_OFN636_n11
XU290 AOI22S $PINS O=n463 A1=N134 A2=FE_OFN637_n12 B1=FE_PHN1276_V_23
+ B2=FE_OFN564_n369
XU291 MOAI1S $PINS O=n557 A1=n261 A2=FE_OFN566_n35 B1=FE_OFN566_n35
+ B2=div_out[20]
XU292 MOAI1S $PINS O=n559 A1=n269 A2=FE_OFN566_n35 B1=FE_OFN566_n35
+ B2=div_out[18]
XU293 AOI22S $PINS O=n270 A1=N97 A2=FE_OFN364_FE_OFN79_n15 B1=N340
+ B2=FE_OFN562_n212
XU294 MOAI1S $PINS O=n523 A1=FE_OFN616_FE_DBTN91_n35 A2=FE_PHN1172_n760
+ B1=FE_OFN616_FE_DBTN91_n35 B2=n139
XU295 AOI22S $PINS O=n141 A1=S[21] A2=FE_OFN366_FE_OFN77_n10 B1=div_in_0[21]
+ B2=FE_OFN482_FE_DBTN94_n37
XU296 MOAI1S $PINS O=n525 A1=FE_OFN639_n A2=n758 B1=FE_OFN639_n B2=n145
XU297 AOI22S $PINS O=n147 A1=S[19] A2=FE_OFN366_FE_OFN77_n10 B1=div_in_0[19]
+ B2=FE_OFN482_FE_DBTN94_n37
XU298 MOAI1S $PINS O=n522 A1=FE_OFN616_FE_DBTN91_n35 A2=FE_DBTN77_S_22
+ B1=FE_OFN616_FE_DBTN91_n35 B2=n136
XU299 OAI112HS $PINS O=n136 A1=n137 B1=n138 C1=FE_OFN567_n720 C2=n760
XU300 AOI22S $PINS O=n138 A1=S[22] A2=FE_OFN366_FE_OFN77_n10 B1=div_in_0[22]
+ B2=FE_OFN482_FE_DBTN94_n37
XU301 MOAI1S $PINS O=n524 A1=FE_OFN616_FE_DBTN91_n35 A2=FE_DBTN78_S_20
+ B1=FE_OFN616_FE_DBTN91_n35 B2=n142
XU302 OAI112HS $PINS O=n142 A1=n143 B1=n144 C1=FE_OFN567_n720 C2=n758
XU303 AOI22S $PINS O=n144 A1=S[20] A2=FE_OFN366_FE_OFN77_n10 B1=div_in_0[20]
+ B2=FE_OFN482_FE_DBTN94_n37
XU304 AOI22S $PINS O=n434 A1=prime[20] A2=FE_OFN633_n371 B1=FE_PHN1233_U_20
+ B2=FE_OFN644_n397
XU305 AOI22S $PINS O=n435 A1=N68 A2=FE_OFN565_n13 B1=FE_PHN1246_U_21
+ B2=FE_OFN645_n29
XU306 AOI22S $PINS O=n436 A1=prime[21] A2=FE_OFN635_n371 B1=FE_PHN1246_U_21
+ B2=n397
XU307 AOI22S $PINS O=n437 A1=N69 A2=n13 B1=FE_PHN1258_U_22 B2=n29
XU308 AOI22S $PINS O=n438 A1=prime[22] A2=FE_OFN635_n371 B1=FE_PHN1258_U_22
+ B2=n397
XU309 AOI22S $PINS O=n439 A1=N70 A2=n13 B1=U[23] B2=n29
XU310 MOAI1S $PINS O=n526 A1=FE_OFN639_n A2=FE_DBTN79_S_18 B1=FE_OFN639_n
+ B2=n148
XU311 OAI112HS $PINS O=n148 A1=n149 B1=n150 C1=FE_OFN567_n720 C2=n756
XU312 AOI22S $PINS O=n150 A1=S[18] A2=FE_OFN366_FE_OFN77_n10 B1=div_in_0[18]
+ B2=FE_OFN482_FE_DBTN94_n37
XU313 AOI22S $PINS O=n149 A1=N97 A2=FE_OFN365_FE_OFN78_n14 B1=N375
+ B2=FE_OFN561_n104
XU314 AOI22S $PINS O=n498 A1=div_in_1[4] A2=FE_OFN634_n371 B1=V[4] B2=n11
XU315 AOI22S $PINS O=n499 A1=N116 A2=FE_OFN637_n12 B1=FE_PHN1215_V_5 B2=n369
XU316 AOI22S $PINS O=n494 A1=div_in_1[6] A2=n371 B1=FE_PHN1219_V_6 B2=n11
XU317 AOI22S $PINS O=n495 A1=N118 A2=FE_OFN637_n12 B1=V[7] B2=n369
XU318 AOI22S $PINS O=n490 A1=div_in_1[8] A2=n371 B1=FE_PHN1322_V_8
+ B2=FE_OFN636_n11
XU319 AOI22S $PINS O=n491 A1=N120 A2=FE_OFN637_n12 B1=FE_PHN1312_V_9 B2=n369
XU320 AOI22S $PINS O=n486 A1=div_in_1[10] A2=FE_OFN634_n371 B1=FE_PHN1310_V_10
+ B2=n11
XU321 AOI22S $PINS O=n487 A1=N122 A2=FE_OFN637_n12 B1=FE_PHN1305_V_11 B2=n369
XU322 AOI22S $PINS O=n478 A1=div_in_1[14] A2=n371 B1=FE_PHN1213_V_14
+ B2=FE_OFN636_n11
XU323 AOI22S $PINS O=n479 A1=N126 A2=FE_OFN637_n12 B1=FE_PHN1277_V_15
+ B2=FE_OFN564_n369
XU324 AOI22S $PINS O=n400 A1=prime[3] A2=FE_OFN633_n371 B1=U[3]
+ B2=FE_OFN644_n397
XU325 AOI22S $PINS O=n401 A1=N51 A2=FE_OFN565_n13 B1=U[4] B2=FE_OFN645_n29
XU326 AOI22S $PINS O=n404 A1=prime[5] A2=FE_OFN633_n371 B1=U[5]
+ B2=FE_OFN644_n397
XU327 AOI22S $PINS O=n405 A1=N53 A2=FE_OFN565_n13 B1=FE_PHN1327_U_6
+ B2=FE_OFN645_n29
XU328 AOI22S $PINS O=n480 A1=div_in_1[13] A2=FE_OFN635_n371 B1=V[13]
+ B2=FE_OFN636_n11
XU329 AOI22S $PINS O=n481 A1=N125 A2=FE_OFN637_n12 B1=FE_PHN1213_V_14
+ B2=FE_OFN564_n369
XU330 AOI22S $PINS O=n472 A1=div_in_1[17] A2=FE_OFN635_n371 B1=FE_PHN1601_V_17
+ B2=FE_OFN636_n11
XU331 AOI22S $PINS O=n473 A1=N129 A2=FE_OFN637_n12 B1=V[18] B2=FE_OFN564_n369
XU332 AOI22S $PINS O=n500 A1=div_in_1[3] A2=FE_OFN634_n371 B1=V[3] B2=n11
XU333 AOI22S $PINS O=n501 A1=N115 A2=n12 B1=V[4] B2=n369
XU334 AOI22S $PINS O=n476 A1=div_in_1[15] A2=FE_OFN635_n371 B1=FE_PHN1277_V_15
+ B2=FE_OFN636_n11
XU335 AOI22S $PINS O=n477 A1=N127 A2=FE_OFN637_n12 B1=FE_PHN1259_V_16
+ B2=FE_OFN564_n369
XU336 AOI22S $PINS O=n496 A1=div_in_1[5] A2=FE_OFN634_n371 B1=FE_PHN1215_V_5
+ B2=n11
XU337 AOI22S $PINS O=n497 A1=N117 A2=FE_OFN637_n12 B1=FE_PHN1219_V_6 B2=n369
XU338 AOI22S $PINS O=n492 A1=div_in_1[7] A2=n371 B1=V[7] B2=FE_OFN636_n11
XU339 AOI22S $PINS O=n493 A1=N119 A2=FE_OFN637_n12 B1=FE_PHN1322_V_8 B2=n369
XU340 AOI22S $PINS O=n488 A1=div_in_1[9] A2=n371 B1=FE_PHN1312_V_9
+ B2=FE_OFN636_n11
XU341 AOI22S $PINS O=n489 A1=N121 A2=FE_OFN637_n12 B1=FE_PHN1310_V_10 B2=n369
XU342 AOI22S $PINS O=n484 A1=div_in_1[11] A2=FE_OFN634_n371 B1=FE_PHN1305_V_11
+ B2=n11
XU343 AOI22S $PINS O=n485 A1=N123 A2=FE_OFN637_n12 B1=FE_PHN1212_V_12
+ B2=FE_OFN564_n369
XU344 AOI22S $PINS O=n468 A1=div_in_1[19] A2=FE_OFN635_n371 B1=V[19]
+ B2=FE_OFN636_n11
XU345 AOI22S $PINS O=n469 A1=N131 A2=FE_OFN637_n12 B1=V[20] B2=FE_OFN564_n369
XU346 AOI22S $PINS O=n504 A1=div_in_1[1] A2=FE_OFN634_n371 B1=FE_PHN1231_V_1
+ B2=n11
XU347 AOI22S $PINS O=n505 A1=N113 A2=n12 B1=V[2] B2=n369
XU348 AOI22S $PINS O=n502 A1=div_in_1[2] A2=FE_OFN634_n371 B1=V[2] B2=n11
XU349 AOI22S $PINS O=n503 A1=N114 A2=n12 B1=V[3] B2=n369
XU350 AOI22S $PINS O=n482 A1=div_in_1[12] A2=n371 B1=FE_PHN1212_V_12
+ B2=FE_OFN636_n11
XU351 AOI22S $PINS O=n483 A1=N124 A2=FE_OFN637_n12 B1=V[13] B2=FE_OFN564_n369
XU352 AOI22S $PINS O=n474 A1=div_in_1[16] A2=FE_OFN635_n371 B1=FE_PHN1259_V_16
+ B2=FE_OFN636_n11
XU353 AOI22S $PINS O=n475 A1=N128 A2=FE_OFN637_n12 B1=V[17] B2=FE_OFN564_n369
XU354 AOI22S $PINS O=n470 A1=div_in_1[18] A2=FE_OFN635_n371 B1=V[18]
+ B2=FE_OFN636_n11
XU355 AOI22S $PINS O=n471 A1=N130 A2=FE_OFN637_n12 B1=V[19] B2=FE_OFN564_n369
XU356 AOI22S $PINS O=n506 A1=div_in_1[0] A2=n371 B1=FE_OCPN661_V_0 B2=n11
XU357 AOI22S $PINS O=n507 A1=N112 A2=FE_OFN637_n12 B1=FE_PHN1231_V_1 B2=n369
XU358 MOAI1S $PINS O=n561 A1=n277 A2=FE_OFN566_n35 B1=n35 B2=div_out[16]
XU359 AOI22S $PINS O=n278 A1=N95 A2=FE_OFN364_FE_OFN79_n15 B1=N338
+ B2=FE_OFN562_n212
XU360 MOAI1S $PINS O=n527 A1=FE_OFN639_n A2=n756 B1=FE_OFN639_n B2=n151
XU361 OAI112HS $PINS O=n151 A1=n152 B1=n153 C1=FE_OFN567_n720 C2=FE_DBTN80_S_16
XU362 AOI22S $PINS O=n153 A1=S[17] A2=FE_OFN366_FE_OFN77_n10 B1=div_in_0[17]
+ B2=FE_OFN482_FE_DBTN94_n37
XU363 AOI22S $PINS O=n152 A1=N96 A2=FE_OFN365_FE_OFN78_n14 B1=N374
+ B2=FE_OFN561_n104
XU364 MOAI1S $PINS O=n528 A1=FE_OFN82_FE_DBTN91_n35 A2=FE_DBTN80_S_16
+ B1=FE_OFN638_n B2=n154
XU365 OAI112HS $PINS O=n154 A1=n155 B1=n156 C1=FE_OFN567_n720 C2=n754
XU366 AOI22S $PINS O=n156 A1=S[16] A2=FE_OFN366_FE_OFN77_n10 B1=div_in_0[16]
+ B2=FE_OFN482_FE_DBTN94_n37
XU367 AOI22S $PINS O=n155 A1=N95 A2=FE_OFN365_FE_OFN78_n14 B1=N373
+ B2=FE_OFN561_n104
XU368 AOI22S $PINS O=n390 A1=FE_PHN1057_U_0 A2=n391 B1=N48 B2=n13
XU369 OAI12HS $PINS O=n391 A1=n388 B1=n393 B2=n387
XU370 AOI22S $PINS O=n395 A1=FE_OCPN177_FE_OFN86_n312 A2=FE_OFN633_n371
+ B1=FE_PHN747_U_1 B2=FE_OFN644_n397
XU371 AOI22S $PINS O=n396 A1=N49 A2=FE_OFN565_n13 B1=FE_PHN1333_U_2
+ B2=FE_OFN645_n29
XU372 AOI22S $PINS O=n398 A1=prime[2] A2=FE_OFN633_n371 B1=FE_PHN1333_U_2
+ B2=FE_OFN644_n397
XU373 AOI22S $PINS O=n399 A1=N50 A2=FE_OFN565_n13 B1=U[3] B2=FE_OFN645_n29
XU374 AOI22S $PINS O=n402 A1=prime[4] A2=FE_OFN633_n371 B1=U[4]
+ B2=FE_OFN644_n397
XU375 AOI22S $PINS O=n403 A1=N52 A2=FE_OFN565_n13 B1=U[5] B2=FE_OFN645_n29
XU376 AOI22S $PINS O=n406 A1=prime[6] A2=FE_OFN633_n371 B1=FE_PHN1327_U_6
+ B2=FE_OFN644_n397
XU377 AOI22S $PINS O=n407 A1=N54 A2=FE_OFN565_n13 B1=U[7] B2=FE_OFN645_n29
XU378 AOI22S $PINS O=n408 A1=prime[7] A2=FE_OFN633_n371 B1=U[7]
+ B2=FE_OFN644_n397
XU379 AOI22S $PINS O=n409 A1=N55 A2=FE_OFN565_n13 B1=U[8] B2=FE_OFN645_n29
XU380 AOI22S $PINS O=n410 A1=FE_OFN144_raw_prime_8 A2=FE_OFN633_n371 B1=U[8]
+ B2=FE_OFN644_n397
XU381 AOI22S $PINS O=n411 A1=N56 A2=FE_OFN565_n13 B1=U[9] B2=FE_OFN645_n29
XU382 AOI22S $PINS O=n412 A1=prime[9] A2=FE_OFN633_n371 B1=U[9]
+ B2=FE_OFN644_n397
XU383 AOI22S $PINS O=n413 A1=N57 A2=FE_OFN565_n13 B1=U[10] B2=FE_OFN645_n29
XU384 AOI22S $PINS O=n414 A1=prime[10] A2=FE_OFN633_n371 B1=U[10]
+ B2=FE_OFN644_n397
XU385 AOI22S $PINS O=n415 A1=N58 A2=FE_OFN565_n13 B1=U[11] B2=FE_OFN645_n29
XU386 AOI22S $PINS O=n416 A1=prime[11] A2=FE_OFN633_n371 B1=U[11]
+ B2=FE_OFN644_n397
XU387 AOI22S $PINS O=n417 A1=N59 A2=FE_OFN565_n13 B1=U[12] B2=FE_OFN645_n29
XU388 AOI22S $PINS O=n418 A1=prime[12] A2=FE_OFN633_n371 B1=U[12]
+ B2=FE_OFN644_n397
XU389 AOI22S $PINS O=n419 A1=N60 A2=FE_OFN565_n13 B1=U[13] B2=FE_OFN645_n29
XU390 AOI22S $PINS O=n420 A1=prime[13] A2=FE_OFN633_n371 B1=U[13]
+ B2=FE_OFN644_n397
XU391 AOI22S $PINS O=n421 A1=N61 A2=FE_OFN565_n13 B1=U[14] B2=FE_OFN645_n29
XU392 AOI22S $PINS O=n422 A1=prime[14] A2=FE_OFN633_n371 B1=U[14]
+ B2=FE_OFN644_n397
XU393 AOI22S $PINS O=n423 A1=N62 A2=FE_OFN565_n13 B1=U[15] B2=FE_OFN645_n29
XU394 AOI22S $PINS O=n424 A1=prime[15] A2=FE_OFN633_n371 B1=U[15]
+ B2=FE_OFN644_n397
XU395 AOI22S $PINS O=n425 A1=N63 A2=FE_OFN565_n13 B1=FE_PHN940_U_16
+ B2=FE_OFN645_n29
XU396 AOI22S $PINS O=n426 A1=prime[16] A2=FE_OFN633_n371 B1=FE_PHN940_U_16
+ B2=FE_OFN644_n397
XU397 AOI22S $PINS O=n427 A1=N64 A2=FE_OFN565_n13 B1=U[17] B2=FE_OFN645_n29
XU398 AOI22S $PINS O=n428 A1=prime[17] A2=FE_OFN633_n371 B1=U[17]
+ B2=FE_OFN644_n397
XU399 AOI22S $PINS O=n429 A1=N65 A2=FE_OFN565_n13 B1=FE_PHN1237_U_18
+ B2=FE_OFN645_n29
XU400 AOI22S $PINS O=n430 A1=prime[18] A2=FE_OFN633_n371 B1=FE_PHN1237_U_18
+ B2=FE_OFN644_n397
XU401 AOI22S $PINS O=n431 A1=N66 A2=FE_OFN565_n13 B1=FE_PHN1247_U_19
+ B2=FE_OFN645_n29
XU402 AOI22S $PINS O=n432 A1=prime[19] A2=FE_OFN633_n371 B1=FE_PHN1247_U_19
+ B2=FE_OFN644_n397
XU403 AOI22S $PINS O=n433 A1=N67 A2=FE_OFN565_n13 B1=FE_PHN1233_U_20
+ B2=FE_OFN645_n29
XU404 MOAI1S $PINS O=n540 A1=FE_OFN640_n A2=FE_DBTN86_S_4 B1=FE_OFN640_n
+ B2=n190
XU405 OAI112HS $PINS O=n190 A1=n191 B1=n192 C1=n720 C2=n742
XU406 AOI22S $PINS O=n191 A1=N83 A2=n14 B1=N361 B2=n104
XU407 AOI22S $PINS O=n192 A1=S[4] A2=n10 B1=div_in_0[4] B2=FE_DBTN94_n37
XU408 MOAI1S $PINS O=n531 A1=FE_OFN639_n A2=n752 B1=FE_OFN639_n B2=n163
XU409 OAI112HS $PINS O=n163 A1=n164 B1=n165 C1=FE_OFN567_n720 C2=FE_DBTN82_S_12
XU410 AOI22S $PINS O=n164 A1=N92 A2=FE_OFN365_FE_OFN78_n14 B1=N370
+ B2=FE_OFN561_n104
XU411 AOI22S $PINS O=n165 A1=S[13] A2=FE_OFN366_FE_OFN77_n10 B1=div_in_0[13]
+ B2=FE_OFN482_FE_DBTN94_n37
XU412 MOAI1S $PINS O=n533 A1=FE_OFN639_n A2=n750 B1=FE_OFN639_n B2=n169
XU413 OAI112HS $PINS O=n169 A1=n170 B1=n171 C1=n720 C2=FE_DBTN83_S_10
XU414 AOI22S $PINS O=n170 A1=N90 A2=n14 B1=N368 B2=n104
XU415 AOI22S $PINS O=n171 A1=S[11] A2=n10 B1=div_in_0[11] B2=FE_DBTN94_n37
XU416 MOAI1S $PINS O=n537 A1=FE_OFN640_n A2=n746 B1=FE_OFN640_n B2=n181
XU417 OAI112HS $PINS O=n181 A1=n182 B1=n183 C1=n720 C2=FE_DBTN85_S_6
XU418 AOI22S $PINS O=n182 A1=N86 A2=n14 B1=N364 B2=n104
XU419 AOI22S $PINS O=n183 A1=S[7] A2=n10 B1=div_in_0[7] B2=FE_DBTN94_n37
XU420 MOAI1S $PINS O=n539 A1=FE_OFN640_n A2=n744 B1=FE_OFN640_n B2=n187
XU421 OAI112HS $PINS O=n187 A1=n188 B1=n189 C1=n720 C2=FE_DBTN86_S_4
XU422 AOI22S $PINS O=n188 A1=N84 A2=n14 B1=N362 B2=n104
XU423 AOI22S $PINS O=n189 A1=S[5] A2=n10 B1=div_in_0[5] B2=FE_DBTN94_n37
XU424 MOAI1S $PINS O=n541 A1=FE_OFN640_n A2=n742 B1=FE_OFN640_n B2=n193
XU425 OAI112HS $PINS O=n193 A1=n194 B1=n195 C1=n720 C2=FE_DBTN87_S_2
XU426 AOI22S $PINS O=n194 A1=N82 A2=n14 B1=N360 B2=n104
XU427 AOI22S $PINS O=n195 A1=S[3] A2=n10 B1=div_in_0[3] B2=FE_DBTN94_n37
XU428 MOAI1S $PINS O=n534 A1=FE_OFN639_n A2=FE_DBTN83_S_10 B1=FE_OFN639_n
+ B2=n172
XU429 OAI112HS $PINS O=n172 A1=n173 B1=n174 C1=n720 C2=n748
XU430 AOI22S $PINS O=n174 A1=S[10] A2=n10 B1=div_in_0[10] B2=FE_DBTN94_n37
XU431 MOAI1S $PINS O=n536 A1=FE_OFN640_n A2=FE_DBTN84_S_8 B1=FE_OFN640_n
+ B2=n178
XU432 OAI112HS $PINS O=n178 A1=n179 B1=n180 C1=n720 C2=n746
XU433 AOI22S $PINS O=n179 A1=N87 A2=n14 B1=N365 B2=n104
XU434 AOI22S $PINS O=n180 A1=S[8] A2=n10 B1=div_in_0[8] B2=FE_DBTN94_n37
XU435 MOAI1S $PINS O=n563 A1=n285 A2=n35 B1=n35 B2=div_out[14]
XU436 AOI22S $PINS O=n286 A1=N93 A2=FE_OFN364_FE_OFN79_n15 B1=N336
+ B2=FE_OFN562_n212
XU437 MOAI1S $PINS O=n565 A1=n293 A2=n35 B1=n35 B2=div_out[12]
XU438 AOI22S $PINS O=n294 A1=N91 A2=FE_OFN79_n15 B1=N334 B2=n212
XU439 MOAI1S $PINS O=n529 A1=FE_OFN639_n A2=n754 B1=FE_OFN639_n B2=n157
XU440 OAI112HS $PINS O=n157 A1=n158 B1=n159 C1=FE_OFN567_n720 C2=FE_DBTN81_S_14
XU441 AOI22S $PINS O=n159 A1=S[15] A2=FE_OFN366_FE_OFN77_n10 B1=div_in_0[15]
+ B2=FE_OFN482_FE_DBTN94_n37
XU442 AOI22S $PINS O=n158 A1=N94 A2=FE_OFN365_FE_OFN78_n14 B1=N372
+ B2=FE_OFN561_n104
XU443 MOAI1S $PINS O=n535 A1=FE_OFN639_n A2=n748 B1=FE_OFN640_n B2=n175
XU444 AOI22S $PINS O=n177 A1=S[9] A2=n10 B1=div_in_0[9] B2=FE_DBTN94_n37
XU445 MOAI1S $PINS O=n530 A1=FE_OFN639_n A2=FE_DBTN81_S_14 B1=FE_OFN639_n
+ B2=n160
XU446 OAI112HS $PINS O=n160 A1=n161 B1=n162 C1=FE_OFN567_n720 C2=n752
XU447 AOI22S $PINS O=n161 A1=N93 A2=FE_OFN365_FE_OFN78_n14 B1=N371
+ B2=FE_OFN561_n104
XU448 AOI22S $PINS O=n162 A1=S[14] A2=FE_OFN366_FE_OFN77_n10 B1=div_in_0[14]
+ B2=FE_OFN482_FE_DBTN94_n37
XU449 MOAI1S $PINS O=n532 A1=FE_OFN639_n A2=FE_DBTN82_S_12 B1=FE_OFN639_n
+ B2=n166
XU450 OAI112HS $PINS O=n166 A1=n167 B1=n168 C1=n720 C2=n750
XU451 AOI22S $PINS O=n167 A1=N91 A2=n14 B1=N369 B2=n104
XU452 AOI22S $PINS O=n168 A1=S[12] A2=n10 B1=div_in_0[12]
+ B2=FE_OFN482_FE_DBTN94_n37
XU453 MOAI1S $PINS O=n538 A1=FE_OFN640_n A2=FE_DBTN85_S_6 B1=FE_OFN640_n
+ B2=n184
XU454 OAI112HS $PINS O=n184 A1=n185 B1=n186 C1=n720 C2=n744
XU455 AOI22S $PINS O=n185 A1=N85 A2=n14 B1=N363 B2=n104
XU456 AOI22S $PINS O=n186 A1=S[6] A2=n10 B1=div_in_0[6] B2=FE_DBTN94_n37
XU457 MOAI1S $PINS O=n542 A1=FE_OFN640_n A2=FE_DBTN87_S_2 B1=FE_OFN640_n
+ B2=n196
XU458 OAI112HS $PINS O=n196 A1=n197 B1=n198 C1=n720 C2=FE_DBTN88_S_1
XU459 AOI22S $PINS O=n198 A1=S[2] A2=n10 B1=div_in_0[2] B2=FE_DBTN94_n37
XU460 MOAI1S $PINS O=n543 A1=FE_OFN640_n A2=FE_DBTN88_S_1 B1=FE_OFN640_n
+ B2=n199
XU461 AOI22S $PINS O=n201 A1=S[1] A2=n10 B1=div_in_0[1] B2=FE_DBTN94_n37
XU462 MOAI1S $PINS O=n544 A1=n202 A2=FE_DBTN89_S_0 B1=FE_OFN640_n B2=n203
XU463 NR2 $PINS O=n202 I1=n35 I2=n10
XU464 AOI22S $PINS O=n344 A1=div_out[1] A2=n217 B1=FE_OFN79_n15 B2=N79
XU465 ND3 $PINS O=n458 I1=n38 I2=n721 I3=n509
XU466 AOI22S $PINS O=n509 A1=state[1] A2=n718 B1=sel_div B2=n51
XU467 ND3S $PINS O=n345 I1=FE_OCPN661_V_0 I2=U[0] I3=N32
XU468 MOAI1S $PINS O=n567 A1=n301 A2=n35 B1=n35 B2=div_out[10]
XU469 AOI22S $PINS O=n302 A1=N89 A2=FE_OFN79_n15 B1=N332 B2=n212
XU470 MOAI1S $PINS O=n569 A1=n309 A2=n35 B1=n35 B2=div_out[8]
XU471 MOAI1S $PINS O=n312 A1=n719 A2=FE_DBTN131_div_out_9 B1=N581 B2=n218
XU472 MOAI1S $PINS O=n571 A1=n317 A2=n35 B1=n35 B2=div_out[6]
XU473 MOAI1S $PINS O=n320 A1=n719 A2=FE_DBTN130_div_out_7 B1=N579 B2=n218
XU474 MOAI1S $PINS O=n573 A1=n325 A2=n35 B1=n35 B2=FE_OFN108_div_out_4
XU475 MOAI1S $PINS O=n328 A1=n719 A2=FE_DBTN129_div_out_5 B1=N577 B2=n218
XU476 MOAI1S $PINS O=n575 A1=n333 A2=n35 B1=n35 B2=div_out[2]
XU477 MOAI1S $PINS O=n336 A1=n719 A2=FE_DBTN128_div_out_3 B1=N575 B2=n218
XU478 AN2 $PINS O=n386 I1=U[0] I2=n345
XU479 AOI22S $PINS O=n339 A1=n217 A2=div_out[2] B1=N574 B2=n218
XU482 NR2 $PINS O=n508 I1=n723 I2=state[1]
XU483 INV1S $PINS O=n723 I=FE_PHN1249_state_0
XU484 AOI22S $PINS O=n347 A1=FE_PHN1001_i_9 A2=n18 B1=loop_num[9] B2=n205
XU536 AOI22S $PINS O=n348 A1=N46 A2=n722 B1=N568 B2=n9
XU542 AOI22S $PINS O=n350 A1=i[8] A2=n18 B1=loop_num[8] B2=n205
XU545 AOI22S $PINS O=n351 A1=N45 A2=n722 B1=N567 B2=n9
XU546 AOI22S $PINS O=n352 A1=i[7] A2=n18 B1=FE_PHN1535_loop_num_7 B2=n205
XU608 AOI22S $PINS O=n353 A1=N44 A2=n722 B1=N566 B2=n9
XU638 AO22 $PINS O=n43 A1=S[31] A2=n105 B1=S[32] B2=FE_OFN366_FE_OFN77_n10
XU641 OR2 $PINS O=n37 I1=state[0] I2=state[1]
XU643 AOI22S $PINS O=n358 A1=FE_PHN1113_N41 A2=n18 B1=loop_num[4] B2=n205
XU644 AOI22S $PINS O=n359 A1=FE_PHN1113_N41 A2=n722 B1=N563 B2=n9
XU645 AOI22S $PINS O=n360 A1=FE_PHN1108_N40 A2=n18 B1=loop_num[3] B2=n205
XU646 AOI22S $PINS O=n361 A1=FE_PHN1108_N40 A2=n722 B1=N562 B2=n9
XU647 AOI22S $PINS O=n362 A1=FE_PHN1123_N39 A2=n18 B1=loop_num[2] B2=n205
XU648 AOI22S $PINS O=n363 A1=FE_PHN1123_N39 A2=n722 B1=N561 B2=n9
XU649 AOI22S $PINS O=n364 A1=FE_PHN1136_N38 A2=n18 B1=loop_num[1] B2=n205
XU650 AOI22S $PINS O=n365 A1=FE_PHN1136_N38 A2=n722 B1=N560 B2=n9
XU651 AOI22S $PINS O=n510 A1=FE_PHN1138_N37 A2=n18 B1=FE_PHN1519_loop_num_0
+ B2=n205
XU652 AOI22S $PINS O=n511 A1=FE_PHN1138_N37 A2=n722 B1=N559 B2=n9
XU654 NR2P $PINS O=n217 I1=n342 I2=FE_OCPN664_div_out_0
XU655 AOI22S $PINS O=FE_PHN1414_n354 A1=i[6] A2=n18 B1=loop_num[6] B2=n205
XU656 AOI22S $PINS O=n355 A1=N43 A2=n722 B1=N565 B2=n9
XU657 AOI22S $PINS O=n356 A1=i[5] A2=n18 B1=loop_num[5] B2=n205
XU658 AOI22S $PINS O=n357 A1=N42 A2=n722 B1=N564 B2=n9
XU659 INV1S $PINS O=N42 I=i[5]
XU660 OR2 $PINS O=n38 I1=n51 I2=state[0]
XU661 INV1S $PINS O=n205 I=n38
XU677 INV1S $PINS O=n768 I=S[29]
XU678 INV1S $PINS O=n760 I=S[21]
XU679 INV1S $PINS O=n752 I=S[13]
XU680 INV1S $PINS O=n756 I=S[17]
XU681 INV1S $PINS O=n762 I=S[23]
XU682 INV1S $PINS O=n758 I=S[19]
XU683 INV1S $PINS O=n754 I=S[15]
XU684 INV1S $PINS O=n742 I=S[3]
XU685 INV1S $PINS O=n766 I=S[27]
XU686 INV1S $PINS O=n764 I=S[25]
XU687 INV1S $PINS O=n750 I=S[11]
XU688 INV1S $PINS O=n748 I=S[9]
XU689 INV1S $PINS O=n746 I=S[7]
XU690 INV1S $PINS O=n744 I=S[5]
XU711 AOI22S $PINS O=n343 A1=N322 A2=n212 B1=N637 B2=done_div_n
XU712 AN2 $PINS O=n104 I1=N355 I2=n205
XU713 AOI22S $PINS O=n200 A1=N80 A2=n14 B1=N358 B2=n104
XU714 AOI22S $PINS O=n197 A1=N81 A2=n14 B1=N359 B2=n104
XU715 OAI112HS $PINS O=n199 A1=n200 B1=n201 C1=n720 C2=FE_DBTN89_S_0
XU716 AOI22S $PINS O=n176 A1=N88 A2=n14 B1=N366 B2=n104
XU717 AOI22S $PINS O=n173 A1=N89 A2=n14 B1=N367 B2=n104
XU718 OAI112HS $PINS O=n175 A1=n176 B1=n177 C1=n720 C2=FE_DBTN84_S_8
XU719 AOI22S $PINS O=n146 A1=N98 A2=FE_OFN365_FE_OFN78_n14 B1=N376
+ B2=FE_OFN561_n104
XU720 AOI22S $PINS O=n143 A1=N99 A2=FE_OFN365_FE_OFN78_n14 B1=N377
+ B2=FE_OFN561_n104
XU721 OAI112HS $PINS O=n145 A1=n146 B1=n147 C1=FE_OFN567_n720 C2=FE_DBTN79_S_18
XU722 AOI22S $PINS O=n140 A1=N100 A2=FE_OFN365_FE_OFN78_n14 B1=N378
+ B2=FE_OFN561_n104
XU723 AOI22S $PINS O=n137 A1=N101 A2=FE_OFN365_FE_OFN78_n14 B1=N379
+ B2=FE_OFN561_n104
XU724 OAI112HS $PINS O=n139 A1=n140 B1=n141 C1=FE_OFN567_n720 C2=FE_DBTN78_S_20
XU725 AOI22S $PINS O=n134 A1=N102 A2=FE_OFN365_FE_OFN78_n14 B1=N380
+ B2=FE_OFN561_n104
XU726 AOI22S $PINS O=n131 A1=N103 A2=FE_OFN365_FE_OFN78_n14 B1=N381
+ B2=FE_OFN561_n104
XU727 OAI112HS $PINS O=n133 A1=n134 B1=n135 C1=FE_OFN567_n720 C2=FE_DBTN77_S_22
XU728 AOI22S $PINS O=n122 A1=N106 A2=FE_OFN365_FE_OFN78_n14 B1=N384
+ B2=FE_OFN561_n104
XU729 AOI22S $PINS O=n119 A1=N107 A2=FE_OFN365_FE_OFN78_n14 B1=N385
+ B2=FE_OFN561_n104
XU730 OAI112HS $PINS O=n121 A1=n122 B1=n123 C1=FE_OFN567_n720 C2=FE_DBTN75_S_26
XU732 AOI22S $PINS O=n389 A1=FE_PHN747_U_1 A2=n29 B1=FE_OFN338_n310 B2=n371
XU733 AOI22S $PINS O=n236 A1=N106 A2=FE_OFN364_FE_OFN79_n15 B1=N349
+ B2=FE_OFN562_n212
XU734 AOI22S $PINS O=n230 A1=N107 A2=FE_OFN364_FE_OFN79_n15 B1=N350
+ B2=FE_OFN562_n212
XU735 AOI22S $PINS O=n228 A1=N108 A2=FE_OFN364_FE_OFN79_n15 B1=N351
+ B2=FE_OFN562_n212
XU736 AOI22S $PINS O=n222 A1=N109 A2=FE_OFN364_FE_OFN79_n15 B1=N352
+ B2=FE_OFN562_n212
XU737 AOI22S $PINS O=n260 A1=N100 A2=FE_OFN364_FE_OFN79_n15 B1=N343
+ B2=FE_OFN562_n212
XU738 AOI22S $PINS O=n254 A1=N101 A2=FE_OFN364_FE_OFN79_n15 B1=N344
+ B2=FE_OFN562_n212
XU739 AOI22S $PINS O=n244 A1=N104 A2=FE_OFN364_FE_OFN79_n15 B1=N347
+ B2=FE_OFN562_n212
XU740 AOI22S $PINS O=n238 A1=N105 A2=FE_OFN364_FE_OFN79_n15 B1=N348
+ B2=FE_OFN562_n212
XU741 AOI22S $PINS O=n268 A1=N98 A2=FE_OFN364_FE_OFN79_n15 B1=N341
+ B2=FE_OFN562_n212
XU742 AOI22S $PINS O=n262 A1=N99 A2=FE_OFN364_FE_OFN79_n15 B1=N342
+ B2=FE_OFN562_n212
XU743 XNR2HS $PINS O=N46 I1=FE_PHN1001_i_9 I2=sub_3380/carry[9]
XU744 OR2 $PINS O=sub_3380/carry[9] I1=i[8] I2=sub_3380/carry[8]
XU745 XNR2HS $PINS O=N45 I1=sub_3380/carry[8] I2=i[8]
XU746 OR2 $PINS O=sub_3380/carry[8] I1=i[7] I2=sub_3380/carry[7]
XU747 XNR2HS $PINS O=N44 I1=sub_3380/carry[7] I2=i[7]
XU748 OR2 $PINS O=sub_3380/carry[7] I1=i[6] I2=i[5]
XU749 XNR2HS $PINS O=N43 I1=i[5] I2=i[6]
XU750 INV1S $PINS O=N559 I=loop_num[0]
XU752 AO12 $PINS O=N560 A1=n717 B1=loop_num[0] B2=loop_num[1]
XU753 NR2 $PINS O=n682 I1=n689 I2=loop_num[2]
XU754 AO12 $PINS O=N561 A1=n682 B1=n689 B2=loop_num[2]
XU755 NR2 $PINS O=n683 I1=n690 I2=loop_num[3]
XU756 AO12 $PINS O=N562 A1=n683 B1=n690 B2=loop_num[3]
XU757 NR2 $PINS O=n684 I1=n691 I2=loop_num[4]
XU758 AO12 $PINS O=N563 A1=n684 B1=n691 B2=loop_num[4]
XU759 NR2 $PINS O=n685 I1=n692 I2=loop_num[5]
XU760 AO12 $PINS O=N564 A1=n685 B1=n692 B2=loop_num[5]
XU761 NR2 $PINS O=n686 I1=n693 I2=loop_num[6]
XU762 AO12 $PINS O=N565 A1=n686 B1=n693 B2=loop_num[6]
XU763 NR2 $PINS O=n687 I1=n694 I2=loop_num[7]
XU764 AO12 $PINS O=N566 A1=n687 B1=n694 B2=loop_num[7]
XU765 XOR2HS $PINS O=N567 I1=loop_num[8] I2=n687
XU766 AN2B1S $PINS O=n688 I1=n687 B1=loop_num[8]
XU767 XOR2HS $PINS O=N568 I1=loop_num[9] I2=n688
XU768 NR2 $PINS O=n695 I1=FE_PHN1212_V_12 I2=FE_PHN1305_V_11
XU769 AN3B2S $PINS O=n713 I1=n695 B1=FE_PHN1310_V_10 B2=FE_OCPN661_V_0
XU770 NR2 $PINS O=n696 I1=FE_PHN1259_V_16 I2=V[15]
XU771 AN3B2S $PINS O=n712 I1=n696 B1=FE_PHN1213_V_14 B2=V[13]
XU772 NR2 $PINS O=n705 I1=V[25] I2=FE_PHN1267_V_24
XU773 NR2 $PINS O=n704 I1=V[27] I2=V[26]
XU774 NR2 $PINS O=n697 I1=V[30] I2=V[2]
XU775 AN3B2S $PINS O=n703 I1=n697 B1=V[29] B2=V[28]
XU776 NR2 $PINS O=n701 I1=V[3] I2=V[31]
XU777 NR2 $PINS O=n700 I1=FE_PHN1215_V_5 I2=V[4]
XU778 NR2 $PINS O=n698 I1=FE_PHN1312_V_9 I2=FE_PHN1322_V_8
XU779 AN3B2S $PINS O=n699 I1=n698 B1=V[7] B2=FE_PHN1219_V_6
XU780 ND3 $PINS O=n702 I1=n701 I2=n700 I3=n699
XU781 AN4B1S $PINS O=n711 I1=n705 I2=n704 I3=n703 B1=n702
XU782 NR2 $PINS O=n709 I1=V[18] I2=V[17]
XU783 NR2 $PINS O=n708 I1=FE_PHN1231_V_1 I2=V[19]
XU784 NR2 $PINS O=n706 I1=FE_PHN1276_V_23 I2=FE_PHN1250_V_22
XU785 AN3B2S $PINS O=n707 I1=n706 B1=FE_PHN1211_V_21 B2=V[20]
XU786 ND3 $PINS O=n710 I1=n709 I2=n708 I3=n707
XU787 AN4B1S $PINS O=N31 I1=n713 I2=n712 I3=n711 B1=n710
XU788 NR2 $PINS O=n717 I1=loop_num[1] I2=loop_num[0]
XU789 NR3 $PINS O=n716 I1=loop_num[2] I2=loop_num[4] I3=loop_num[3]
XU790 NR3 $PINS O=n714 I1=loop_num[7] I2=loop_num[9] I3=loop_num[8]
XU791 AN3B2S $PINS O=n715 I1=n714 B1=loop_num[6] B2=loop_num[5]
XU792 ND3 $PINS O=N569 I1=n717 I2=n716 I3=n715
.ENDS

.SUBCKT GFAU i_rst in_0[31] in_0[30] in_0[29] in_0[28] in_0[27] in_0[26]
+ in_0[25] in_0[24] in_0[23] in_0[22] in_0[21] in_0[20] in_0[19] in_0[18]
+ in_0[17] in_0[16] in_0[15] in_0[14] in_0[13] in_0[12] in_0[11] in_0[10]
+ in_0[9] in_0[8] in_0[7] in_0[6] in_0[5] in_0[4] in_0[3] in_0[2] in_0[1]
+ in_0[0] in_1[31] in_1[30] in_1[29] in_1[28] in_1[27] in_1[26] in_1[25]
+ in_1[24] in_1[23] in_1[22] in_1[21] in_1[20] in_1[19] in_1[18] in_1[17]
+ in_1[16] in_1[15] in_1[14] in_1[13] in_1[12] in_1[11] in_1[10] in_1[9]
+ in_1[8] in_1[7] in_1[6] in_1[5] in_1[4] in_1[3] in_1[2] in_1[1] in_1[0]
+ prime[31] prime[30] prime[29] prime[28] prime[27] prime[26] prime[25]
+ prime[24] prime[23] prime[22] prime[21] prime[20] prime[19] prime[18]
+ prime[17] prime[16] prime[15] prime[14] prime[13] prime[12] prime[11]
+ prime[10] prime[9] prime[8] prime[7] prime[6] prime[5] prime[4] prime[3]
+ prime[2] prime[1] prime[0] operation_select[1] operation_select[0]
+ GFAU_done_from_control result[31] result[30] result[29] result[28] result[27]
+ result[26] result[25] result[24] result[23] result[22] result[21] result[20]
+ result[19] result[18] result[17] result[16] result[15] result[14] result[13]
+ result[12] result[11] result[10] result[9] result[8] result[7] result[6]
+ result[5] result[4] result[3] result[2] result[1] result[0]
+ GFAU_done_to_control FE_OFN38_FE_DBTN1_i_i_rst FE_OFN17_FE_DBTN1_i_i_rst
+ FE_OFN13_FE_DBTN1_i_i_rst FE_OFN7_FE_DBTN1_i_i_rst FE_OFN4_FE_DBTN1_i_i_rst
+ FE_OFN51_raw_prime_30 FE_OFN55_raw_prime_29 FE_OFN61_raw_prime_27
+ FE_OFN65_raw_prime_26 FE_OFN69_raw_prime_25 FE_OFN75_raw_prime_23
+ FE_OFN79_raw_prime_22 FE_OFN83_raw_prime_21 FE_OFN89_raw_prime_19
+ FE_OFN93_raw_prime_18 FE_OFN97_raw_prime_17 FE_OFN101_raw_prime_16
+ FE_OFN114_raw_prime_12 FE_OFN142_raw_prime_8 FE_OFN166_n FE_OFN161_n
+ FE_OFN198_FE_OFN55_raw_prime_7 FE_OFN202_FE_OFN53_raw_prime_9
+ FE_OFN205_FE_OFN52_raw_prime_10 FE_OFN210_FE_OFN51_raw_prime_11
+ FE_OFN216_FE_OFN49_raw_prime_13 FE_OFN232_FE_OFN42_raw_prime_20
+ FE_OFN252_FE_OFN36_raw_prime_26 FE_OFN273_FE_OFN31_raw_prime_31
+ FE_OFN292_FE_OFN7_FE_DBTN1_i_i_rst FE_OFN302_FE_OFN5_FE_DBTN1_i_i_rst
+ FE_OFN299_FE_OFN5_FE_DBTN1_i_i_rst FE_OFN296_FE_OFN5_FE_DBTN1_i_i_rst
+ FE_OFN325_n i_clk_clone5 i_clk_clone6 i_clk_clone4 i_clk_clone3 i_clk_clone2
+ i_clk_clone1 i_clk
XFE_OCPC657_FE_OCPN344_FE_OFN86_n312 BUF1 $PINS
+ O=FE_OCPN662_FE_OCPN344_FE_OFN86_n312 I=FE_OCPN344_FE_OFN86_n312
XCTS_ccl_a_INV_i_clk_G0_L7_22 INV12CK $PINS O=CTS_18 I=CTS_19
XCTS_ccl_a_INV_i_clk_G0_L7_21 INV12CK $PINS O=CTS_17 I=CTS_19
XCTS_ccl_a_INV_i_clk_G0_L6_9 INV6CK $PINS O=CTS_19 I=i_clk
XCTS_ccl_a_INV_i_clk_G0_L7_8 INV12CK $PINS O=CTS_16 I=i_clk_clone6
XFE_OFC643_FE_OFN96_raw_prime_3 BUF2 $PINS O=FE_OFN351_FE_OFN96_raw_prime_3
+ I=prime[3]
XFE_OFC597_n10 BUF1 $PINS O=FE_OFN630_n10 I=n10
XFE_OFC596_n8 BUF1 $PINS O=FE_OFN629_n8 I=n8
XFE_OFC552_raw_prime_14 BUF1 $PINS O=FE_OFN585_n I=prime[14]
XFE_OFC551_raw_prime_4 BUF2CK $PINS O=FE_OFN584_n I=prime[4]
XFE_OFC535_n9 BUF1 $PINS O=FE_OFN568_n I=FE_OFN76_n9
XFE_OFC521_done_add BUF1 $PINS O=FE_OFN554_done_add I=done_add
XFE_OFC448_FE_OFN1_FE_DBTN1_i_i_rst BUF1 $PINS
+ O=FE_OFN481_FE_OFN1_FE_DBTN1_i_i_rst I=FE_OFN480_FE_OFN1_FE_DBTN1_i_i_rst
XFE_OFC447_FE_OFN1_FE_DBTN1_i_i_rst BUF1 $PINS
+ O=FE_OFN480_FE_OFN1_FE_DBTN1_i_i_rst I=FE_OFN1_FE_DBTN1_i_i_rst
XFE_OFC446_FE_OFN2_FE_DBTN1_i_i_rst BUF1 $PINS
+ O=FE_OFN479_FE_OFN2_FE_DBTN1_i_i_rst I=FE_OFN477_FE_OFN2_FE_DBTN1_i_i_rst
XFE_OFC445_FE_OFN2_FE_DBTN1_i_i_rst BUF1 $PINS
+ O=FE_OFN478_FE_OFN2_FE_DBTN1_i_i_rst I=FE_OFN2_FE_DBTN1_i_i_rst
XFE_OFC444_FE_OFN2_FE_DBTN1_i_i_rst BUF1 $PINS
+ O=FE_OFN477_FE_OFN2_FE_DBTN1_i_i_rst I=FE_OFN2_FE_DBTN1_i_i_rst
XFE_OFC443_FE_OFN3_FE_DBTN1_i_i_rst BUF1 $PINS
+ O=FE_OFN476_FE_OFN3_FE_DBTN1_i_i_rst I=FE_OFN475_FE_OFN3_FE_DBTN1_i_i_rst
XFE_OFC442_FE_OFN3_FE_DBTN1_i_i_rst BUF1 $PINS
+ O=FE_OFN475_FE_OFN3_FE_DBTN1_i_i_rst I=FE_OFN3_FE_DBTN1_i_i_rst
XFE_OFC437_FE_OFN5_FE_DBTN1_i_i_rst INV1S $PINS
+ O=FE_OFN470_FE_OFN5_FE_DBTN1_i_i_rst I=FE_OFN299_FE_OFN5_FE_DBTN1_i_i_rst
XFE_OFC434_FE_OFN6_FE_DBTN1_i_i_rst BUF1 $PINS
+ O=FE_OFN467_FE_OFN6_FE_DBTN1_i_i_rst I=FE_OFN13_FE_DBTN1_i_i_rst
XFE_OFC407_FE_OFN32_raw_prime_30 BUF1 $PINS O=FE_OFN440_FE_OFN32_raw_prime_30
+ I=FE_OFN51_raw_prime_30
XFE_OFC404_FE_OFN33_raw_prime_29 INV2 $PINS O=FE_OFN437_FE_OFN33_raw_prime_29
+ I=FE_OFN55_raw_prime_29
XFE_OFC402_FE_OFN34_raw_prime_28 BUF1 $PINS O=FE_OFN435_FE_OFN34_raw_prime_28
+ I=prime[28]
XFE_OFC400_FE_OFN35_raw_prime_27 BUF1 $PINS O=FE_OFN433_FE_OFN35_raw_prime_27
+ I=FE_OFN61_raw_prime_27
XFE_OFC398_FE_OFN36_raw_prime_26 BUF1 $PINS O=FE_OFN431_FE_OFN36_raw_prime_26
+ I=FE_OFN252_FE_OFN36_raw_prime_26
XFE_OFC396_FE_OFN37_raw_prime_25 BUF1 $PINS O=FE_OFN429_FE_OFN37_raw_prime_25
+ I=FE_OFN69_raw_prime_25
XFE_OFC394_FE_OFN38_raw_prime_24 BUF1 $PINS O=FE_OFN427_FE_OFN38_raw_prime_24
+ I=prime[24]
XFE_OFC392_FE_OFN39_raw_prime_23 BUF1 $PINS O=FE_OFN425_FE_OFN39_raw_prime_23
+ I=FE_OFN75_raw_prime_23
XFE_OFC390_FE_OFN40_raw_prime_22 BUF1 $PINS O=FE_OFN423_FE_OFN40_raw_prime_22
+ I=FE_OFN79_raw_prime_22
XFE_OFC386_FE_OFN42_raw_prime_20 BUF2CK $PINS O=FE_OFN419_FE_OFN42_raw_prime_20
+ I=FE_OFN232_FE_OFN42_raw_prime_20
XFE_OFC383_FE_OFN43_raw_prime_19 BUF1 $PINS O=FE_OFN416_FE_OFN43_raw_prime_19
+ I=FE_OFN89_raw_prime_19
XFE_OFC381_FE_OFN44_raw_prime_18 BUF1 $PINS O=FE_OFN414_FE_OFN44_raw_prime_18
+ I=FE_OFN93_raw_prime_18
XFE_OFC379_FE_OFN45_raw_prime_17 BUF1 $PINS O=FE_OFN412_FE_OFN45_raw_prime_17
+ I=FE_OFN97_raw_prime_17
XFE_OFC377_FE_OFN46_raw_prime_16 BUF1 $PINS O=FE_OFN410_FE_OFN46_raw_prime_16
+ I=FE_OFN408_FE_OFN46_raw_prime_16
XFE_OFC375_FE_OFN46_raw_prime_16 INV1S $PINS O=FE_OFN408_FE_OFN46_raw_prime_16
+ I=FE_OFN101_raw_prime_16
XFE_OFC373_FE_OFN49_raw_prime_13 BUF1 $PINS O=FE_OFN406_FE_OFN49_raw_prime_13
+ I=FE_OFN216_FE_OFN49_raw_prime_13
XFE_OFC371_FE_OFN50_raw_prime_12 BUF1 $PINS O=FE_OFN404_FE_OFN50_raw_prime_12
+ I=FE_OFN114_raw_prime_12
XFE_OFC369_FE_OFN51_raw_prime_11 INV2 $PINS O=FE_OFN402_FE_OFN51_raw_prime_11
+ I=FE_OFN210_FE_OFN51_raw_prime_11
XFE_OFC366_FE_OFN52_raw_prime_10 BUF1 $PINS O=FE_OFN399_FE_OFN52_raw_prime_10
+ I=FE_OFN205_FE_OFN52_raw_prime_10
XFE_OFC363_FE_OFN53_raw_prime_9 BUF1 $PINS O=FE_OFN396_FE_OFN53_raw_prime_9
+ I=FE_OFN202_FE_OFN53_raw_prime_9
XFE_OFC360_FE_OFN56_raw_prime_6 BUF2CK $PINS O=FE_OFN393_FE_OFN56_raw_prime_6
+ I=prime[6]
XFE_OFC357_FE_OFN57_raw_prime_5 BUF2CK $PINS O=FE_OFN390_FE_OFN57_raw_prime_5
+ I=prime[5]
XFE_OFC325_FE_OFN88_raw_prime_8 BUF1 $PINS O=FE_OFN358_FE_OFN88_raw_prime_8
+ I=prime[8]
XFE_OCPC311_FE_OFN86_n312 BUF2 $PINS O=FE_OCPN344_FE_OFN86_n312 I=prime[1]
XFE_OCPC310_FE_OFN338_n310 BUF1 $PINS O=FE_OCPN343_FE_OFN338_n310 I=prime[0]
XFE_OFC292_Py_mont_0 INV1S $PINS O=FE_OFN331_Py_mont_0 I=FE_OFN328_Py_mont_0
XFE_OFC289_Py_mont_0 INV2 $PINS O=FE_OFN328_Py_mont_0 I=in_1[0]
XFE_OFC248_Py_mont_4 INV1S $PINS O=FE_OFN114_Py_mont_4 I=FE_OFN112_Py_mont_4
XFE_OFC246_Py_mont_4 INV1S $PINS O=FE_OFN112_Py_mont_4 I=in_1[4]
XFE_OFC74_n9 BUF1 $PINS O=FE_OFN76_n9 I=n9
XFE_OFC3_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN3_FE_DBTN1_i_i_rst I=i_rst
XFE_OFC2_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN2_FE_DBTN1_i_i_rst I=i_rst
XFE_OFC1_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN1_FE_DBTN1_i_i_rst I=i_rst
XU79 ND2 $PINS O=result[9] I1=n6 I2=n7
XU80 ND2 $PINS O=result[8] I1=n11 I2=n12
XU81 ND2 $PINS O=result[7] I1=n13 I2=n14
XU82 ND2 $PINS O=result[6] I1=n15 I2=n16
XU83 ND2 $PINS O=result[5] I1=n17 I2=n18
XU84 ND2 $PINS O=result[4] I1=n19 I2=n20
XU85 ND2 $PINS O=result[3] I1=n21 I2=n22
XU86 ND2 $PINS O=result[31] I1=n23 I2=n24
XU87 ND2 $PINS O=result[30] I1=n25 I2=n26
XU88 ND2 $PINS O=result[2] I1=n27 I2=n28
XU89 ND2 $PINS O=result[29] I1=n29 I2=n30
XU90 ND2 $PINS O=result[28] I1=n31 I2=n32
XU91 ND2 $PINS O=result[27] I1=n33 I2=n34
XU92 ND2 $PINS O=result[26] I1=n35 I2=n36
XU93 ND2 $PINS O=result[25] I1=n37 I2=n38
XU94 ND2 $PINS O=result[24] I1=n39 I2=n40
XU95 ND2 $PINS O=result[23] I1=n41 I2=n42
XU96 ND2 $PINS O=result[22] I1=n43 I2=n44
XU97 ND2 $PINS O=result[21] I1=n45 I2=n46
XU98 ND2 $PINS O=result[20] I1=n47 I2=n48
XU99 ND2 $PINS O=result[1] I1=n49 I2=n50
XU100 ND2 $PINS O=result[19] I1=n51 I2=n52
XU101 ND2 $PINS O=result[18] I1=n53 I2=n54
XU102 ND2 $PINS O=result[17] I1=n55 I2=n56
XU103 ND2 $PINS O=result[16] I1=n57 I2=n58
XU104 ND2 $PINS O=result[15] I1=n59 I2=n60
XU105 ND2 $PINS O=result[14] I1=n61 I2=n62
XU106 ND2 $PINS O=result[13] I1=n63 I2=n64
XU107 ND2 $PINS O=result[12] I1=n65 I2=n66
XU108 ND2 $PINS O=result[11] I1=n67 I2=n68
XU109 ND2 $PINS O=result[10] I1=n69 I2=n70
XU110 ND2 $PINS O=result[0] I1=n71 I2=n72
XU111 AN3B2 $PINS O=n8 I1=n73 B1=done_mult B2=done_sub
XU112 AN2B1S $PINS O=n73 I1=done_div B1=FE_OFN554_done_add
Xadd_0 add $PINS i_rst=FE_OFN479_FE_OFN2_FE_DBTN1_i_i_rst add_in_0[31]=in_0[31]
+ add_in_0[30]=in_0[30] add_in_0[29]=in_0[29] add_in_0[28]=in_0[28]
+ add_in_0[27]=in_0[27] add_in_0[26]=in_0[26] add_in_0[25]=in_0[25]
+ add_in_0[24]=in_0[24] add_in_0[23]=in_0[23] add_in_0[22]=in_0[22]
+ add_in_0[21]=in_0[21] add_in_0[20]=in_0[20] add_in_0[19]=in_0[19]
+ add_in_0[18]=in_0[18] add_in_0[17]=in_0[17] add_in_0[16]=in_0[16]
+ add_in_0[15]=in_0[15] add_in_0[14]=in_0[14] add_in_0[13]=in_0[13]
+ add_in_0[12]=in_0[12] add_in_0[11]=in_0[11] add_in_0[10]=in_0[10]
+ add_in_0[9]=in_0[9] add_in_0[8]=in_0[8] add_in_0[7]=in_0[7] add_in_0[6]=in_0[6]
+ add_in_0[5]=in_0[5] add_in_0[4]=in_0[4] add_in_0[3]=in_0[3] add_in_0[2]=in_0[2]
+ add_in_0[1]=in_0[1] add_in_0[0]=in_0[0] add_in_1[31]=in_1[31]
+ add_in_1[30]=in_1[30] add_in_1[29]=in_1[29] add_in_1[28]=in_1[28]
+ add_in_1[27]=in_1[27] add_in_1[26]=in_1[26] add_in_1[25]=in_1[25]
+ add_in_1[24]=in_1[24] add_in_1[23]=in_1[23] add_in_1[22]=in_1[22]
+ add_in_1[21]=in_1[21] add_in_1[20]=in_1[20] add_in_1[19]=in_1[19]
+ add_in_1[18]=in_1[18] add_in_1[17]=in_1[17] add_in_1[16]=in_1[16]
+ add_in_1[15]=in_1[15] add_in_1[14]=in_1[14] add_in_1[13]=in_1[13]
+ add_in_1[12]=in_1[12] add_in_1[11]=in_1[11] add_in_1[10]=in_1[10]
+ add_in_1[9]=in_1[9] add_in_1[8]=in_1[8] add_in_1[7]=in_1[7] add_in_1[6]=in_1[6]
+ add_in_1[5]=in_1[5] add_in_1[4]=FE_OFN114_Py_mont_4 add_in_1[3]=in_1[3]
+ add_in_1[2]=in_1[2] add_in_1[1]=in_1[1] add_in_1[0]=FE_OFN331_Py_mont_0
+ prime[31]=FE_OFN273_FE_OFN31_raw_prime_31
+ prime[30]=FE_OFN440_FE_OFN32_raw_prime_30
+ prime[29]=FE_OFN437_FE_OFN33_raw_prime_29
+ prime[28]=FE_OFN435_FE_OFN34_raw_prime_28
+ prime[27]=FE_OFN433_FE_OFN35_raw_prime_27
+ prime[26]=FE_OFN252_FE_OFN36_raw_prime_26
+ prime[25]=FE_OFN429_FE_OFN37_raw_prime_25
+ prime[24]=FE_OFN427_FE_OFN38_raw_prime_24
+ prime[23]=FE_OFN425_FE_OFN39_raw_prime_23
+ prime[22]=FE_OFN423_FE_OFN40_raw_prime_22 prime[21]=FE_OFN83_raw_prime_21
+ prime[20]=FE_OFN419_FE_OFN42_raw_prime_20
+ prime[19]=FE_OFN416_FE_OFN43_raw_prime_19 prime[18]=FE_OFN93_raw_prime_18
+ prime[17]=FE_OFN412_FE_OFN45_raw_prime_17
+ prime[16]=FE_OFN410_FE_OFN46_raw_prime_16 prime[15]=FE_OFN325_n
+ prime[14]=FE_OFN585_n prime[13]=FE_OFN406_FE_OFN49_raw_prime_13
+ prime[12]=FE_OFN404_FE_OFN50_raw_prime_12
+ prime[11]=FE_OFN402_FE_OFN51_raw_prime_11
+ prime[10]=FE_OFN399_FE_OFN52_raw_prime_10
+ prime[9]=FE_OFN396_FE_OFN53_raw_prime_9 prime[8]=prime[8]
+ prime[7]=FE_OFN198_FE_OFN55_raw_prime_7 prime[6]=FE_OFN393_FE_OFN56_raw_prime_6
+ prime[5]=FE_OFN390_FE_OFN57_raw_prime_5 prime[4]=FE_OFN584_n prime[3]=prime[3]
+ prime[2]=prime[2] prime[1]=FE_OCPN662_FE_OCPN344_FE_OFN86_n312
+ prime[0]=FE_OCPN343_FE_OFN338_n310 sel_add=N1 add_out[31]=add_out[31]
+ add_out[30]=add_out[30] add_out[29]=add_out[29] add_out[28]=add_out[28]
+ add_out[27]=add_out[27] add_out[26]=add_out[26] add_out[25]=add_out[25]
+ add_out[24]=add_out[24] add_out[23]=add_out[23] add_out[22]=add_out[22]
+ add_out[21]=add_out[21] add_out[20]=add_out[20] add_out[19]=add_out[19]
+ add_out[18]=add_out[18] add_out[17]=add_out[17] add_out[16]=add_out[16]
+ add_out[15]=add_out[15] add_out[14]=add_out[14] add_out[13]=add_out[13]
+ add_out[12]=add_out[12] add_out[11]=add_out[11] add_out[10]=add_out[10]
+ add_out[9]=add_out[9] add_out[8]=add_out[8] add_out[7]=add_out[7]
+ add_out[6]=add_out[6] add_out[5]=add_out[5] add_out[4]=add_out[4]
+ add_out[3]=add_out[3] add_out[2]=add_out[2] add_out[1]=add_out[1]
+ add_out[0]=add_out[0] done_add=done_add
+ FE_OFN15_FE_DBTN1_i_i_rst=FE_OFN13_FE_DBTN1_i_i_rst
+ FE_OFN11_FE_DBTN1_i_i_rst=FE_OFN7_FE_DBTN1_i_i_rst
+ FE_OFN184_FE_OFN88_raw_prime_8=FE_OFN358_FE_OFN88_raw_prime_8
+ FE_OFN253_FE_OFN36_raw_prime_26=FE_OFN431_FE_OFN36_raw_prime_26
+ FE_OFN294_FE_OFN6_FE_DBTN1_i_i_rst=FE_OFN467_FE_OFN6_FE_DBTN1_i_i_rst
+ FE_OFN297_FE_OFN5_FE_DBTN1_i_i_rst=FE_OFN296_FE_OFN5_FE_DBTN1_i_i_rst
+ FE_OFN346_FE_OFN96_raw_prime_3=FE_OFN351_FE_OFN96_raw_prime_3
+ i_clk_clone3=CTS_16 i_clk_clone2=i_clk_clone5 i_clk_clone1=i_clk_clone2
+ i_clk=i_clk_clone1
Xsub_0 sub $PINS i_rst=FE_OFN479_FE_OFN2_FE_DBTN1_i_i_rst sub_in_0[31]=in_0[31]
+ sub_in_0[30]=in_0[30] sub_in_0[29]=in_0[29] sub_in_0[28]=in_0[28]
+ sub_in_0[27]=in_0[27] sub_in_0[26]=in_0[26] sub_in_0[25]=in_0[25]
+ sub_in_0[24]=in_0[24] sub_in_0[23]=in_0[23] sub_in_0[22]=in_0[22]
+ sub_in_0[21]=in_0[21] sub_in_0[20]=in_0[20] sub_in_0[19]=in_0[19]
+ sub_in_0[18]=in_0[18] sub_in_0[17]=in_0[17] sub_in_0[16]=in_0[16]
+ sub_in_0[15]=in_0[15] sub_in_0[14]=in_0[14] sub_in_0[13]=in_0[13]
+ sub_in_0[12]=in_0[12] sub_in_0[11]=in_0[11] sub_in_0[10]=in_0[10]
+ sub_in_0[9]=in_0[9] sub_in_0[8]=in_0[8] sub_in_0[7]=in_0[7] sub_in_0[6]=in_0[6]
+ sub_in_0[5]=in_0[5] sub_in_0[4]=in_0[4] sub_in_0[3]=in_0[3] sub_in_0[2]=in_0[2]
+ sub_in_0[1]=in_0[1] sub_in_0[0]=in_0[0] sub_in_1[31]=in_1[31]
+ sub_in_1[30]=in_1[30] sub_in_1[29]=in_1[29] sub_in_1[28]=in_1[28]
+ sub_in_1[27]=in_1[27] sub_in_1[26]=in_1[26] sub_in_1[25]=in_1[25]
+ sub_in_1[24]=in_1[24] sub_in_1[23]=in_1[23] sub_in_1[22]=in_1[22]
+ sub_in_1[21]=in_1[21] sub_in_1[20]=in_1[20] sub_in_1[19]=in_1[19]
+ sub_in_1[18]=in_1[18] sub_in_1[17]=in_1[17] sub_in_1[16]=in_1[16]
+ sub_in_1[15]=in_1[15] sub_in_1[14]=in_1[14] sub_in_1[13]=in_1[13]
+ sub_in_1[12]=in_1[12] sub_in_1[11]=in_1[11] sub_in_1[10]=in_1[10]
+ sub_in_1[9]=in_1[9] sub_in_1[8]=in_1[8] sub_in_1[7]=in_1[7] sub_in_1[6]=in_1[6]
+ sub_in_1[5]=in_1[5] sub_in_1[4]=in_1[4] sub_in_1[3]=in_1[3] sub_in_1[2]=in_1[2]
+ sub_in_1[1]=in_1[1] sub_in_1[0]=FE_OFN328_Py_mont_0
+ prime[31]=FE_OFN273_FE_OFN31_raw_prime_31 prime[30]=FE_OFN51_raw_prime_30
+ prime[29]=FE_OFN437_FE_OFN33_raw_prime_29 prime[28]=prime[28]
+ prime[27]=FE_OFN433_FE_OFN35_raw_prime_27
+ prime[26]=FE_OFN252_FE_OFN36_raw_prime_26
+ prime[25]=FE_OFN429_FE_OFN37_raw_prime_25 prime[24]=prime[24]
+ prime[23]=FE_OFN425_FE_OFN39_raw_prime_23 prime[22]=FE_OFN79_raw_prime_22
+ prime[21]=FE_OFN83_raw_prime_21 prime[20]=FE_OFN232_FE_OFN42_raw_prime_20
+ prime[19]=FE_OFN416_FE_OFN43_raw_prime_19 prime[18]=FE_OFN93_raw_prime_18
+ prime[17]=FE_OFN97_raw_prime_17 prime[16]=FE_OFN408_FE_OFN46_raw_prime_16
+ prime[15]=FE_OFN325_n prime[14]=prime[14]
+ prime[13]=FE_OFN216_FE_OFN49_raw_prime_13 prime[12]=FE_OFN114_raw_prime_12
+ prime[11]=FE_OFN402_FE_OFN51_raw_prime_11
+ prime[10]=FE_OFN205_FE_OFN52_raw_prime_10
+ prime[9]=FE_OFN396_FE_OFN53_raw_prime_9 prime[8]=prime[8]
+ prime[7]=FE_OFN198_FE_OFN55_raw_prime_7 prime[6]=prime[6]
+ prime[5]=FE_OFN390_FE_OFN57_raw_prime_5 prime[4]=prime[4] prime[3]=prime[3]
+ prime[2]=FE_OFN166_n prime[1]=prime[1] prime[0]=prime[0] sel_sub=N2
+ sub_out[31]=sub_out[31] sub_out[30]=sub_out[30] sub_out[29]=sub_out[29]
+ sub_out[28]=sub_out[28] sub_out[27]=sub_out[27] sub_out[26]=sub_out[26]
+ sub_out[25]=sub_out[25] sub_out[24]=sub_out[24] sub_out[23]=sub_out[23]
+ sub_out[22]=sub_out[22] sub_out[21]=sub_out[21] sub_out[20]=sub_out[20]
+ sub_out[19]=sub_out[19] sub_out[18]=sub_out[18] sub_out[17]=sub_out[17]
+ sub_out[16]=sub_out[16] sub_out[15]=sub_out[15] sub_out[14]=sub_out[14]
+ sub_out[13]=sub_out[13] sub_out[12]=sub_out[12] sub_out[11]=sub_out[11]
+ sub_out[10]=sub_out[10] sub_out[9]=sub_out[9] sub_out[8]=sub_out[8]
+ sub_out[7]=sub_out[7] sub_out[6]=sub_out[6] sub_out[5]=sub_out[5]
+ sub_out[4]=sub_out[4] sub_out[3]=sub_out[3] sub_out[2]=sub_out[2]
+ sub_out[1]=sub_out[1] sub_out[0]=sub_out[0] done_sub=done_sub
+ p1=FE_DBTN2_done_sub FE_OFN18_FE_DBTN1_i_i_rst=FE_OFN17_FE_DBTN1_i_i_rst
+ FE_OFN14_FE_DBTN1_i_i_rst=FE_OFN13_FE_DBTN1_i_i_rst
+ FE_OFN10_FE_DBTN1_i_i_rst=FE_OFN7_FE_DBTN1_i_i_rst
+ FE_OFN155_Py_mont_4=FE_OFN112_Py_mont_4 FE_OFN331_Py_mont_0=FE_OFN331_Py_mont_0
+ FE_OFN114_Py_mont_4=FE_OFN114_Py_mont_4
+ FE_OFN217_FE_OFN49_raw_prime_13=FE_OFN406_FE_OFN49_raw_prime_13
+ FE_OFN293_FE_OFN7_FE_DBTN1_i_i_rst=FE_OFN292_FE_OFN7_FE_DBTN1_i_i_rst
+ FE_OFN295_FE_OFN6_FE_DBTN1_i_i_rst=FE_OFN467_FE_OFN6_FE_DBTN1_i_i_rst
+ FE_OFN300_FE_OFN5_FE_DBTN1_i_i_rst=FE_OFN470_FE_OFN5_FE_DBTN1_i_i_rst
+ FE_OFN298_FE_OFN5_FE_DBTN1_i_i_rst=FE_OFN296_FE_OFN5_FE_DBTN1_i_i_rst
+ i_clk_clone2=i_clk_clone5 i_clk_clone1=i_clk_clone2 i_clk=i_clk_clone1
Xmult_0 mult $PINS i_rst=FE_OFN481_FE_OFN1_FE_DBTN1_i_i_rst
+ mult_in_0[31]=in_0[31] mult_in_0[30]=in_0[30] mult_in_0[29]=in_0[29]
+ mult_in_0[28]=in_0[28] mult_in_0[27]=in_0[27] mult_in_0[26]=in_0[26]
+ mult_in_0[25]=in_0[25] mult_in_0[24]=in_0[24] mult_in_0[23]=in_0[23]
+ mult_in_0[22]=in_0[22] mult_in_0[21]=in_0[21] mult_in_0[20]=in_0[20]
+ mult_in_0[19]=in_0[19] mult_in_0[18]=in_0[18] mult_in_0[17]=in_0[17]
+ mult_in_0[16]=in_0[16] mult_in_0[15]=in_0[15] mult_in_0[14]=in_0[14]
+ mult_in_0[13]=in_0[13] mult_in_0[12]=in_0[12] mult_in_0[11]=in_0[11]
+ mult_in_0[10]=in_0[10] mult_in_0[9]=in_0[9] mult_in_0[8]=in_0[8]
+ mult_in_0[7]=in_0[7] mult_in_0[6]=in_0[6] mult_in_0[5]=in_0[5]
+ mult_in_0[4]=in_0[4] mult_in_0[3]=in_0[3] mult_in_0[2]=in_0[2]
+ mult_in_0[1]=in_0[1] mult_in_0[0]=in_0[0] mult_in_1[31]=in_1[31]
+ mult_in_1[30]=in_1[30] mult_in_1[29]=in_1[29] mult_in_1[28]=in_1[28]
+ mult_in_1[27]=in_1[27] mult_in_1[26]=in_1[26] mult_in_1[25]=in_1[25]
+ mult_in_1[24]=in_1[24] mult_in_1[23]=in_1[23] mult_in_1[22]=in_1[22]
+ mult_in_1[21]=in_1[21] mult_in_1[20]=in_1[20] mult_in_1[19]=in_1[19]
+ mult_in_1[18]=in_1[18] mult_in_1[17]=in_1[17] mult_in_1[16]=in_1[16]
+ mult_in_1[15]=in_1[15] mult_in_1[14]=in_1[14] mult_in_1[13]=in_1[13]
+ mult_in_1[12]=in_1[12] mult_in_1[11]=in_1[11] mult_in_1[10]=in_1[10]
+ mult_in_1[9]=in_1[9] mult_in_1[8]=in_1[8] mult_in_1[7]=in_1[7]
+ mult_in_1[6]=in_1[6] mult_in_1[5]=in_1[5] mult_in_1[4]=FE_OFN114_Py_mont_4
+ mult_in_1[3]=in_1[3] mult_in_1[2]=in_1[2] mult_in_1[1]=in_1[1]
+ mult_in_1[0]=FE_OFN331_Py_mont_0 prime[31]=FE_OFN273_FE_OFN31_raw_prime_31
+ prime[30]=FE_OFN440_FE_OFN32_raw_prime_30
+ prime[29]=FE_OFN437_FE_OFN33_raw_prime_29
+ prime[28]=FE_OFN435_FE_OFN34_raw_prime_28
+ prime[27]=FE_OFN433_FE_OFN35_raw_prime_27
+ prime[26]=FE_OFN431_FE_OFN36_raw_prime_26
+ prime[25]=FE_OFN429_FE_OFN37_raw_prime_25
+ prime[24]=FE_OFN427_FE_OFN38_raw_prime_24
+ prime[23]=FE_OFN425_FE_OFN39_raw_prime_23
+ prime[22]=FE_OFN423_FE_OFN40_raw_prime_22 prime[21]=FE_OFN83_raw_prime_21
+ prime[20]=FE_OFN419_FE_OFN42_raw_prime_20
+ prime[19]=FE_OFN416_FE_OFN43_raw_prime_19
+ prime[18]=FE_OFN414_FE_OFN44_raw_prime_18
+ prime[17]=FE_OFN412_FE_OFN45_raw_prime_17
+ prime[16]=FE_OFN410_FE_OFN46_raw_prime_16 prime[15]=FE_OFN325_n
+ prime[14]=FE_OFN585_n prime[13]=FE_OFN406_FE_OFN49_raw_prime_13
+ prime[12]=FE_OFN404_FE_OFN50_raw_prime_12
+ prime[11]=FE_OFN402_FE_OFN51_raw_prime_11
+ prime[10]=FE_OFN399_FE_OFN52_raw_prime_10
+ prime[9]=FE_OFN396_FE_OFN53_raw_prime_9 prime[8]=FE_OFN358_FE_OFN88_raw_prime_8
+ prime[7]=FE_OFN198_FE_OFN55_raw_prime_7 prime[6]=FE_OFN393_FE_OFN56_raw_prime_6
+ prime[5]=FE_OFN390_FE_OFN57_raw_prime_5 prime[4]=FE_OFN584_n
+ prime[3]=FE_OFN351_FE_OFN96_raw_prime_3 prime[2]=prime[2] prime[1]=prime[1]
+ prime[0]=prime[0] sel_mult=N3 mult_out[31]=mult_out[31]
+ mult_out[30]=mult_out[30] mult_out[29]=mult_out[29] mult_out[28]=mult_out[28]
+ mult_out[27]=mult_out[27] mult_out[26]=mult_out[26] mult_out[25]=mult_out[25]
+ mult_out[24]=mult_out[24] mult_out[23]=mult_out[23] mult_out[22]=mult_out[22]
+ mult_out[21]=mult_out[21] mult_out[20]=mult_out[20] mult_out[19]=mult_out[19]
+ mult_out[18]=mult_out[18] mult_out[17]=mult_out[17] mult_out[16]=mult_out[16]
+ mult_out[15]=mult_out[15] mult_out[14]=mult_out[14] mult_out[13]=mult_out[13]
+ mult_out[12]=mult_out[12] mult_out[11]=mult_out[11] mult_out[10]=mult_out[10]
+ mult_out[9]=mult_out[9] mult_out[8]=mult_out[8] mult_out[7]=mult_out[7]
+ mult_out[6]=mult_out[6] mult_out[5]=mult_out[5] mult_out[4]=mult_out[4]
+ mult_out[3]=mult_out[3] mult_out[2]=mult_out[2] mult_out[1]=mult_out[1]
+ mult_out[0]=mult_out[0] done_mult=done_mult
+ FE_OFN8_FE_DBTN1_i_i_rst=FE_OFN7_FE_DBTN1_i_i_rst
+ FE_OFN3_FE_DBTN1_i_i_rst=FE_OFN476_FE_OFN3_FE_DBTN1_i_i_rst
+ FE_OFN1_FE_DBTN1_i_i_rst=FE_OFN477_FE_OFN2_FE_DBTN1_i_i_rst
+ FE_OFN164_n=FE_OFN161_n FE_OFN171_n310=prime[0]
+ FE_OCPN174_FE_OFN338_n310=FE_OCPN343_FE_OFN338_n310
+ FE_OCPN176_FE_OFN86_n312=FE_OCPN662_FE_OCPN344_FE_OFN86_n312
+ FE_OFN301_FE_OFN5_FE_DBTN1_i_i_rst=FE_OFN470_FE_OFN5_FE_DBTN1_i_i_rst
+ FE_OFN311_FE_OFN2_FE_DBTN1_i_i_rst=FE_OFN479_FE_OFN2_FE_DBTN1_i_i_rst
+ FE_OFN310_FE_OFN2_FE_DBTN1_i_i_rst=FE_OFN478_FE_OFN2_FE_DBTN1_i_i_rst
+ i_clk_clone4=CTS_16 i_clk_clone3=i_clk_clone2 i_clk_clone2=i_clk_clone1
+ i_clk_clone1=CTS_17 i_clk=CTS_18
Xdiv_0 div $PINS i_rst=FE_OFN1_FE_DBTN1_i_i_rst div_in_0[31]=in_0[31]
+ div_in_0[30]=in_0[30] div_in_0[29]=in_0[29] div_in_0[28]=in_0[28]
+ div_in_0[27]=in_0[27] div_in_0[26]=in_0[26] div_in_0[25]=in_0[25]
+ div_in_0[24]=in_0[24] div_in_0[23]=in_0[23] div_in_0[22]=in_0[22]
+ div_in_0[21]=in_0[21] div_in_0[20]=in_0[20] div_in_0[19]=in_0[19]
+ div_in_0[18]=in_0[18] div_in_0[17]=in_0[17] div_in_0[16]=in_0[16]
+ div_in_0[15]=in_0[15] div_in_0[14]=in_0[14] div_in_0[13]=in_0[13]
+ div_in_0[12]=in_0[12] div_in_0[11]=in_0[11] div_in_0[10]=in_0[10]
+ div_in_0[9]=in_0[9] div_in_0[8]=in_0[8] div_in_0[7]=in_0[7] div_in_0[6]=in_0[6]
+ div_in_0[5]=in_0[5] div_in_0[4]=in_0[4] div_in_0[3]=in_0[3] div_in_0[2]=in_0[2]
+ div_in_0[1]=in_0[1] div_in_0[0]=in_0[0] div_in_1[31]=in_1[31]
+ div_in_1[30]=in_1[30] div_in_1[29]=in_1[29] div_in_1[28]=in_1[28]
+ div_in_1[27]=in_1[27] div_in_1[26]=in_1[26] div_in_1[25]=in_1[25]
+ div_in_1[24]=in_1[24] div_in_1[23]=in_1[23] div_in_1[22]=in_1[22]
+ div_in_1[21]=in_1[21] div_in_1[20]=in_1[20] div_in_1[19]=in_1[19]
+ div_in_1[18]=in_1[18] div_in_1[17]=in_1[17] div_in_1[16]=in_1[16]
+ div_in_1[15]=in_1[15] div_in_1[14]=in_1[14] div_in_1[13]=in_1[13]
+ div_in_1[12]=in_1[12] div_in_1[11]=in_1[11] div_in_1[10]=in_1[10]
+ div_in_1[9]=in_1[9] div_in_1[8]=in_1[8] div_in_1[7]=in_1[7] div_in_1[6]=in_1[6]
+ div_in_1[5]=in_1[5] div_in_1[4]=FE_OFN114_Py_mont_4 div_in_1[3]=in_1[3]
+ div_in_1[2]=in_1[2] div_in_1[1]=in_1[1] div_in_1[0]=FE_OFN331_Py_mont_0
+ prime[31]=prime[31] prime[30]=prime[30] prime[29]=prime[29] prime[28]=prime[28]
+ prime[27]=prime[27] prime[26]=prime[26] prime[25]=prime[25] prime[24]=prime[24]
+ prime[23]=prime[23] prime[22]=prime[22] prime[21]=prime[21] prime[20]=prime[20]
+ prime[19]=prime[19] prime[18]=prime[18] prime[17]=prime[17] prime[16]=prime[16]
+ prime[15]=prime[15] prime[14]=prime[14] prime[13]=prime[13] prime[12]=prime[12]
+ prime[11]=prime[11] prime[10]=prime[10] prime[9]=prime[9]
+ prime[8]=FE_OFN358_FE_OFN88_raw_prime_8 prime[7]=prime[7] prime[6]=prime[6]
+ prime[5]=FE_OFN390_FE_OFN57_raw_prime_5 prime[4]=prime[4]
+ prime[3]=FE_OFN351_FE_OFN96_raw_prime_3 prime[2]=prime[2] prime[1]=prime[1]
+ prime[0]=prime[0] sel_div=N4 div_out[31]=div_out[31] div_out[30]=div_out[30]
+ div_out[29]=div_out[29] div_out[28]=div_out[28] div_out[27]=div_out[27]
+ div_out[26]=div_out[26] div_out[25]=div_out[25] div_out[24]=div_out[24]
+ div_out[23]=div_out[23] div_out[22]=div_out[22] div_out[21]=div_out[21]
+ div_out[20]=div_out[20] div_out[19]=div_out[19] div_out[18]=div_out[18]
+ div_out[17]=div_out[17] div_out[16]=div_out[16] div_out[15]=div_out[15]
+ div_out[14]=div_out[14] div_out[13]=div_out[13] div_out[12]=div_out[12]
+ div_out[11]=div_out[11] div_out[10]=div_out[10] div_out[9]=div_out[9]
+ div_out[8]=div_out[8] div_out[7]=div_out[7] div_out[6]=div_out[6]
+ div_out[5]=div_out[5] div_out[4]=div_out[4] div_out[3]=div_out[3]
+ div_out[2]=div_out[2] div_out[1]=div_out[1] div_out[0]=div_out[0]
+ done_div=done_div FE_OFN39_FE_DBTN1_i_i_rst=FE_OFN38_FE_DBTN1_i_i_rst
+ FE_OFN9_FE_DBTN1_i_i_rst=FE_OFN470_FE_OFN5_FE_DBTN1_i_i_rst
+ FE_OFN5_FE_DBTN1_i_i_rst=FE_OFN4_FE_DBTN1_i_i_rst
+ FE_OFN2_FE_DBTN1_i_i_rst=FE_OFN3_FE_DBTN1_i_i_rst
+ FE_OFN0_FE_DBTN1_i_i_rst=FE_OFN2_FE_DBTN1_i_i_rst
+ FE_OFN52_raw_prime_30=FE_OFN440_FE_OFN32_raw_prime_30
+ FE_OFN56_raw_prime_29=FE_OFN437_FE_OFN33_raw_prime_29
+ FE_OFN62_raw_prime_27=FE_OFN433_FE_OFN35_raw_prime_27
+ FE_OFN66_raw_prime_26=FE_OFN65_raw_prime_26
+ FE_OFN70_raw_prime_25=FE_OFN429_FE_OFN37_raw_prime_25
+ FE_OFN76_raw_prime_23=FE_OFN425_FE_OFN39_raw_prime_23
+ FE_OFN80_raw_prime_22=FE_OFN423_FE_OFN40_raw_prime_22
+ FE_OFN84_raw_prime_21=FE_OFN83_raw_prime_21
+ FE_OFN90_raw_prime_19=FE_OFN416_FE_OFN43_raw_prime_19
+ FE_OFN94_raw_prime_18=FE_OFN414_FE_OFN44_raw_prime_18
+ FE_OFN98_raw_prime_17=FE_OFN412_FE_OFN45_raw_prime_17
+ FE_OFN102_raw_prime_16=FE_OFN410_FE_OFN46_raw_prime_16
+ FE_OFN115_raw_prime_12=FE_OFN404_FE_OFN50_raw_prime_12
+ FE_OFN144_raw_prime_8=FE_OFN142_raw_prime_8 FE_OFN163_n=FE_OFN161_n
+ FE_OFN338_n310=FE_OCPN343_FE_OFN338_n310
+ FE_OCPN177_FE_OFN86_n312=FE_OCPN344_FE_OFN86_n312
+ FE_OFN195_FE_OFN56_raw_prime_6=FE_OFN393_FE_OFN56_raw_prime_6
+ FE_OFN199_FE_OFN55_raw_prime_7=FE_OFN198_FE_OFN55_raw_prime_7
+ FE_OFN203_FE_OFN53_raw_prime_9=FE_OFN396_FE_OFN53_raw_prime_9
+ FE_OFN208_FE_OFN52_raw_prime_10=FE_OFN399_FE_OFN52_raw_prime_10
+ FE_OFN211_FE_OFN51_raw_prime_11=FE_OFN402_FE_OFN51_raw_prime_11
+ FE_OFN219_FE_OFN49_raw_prime_13=FE_OFN406_FE_OFN49_raw_prime_13
+ FE_OFN233_FE_OFN42_raw_prime_20=FE_OFN419_FE_OFN42_raw_prime_20
+ FE_OFN245_FE_OFN38_raw_prime_24=FE_OFN427_FE_OFN38_raw_prime_24
+ FE_OFN254_FE_OFN36_raw_prime_26=FE_OFN431_FE_OFN36_raw_prime_26
+ FE_OFN262_FE_OFN34_raw_prime_28=FE_OFN435_FE_OFN34_raw_prime_28
+ FE_OFN274_FE_OFN31_raw_prime_31=FE_OFN273_FE_OFN31_raw_prime_31
+ FE_OFN303_FE_OFN5_FE_DBTN1_i_i_rst=FE_OFN302_FE_OFN5_FE_DBTN1_i_i_rst
+ FE_OFN307_FE_OFN3_FE_DBTN1_i_i_rst=FE_OFN476_FE_OFN3_FE_DBTN1_i_i_rst
+ FE_OFN306_FE_OFN3_FE_DBTN1_i_i_rst=FE_OFN475_FE_OFN3_FE_DBTN1_i_i_rst
+ FE_OFN309_FE_OFN2_FE_DBTN1_i_i_rst=FE_OFN478_FE_OFN2_FE_DBTN1_i_i_rst
+ FE_OFN308_FE_OFN2_FE_DBTN1_i_i_rst=FE_OFN477_FE_OFN2_FE_DBTN1_i_i_rst
+ FE_OFN313_FE_OFN1_FE_DBTN1_i_i_rst=FE_OFN481_FE_OFN1_FE_DBTN1_i_i_rst
+ FE_OFN312_FE_OFN1_FE_DBTN1_i_i_rst=FE_OFN480_FE_OFN1_FE_DBTN1_i_i_rst
+ FE_OFN319_n=FE_OFN584_n FE_OFN320_n=FE_OFN585_n FE_OFN326_n=FE_OFN325_n
+ i_clk_clone5=CTS_16 i_clk_clone4=i_clk_clone4 i_clk_clone3=i_clk_clone3
+ i_clk_clone2=i_clk_clone2 i_clk_clone1=CTS_17 i_clk=CTS_18
+ FE_OCPN350_FE_OCPN344_FE_OFN86_n312=FE_OCPN662_FE_OCPN344_FE_OFN86_n312
XU22 INV1S $PINS O=n124 I=operation_select[0]
XU23 INV1S $PINS O=n125 I=operation_select[1]
XU24 NR3 $PINS O=N4 I1=n125 I2=n121 I3=n124
XU25 NR3 $PINS O=N3 I1=n125 I2=operation_select[0] I3=n121
XU26 NR3 $PINS O=N2 I1=n124 I2=operation_select[1] I3=n121
XU32 INV1S $PINS O=n121 I=GFAU_done_from_control
XU33 NR3 $PINS O=N1 I1=n121 I2=operation_select[1] I3=operation_select[0]
XU34 INV1S $PINS O=n122 I=done_mult
XU35 NR2 $PINS O=n10 I1=FE_DBTN2_done_sub I2=FE_OFN554_done_add
XU51 ND3 $PINS O=GFAU_done_to_control I1=n122 I2=FE_DBTN2_done_sub I3=n74
XU52 NR2 $PINS O=n74 I1=done_div I2=FE_OFN554_done_add
XU65 NR3 $PINS O=n9 I1=FE_OFN554_done_add I2=done_sub I3=n122
XU66 AOI22S $PINS O=n49 A1=sub_out[1] A2=n10 B1=add_out[1]
+ B2=FE_OFN554_done_add
XU67 AOI22S $PINS O=n50 A1=div_out[1] A2=n8 B1=mult_out[1] B2=FE_OFN76_n9
XU68 AOI22S $PINS O=n67 A1=sub_out[11] A2=n10 B1=add_out[11]
+ B2=FE_OFN554_done_add
XU69 AOI22S $PINS O=n68 A1=div_out[11] A2=n8 B1=mult_out[11] B2=FE_OFN76_n9
XU70 AOI22S $PINS O=n55 A1=sub_out[17] A2=FE_OFN630_n10 B1=add_out[17]
+ B2=done_add
XU71 AOI22S $PINS O=n56 A1=div_out[17] A2=FE_OFN629_n8 B1=mult_out[17]
+ B2=FE_OFN568_n
XU72 AOI22S $PINS O=n37 A1=sub_out[25] A2=FE_OFN630_n10 B1=add_out[25]
+ B2=done_add
XU73 AOI22S $PINS O=n38 A1=div_out[25] A2=FE_OFN629_n8 B1=mult_out[25]
+ B2=FE_OFN568_n
XU74 AOI22S $PINS O=n33 A1=sub_out[27] A2=FE_OFN630_n10 B1=add_out[27]
+ B2=done_add
XU75 AOI22S $PINS O=n34 A1=div_out[27] A2=FE_OFN629_n8 B1=mult_out[27]
+ B2=FE_OFN568_n
XU76 AOI22S $PINS O=n17 A1=sub_out[5] A2=n10 B1=add_out[5]
+ B2=FE_OFN554_done_add
XU77 AOI22S $PINS O=n18 A1=div_out[5] A2=n8 B1=mult_out[5] B2=FE_OFN76_n9
XU78 AOI22S $PINS O=n13 A1=sub_out[7] A2=n10 B1=add_out[7]
+ B2=FE_OFN554_done_add
XU113 AOI22S $PINS O=n14 A1=div_out[7] A2=n8 B1=mult_out[7] B2=FE_OFN76_n9
XU114 AOI22S $PINS O=n6 A1=sub_out[9] A2=n10 B1=FE_OFN554_done_add
+ B2=add_out[9]
XU115 AOI22S $PINS O=n7 A1=div_out[9] A2=n8 B1=mult_out[9] B2=FE_OFN76_n9
XU116 AOI22S $PINS O=n23 A1=sub_out[31] A2=FE_OFN630_n10 B1=add_out[31]
+ B2=done_add
XU117 AOI22S $PINS O=n24 A1=div_out[31] A2=FE_OFN629_n8 B1=mult_out[31]
+ B2=FE_OFN568_n
XU118 AOI22S $PINS O=n71 A1=sub_out[0] A2=n10 B1=add_out[0]
+ B2=FE_OFN554_done_add
XU119 AOI22S $PINS O=n72 A1=div_out[0] A2=n8 B1=mult_out[0] B2=FE_OFN76_n9
XU120 AOI22S $PINS O=n63 A1=sub_out[13] A2=FE_OFN630_n10 B1=add_out[13]
+ B2=FE_OFN554_done_add
XU121 AOI22S $PINS O=n64 A1=div_out[13] A2=FE_OFN629_n8 B1=mult_out[13]
+ B2=FE_OFN568_n
XU122 AOI22S $PINS O=n45 A1=sub_out[21] A2=FE_OFN630_n10 B1=add_out[21]
+ B2=done_add
XU123 AOI22S $PINS O=n46 A1=div_out[21] A2=FE_OFN629_n8 B1=mult_out[21]
+ B2=FE_OFN568_n
XU124 AOI22S $PINS O=n29 A1=sub_out[29] A2=FE_OFN630_n10 B1=add_out[29]
+ B2=done_add
XU125 AOI22S $PINS O=n30 A1=div_out[29] A2=FE_OFN629_n8 B1=mult_out[29]
+ B2=FE_OFN568_n
XU126 AOI22S $PINS O=n21 A1=sub_out[3] A2=n10 B1=add_out[3]
+ B2=FE_OFN554_done_add
XU127 AOI22S $PINS O=n22 A1=div_out[3] A2=n8 B1=mult_out[3] B2=FE_OFN76_n9
XU128 AOI22S $PINS O=n59 A1=sub_out[15] A2=FE_OFN630_n10 B1=add_out[15]
+ B2=done_add
XU129 AOI22S $PINS O=n60 A1=div_out[15] A2=FE_OFN629_n8 B1=mult_out[15]
+ B2=FE_OFN568_n
XU130 AOI22S $PINS O=n51 A1=sub_out[19] A2=FE_OFN630_n10 B1=add_out[19]
+ B2=done_add
XU131 AOI22S $PINS O=n52 A1=div_out[19] A2=FE_OFN629_n8 B1=mult_out[19]
+ B2=FE_OFN568_n
XU132 AOI22S $PINS O=n41 A1=sub_out[23] A2=FE_OFN630_n10 B1=add_out[23]
+ B2=done_add
XU133 AOI22S $PINS O=n42 A1=div_out[23] A2=FE_OFN629_n8 B1=mult_out[23]
+ B2=FE_OFN568_n
XU134 AOI22S $PINS O=n27 A1=sub_out[2] A2=n10 B1=add_out[2]
+ B2=FE_OFN554_done_add
XU135 AOI22S $PINS O=n28 A1=div_out[2] A2=n8 B1=mult_out[2] B2=FE_OFN76_n9
XU136 AOI22S $PINS O=n19 A1=sub_out[4] A2=n10 B1=add_out[4]
+ B2=FE_OFN554_done_add
XU137 AOI22S $PINS O=n20 A1=div_out[4] A2=n8 B1=mult_out[4] B2=FE_OFN76_n9
XU138 AOI22S $PINS O=n15 A1=sub_out[6] A2=n10 B1=add_out[6]
+ B2=FE_OFN554_done_add
XU139 AOI22S $PINS O=n16 A1=div_out[6] A2=n8 B1=mult_out[6] B2=FE_OFN76_n9
XU140 AOI22S $PINS O=n11 A1=sub_out[8] A2=n10 B1=add_out[8]
+ B2=FE_OFN554_done_add
XU141 AOI22S $PINS O=n12 A1=div_out[8] A2=n8 B1=mult_out[8] B2=FE_OFN76_n9
XU142 AOI22S $PINS O=n69 A1=sub_out[10] A2=n10 B1=add_out[10]
+ B2=FE_OFN554_done_add
XU143 AOI22S $PINS O=n70 A1=div_out[10] A2=n8 B1=mult_out[10] B2=FE_OFN76_n9
XU144 AOI22S $PINS O=n65 A1=sub_out[12] A2=FE_OFN630_n10 B1=add_out[12]
+ B2=FE_OFN554_done_add
XU145 AOI22S $PINS O=n66 A1=div_out[12] A2=FE_OFN629_n8 B1=mult_out[12]
+ B2=FE_OFN568_n
XU146 AOI22S $PINS O=n61 A1=sub_out[14] A2=FE_OFN630_n10 B1=add_out[14]
+ B2=FE_OFN554_done_add
XU147 AOI22S $PINS O=n62 A1=div_out[14] A2=FE_OFN629_n8 B1=mult_out[14]
+ B2=FE_OFN568_n
XU148 AOI22S $PINS O=n57 A1=sub_out[16] A2=FE_OFN630_n10 B1=add_out[16]
+ B2=done_add
XU149 AOI22S $PINS O=n58 A1=div_out[16] A2=FE_OFN629_n8 B1=mult_out[16]
+ B2=FE_OFN568_n
XU150 AOI22S $PINS O=n53 A1=sub_out[18] A2=FE_OFN630_n10 B1=add_out[18]
+ B2=done_add
XU151 AOI22S $PINS O=n54 A1=div_out[18] A2=FE_OFN629_n8 B1=mult_out[18]
+ B2=FE_OFN568_n
XU152 AOI22S $PINS O=n47 A1=sub_out[20] A2=FE_OFN630_n10 B1=add_out[20]
+ B2=done_add
XU153 AOI22S $PINS O=n48 A1=div_out[20] A2=FE_OFN629_n8 B1=mult_out[20]
+ B2=FE_OFN568_n
XU154 AOI22S $PINS O=n43 A1=sub_out[22] A2=FE_OFN630_n10 B1=add_out[22]
+ B2=done_add
XU155 AOI22S $PINS O=n44 A1=div_out[22] A2=FE_OFN629_n8 B1=mult_out[22]
+ B2=FE_OFN568_n
XU156 AOI22S $PINS O=n39 A1=sub_out[24] A2=FE_OFN630_n10 B1=add_out[24]
+ B2=done_add
XU157 AOI22S $PINS O=n40 A1=div_out[24] A2=FE_OFN629_n8 B1=mult_out[24]
+ B2=FE_OFN568_n
XU158 AOI22S $PINS O=n35 A1=sub_out[26] A2=FE_OFN630_n10 B1=add_out[26]
+ B2=done_add
XU159 AOI22S $PINS O=n36 A1=div_out[26] A2=FE_OFN629_n8 B1=mult_out[26]
+ B2=FE_OFN568_n
XU160 AOI22S $PINS O=n31 A1=sub_out[28] A2=FE_OFN630_n10 B1=add_out[28]
+ B2=done_add
XU161 AOI22S $PINS O=n32 A1=div_out[28] A2=FE_OFN629_n8 B1=mult_out[28]
+ B2=FE_OFN568_n
XU162 AOI22S $PINS O=n25 A1=sub_out[30] A2=FE_OFN630_n10 B1=add_out[30]
+ B2=done_add
XU163 AOI22S $PINS O=n26 A1=div_out[30] A2=FE_OFN629_n8 B1=mult_out[30]
+ B2=FE_OFN568_n
.ENDS

.SUBCKT key_shift i_rst k[31] k[30] k[29] k[28] k[27] k[26] k[25] k[24] k[23]
+ k[22] k[21] k[20] k[19] k[18] k[17] k[16] k[15] k[14] k[13] k[12] k[11] k[10]
+ k[9] k[8] k[7] k[6] k[5] k[4] k[3] k[2] k[1] k[0] key_shift_done_from_control
+ k_out[1] k_out[0] key_shift_done_to_control FE_OFN339_n i_clk
XU71 OA112 $PINS O=n18 A1=n28 B1=n29 C1=key_shift_done_from_control C2=n27
XU72 OR2B1S $PINS O=state_n[1] I1=n31 B1=n32
XU73 ND2 $PINS O=k_out[1] I1=n49 I2=n50
XU74 ND2 $PINS O=k_out[0] I1=n59 I2=n60
XU75 ND2 $PINS O=n28 I1=n65 I2=n66
XU76 ND2 $PINS O=n27 I1=n65 I2=n67
XU77 ND2 $PINS O=n48 I1=n68 I2=n66
XU78 ND2 $PINS O=n37 I1=n68 I2=n67
XU79 ND2 $PINS O=n43 I1=n69 I2=n66
XU80 ND2 $PINS O=n21 I1=n69 I2=n67
XU81 ND2 $PINS O=n46 I1=n66 I2=n70
XU82 ND2 $PINS O=n38 I1=n67 I2=n70
XU83 ND2 $PINS O=n20 I1=n76 I2=n65
XU84 ND2 $PINS O=n47 I1=n75 I2=n70
Xstate_reg[0] QDFFRBN $PINS Q=state[0] D=state_n[0] CK=i_clk RB=FE_OFN339_n
Xstate_reg[1] QDFFRBN $PINS Q=state[1] D=state_n[1] CK=i_clk RB=i_rst
Xstate_reg[3] QDFFRBN $PINS Q=state[3] D=state_n[3] CK=i_clk RB=FE_OFN339_n
Xstate_reg[2] QDFFRBN $PINS Q=state[2] D=state_n[2] CK=i_clk RB=i_rst
XU3 INV1S $PINS O=n4 I=n27
XU4 INV1S $PINS O=n15 I=key_shift_done_from_control
XU5 AOI22S $PINS O=n32 A1=n33 A2=n15 B1=key_shift_done_from_control B2=n34
XU6 INV1S $PINS O=n10 I=n48
XU7 INV1S $PINS O=n3 I=n37
XU8 INV1S $PINS O=n1 I=n38
XU9 INV1S $PINS O=n9 I=n43
XU10 INV1S $PINS O=n2 I=n21
XU11 INV1S $PINS O=n8 I=n46
XU12 INV1S $PINS O=n5 I=n20
XU13 INV1S $PINS O=n11 I=n28
XU14 INV1S $PINS O=n7 I=n47
XU15 OAI22S $PINS O=state_n[0] A1=n35 A2=n15 B1=key_shift_done_from_control
+ B2=n36
XU16 NR3 $PINS O=n35 I1=n42 I2=n25 I3=n31
XU17 NR2 $PINS O=n36 I1=n33 I2=n34
XU18 ND3 $PINS O=n42 I1=n46 I2=n47 I3=n48
XU19 NR2 $PINS O=n29 I1=n10 I2=n3
XU20 ND3 $PINS O=state_n[3] I1=n17 I2=n18 I3=n19
XU21 NR3 $PINS O=n19 I1=n9 I2=n8 I3=n1
XU22 OA12 $PINS O=n17 A1=n21 B1=n20 B2=n15
XU23 ND3 $PINS O=state_n[2] I1=n22 I2=n18 I3=n23
XU24 NR3 $PINS O=n23 I1=n24 I2=n25 I3=n26
XU25 OA22S $PINS O=n22 A1=n15 A2=n30 B1=n20 B2=key_shift_done_from_control
XU26 ND3 $PINS O=n33 I1=n20 I2=n27 I3=n30
XU27 NR2 $PINS O=n30 I1=n41 I2=n2
XU28 ND3 $PINS O=n34 I1=n37 I2=n38 I3=n39
XU29 NR2 $PINS O=n39 I1=n26 I2=n40
XU30 ND3 $PINS O=n31 I1=n28 I2=n43 I3=n44
XU31 NR2 $PINS O=n44 I1=n24 I2=n45
XU32 NR2 $PINS O=n67 I1=n6 I2=n13
XU33 NR2 $PINS O=n65 I1=n14 I2=n12
XU34 AN2 $PINS O=n26 I1=n76 I2=n68
XU35 AN2 $PINS O=n24 I1=n75 I2=n65
XU36 AN4S $PINS O=n50 I1=n51 I2=n52 I3=n53 I4=n54
XU37 AN4S $PINS O=n49 I1=n55 I2=n56 I3=n57 I4=n58
XU38 AN2 $PINS O=n25 I1=n75 I2=n68
XU39 AN2 $PINS O=n41 I1=n76 I2=n69
XU40 AN2 $PINS O=n40 I1=n76 I2=n70
XU41 AN2 $PINS O=n45 I1=n75 I2=n69
XU42 AN4S $PINS O=n60 I1=n61 I2=n62 I3=n63 I4=n64
XU43 AN4S $PINS O=n59 I1=n71 I2=n72 I3=n73 I4=n74
XU44 AOI22S $PINS O=n62 A1=k[8] A2=n2 B1=k[10] B2=n9
XU45 AOI22S $PINS O=n52 A1=k[9] A2=n2 B1=k[11] B2=n9
XU46 AOI22S $PINS O=n63 A1=k[4] A2=n3 B1=k[6] B2=n10
XU47 AOI22S $PINS O=n53 A1=k[5] A2=n3 B1=k[7] B2=n10
XU48 AOI22S $PINS O=n74 A1=k[16] A2=n5 B1=k[18] B2=n24
XU49 AOI22S $PINS O=n58 A1=k[17] A2=n5 B1=k[19] B2=n24
XU50 AOI22S $PINS O=n61 A1=k[12] A2=n1 B1=k[14] B2=n8
XU51 AOI22S $PINS O=n51 A1=k[13] A2=n1 B1=k[15] B2=n8
XU52 AOI22S $PINS O=n64 A1=k[0] A2=n4 B1=k[2] B2=n11
XU53 AOI22S $PINS O=n54 A1=k[1] A2=n4 B1=k[3] B2=n11
XU54 AOI22S $PINS O=n71 A1=k[28] A2=n40 B1=k[30] B2=n7
XU55 AOI22S $PINS O=n55 A1=k[29] A2=n40 B1=k[31] B2=n7
XU56 AOI22S $PINS O=n72 A1=k[24] A2=n41 B1=k[26] B2=n45
XU57 AOI22S $PINS O=n56 A1=k[25] A2=n41 B1=k[27] B2=n45
XU58 NR2 $PINS O=n70 I1=state[2] I2=state[1]
XU59 NR2 $PINS O=n66 I1=n13 I2=state[0]
XU60 AOI22S $PINS O=n73 A1=k[20] A2=n26 B1=k[22] B2=n25
XU61 AOI22S $PINS O=n57 A1=k[21] A2=n26 B1=k[23] B2=n25
XU62 NR2 $PINS O=n68 I1=n14 I2=state[1]
XU63 NR2 $PINS O=n69 I1=n12 I2=state[2]
XU64 NR2 $PINS O=n76 I1=n6 I2=state[3]
XU65 NR2 $PINS O=n75 I1=state[3] I2=state[0]
XU66 INV1S $PINS O=n14 I=state[2]
XU67 INV1S $PINS O=n6 I=state[0]
XU68 INV1S $PINS O=n13 I=state[3]
XU69 INV1S $PINS O=n12 I=state[1]
.ENDS

.SUBCKT ECC_Lookup i_rst i_clk i_start a[3] a[2] a[1] a[0] prime[3] prime[2]
+ prime[1] prime[0] k[3] k[2] k[1] k[0] Px[3] Px[2] Px[1] Px[0] Py[3] Py[2]
+ Py[1] Py[0] kPx[3] kPx[2] kPx[1] kPx[0] kPy[3] kPy[2] kPy[1] kPy[0] done
XFE_PHC1505_raw_k_6 BUF1CK $PINS O=FE_PHN1505_raw_k_6 I=FE_PHN1082_raw_k_6
XFE_PHC1503_raw_k_1 BUF1CK $PINS O=FE_PHN1503_raw_k_1 I=FE_PHN1086_raw_k_1
XFE_PHC1495_raw_k_10 BUF1CK $PINS O=FE_PHN1495_raw_k_10 I=FE_PHN1089_raw_k_10
XFE_PHC1490_raw_k_2 BUF1CK $PINS O=FE_PHN1490_raw_k_2 I=raw_k[2]
XFE_PHC1487_raw_k_26 BUF1CK $PINS O=FE_PHN1487_raw_k_26 I=FE_PHN1111_raw_k_26
XFE_PHC1338_raw1_0 BUF1CK $PINS O=FE_PHN1338_raw1_0 I=raw1[0]
XFE_PHC1332_raw_a_4 BUF1CK $PINS O=raw_a[4] I=FE_PHN1332_raw_a_4
XFE_PHC1330_raw_a_7 BUF1CK $PINS O=raw_a[7] I=FE_PHN1330_raw_a_7
XFE_PHC1321_raw2_6 BUF1CK $PINS O=raw2[6] I=FE_PHN1321_raw2_6
XFE_PHC1318_raw2_7 BUF1CK $PINS O=raw2[7] I=FE_PHN1318_raw2_7
XFE_PHC1317_raw2_4 BUF1CK $PINS O=FE_PHN1317_raw2_4 I=raw2[4]
XFE_PHC1316_raw_a_2 BUF1CK $PINS O=raw_a[2] I=FE_PHN1316_raw_a_2
XFE_PHC1313_raw2_5 BUF1CK $PINS O=FE_PHN1313_raw2_5 I=raw2[5]
XFE_PHC1311_raw2_3 BUF1CK $PINS O=raw2[3] I=FE_PHN1311_raw2_3
XFE_PHC1307_raw_a_3 BUF1CK $PINS O=raw_a[3] I=FE_PHN1307_raw_a_3
XFE_PHC1304_raw2_12 BUF1CK $PINS O=raw2[12] I=FE_PHN1304_raw2_12
XFE_PHC1303_raw_a_5 BUF1CK $PINS O=FE_PHN1303_raw_a_5 I=raw_a[5]
XFE_PHC1302_raw_a_1 BUF1CK $PINS O=raw_a[1] I=FE_PHN1302_raw_a_1
XFE_PHC1299_raw2_8 BUF1CK $PINS O=FE_PHN1299_raw2_8 I=raw2[8]
XFE_PHC1296_raw_a_10 BUF1CK $PINS O=FE_PHN1296_raw_a_10 I=raw_a[10]
XFE_PHC1295_raw_a_0 BUF1S $PINS O=FE_PHN1295_raw_a_0 I=raw_a[0]
XFE_PHC1292_raw2_2 BUF1CK $PINS O=FE_PHN1292_raw2_2 I=raw2[2]
XFE_PHC1291_raw2_11 BUF1CK $PINS O=raw2[11] I=FE_PHN1291_raw2_11
XFE_PHC1289_raw2_1 BUF1S $PINS O=raw2[1] I=FE_PHN1289_raw2_1
XFE_PHC1288_raw_a_8 BUF1CK $PINS O=FE_PHN1288_raw_a_8 I=raw_a[8]
XFE_PHC1287_raw2_0 BUF1S $PINS O=raw2[0] I=FE_PHN1287_raw2_0
XFE_PHC1286_raw2_9 BUF1CK $PINS O=FE_PHN1286_raw2_9 I=raw2[9]
XFE_PHC1285_raw2_13 BUF1CK $PINS O=FE_PHN1285_raw2_13 I=raw2[13]
XFE_PHC1284_raw_a_9 BUF1CK $PINS O=raw_a[9] I=FE_PHN1284_raw_a_9
XFE_PHC1283_raw2_10 BUF1CK $PINS O=raw2[10] I=FE_PHN1283_raw2_10
XFE_PHC1281_raw_a_11 BUF1CK $PINS O=raw_a[11] I=FE_PHN1281_raw_a_11
XFE_PHC1280_raw_a_15 BUF1CK $PINS O=FE_PHN1280_raw_a_15 I=raw_a[15]
XFE_PHC1279_raw_a_12 BUF1CK $PINS O=raw_a[12] I=FE_PHN1279_raw_a_12
XFE_PHC1278_raw_a_14 BUF1CK $PINS O=raw_a[14] I=FE_PHN1278_raw_a_14
XFE_PHC1272_raw2_14 BUF1CK $PINS O=raw2[14] I=FE_PHN1272_raw2_14
XFE_PHC1266_raw_a_16 BUF1CK $PINS O=FE_PHN1266_raw_a_16 I=raw_a[16]
XFE_PHC1265_raw_a_13 BUF1CK $PINS O=raw_a[13] I=FE_PHN1265_raw_a_13
XFE_PHC1264_raw2_15 BUF1CK $PINS O=FE_PHN1264_raw2_15 I=raw2[15]
XFE_PHC1256_raw2_30 BUF1CK $PINS O=raw2[30] I=FE_PHN1256_raw2_30
XFE_PHC1255_raw2_28 BUF1CK $PINS O=FE_PHN1255_raw2_28 I=raw2[28]
XFE_PHC1252_raw_a_30 BUF1CK $PINS O=raw_a[30] I=FE_PHN1252_raw_a_30
XFE_PHC1251_raw2_29 BUF1CK $PINS O=raw2[29] I=FE_PHN1251_raw2_29
XFE_PHC1243_raw2_21 BUF1CK $PINS O=raw2[21] I=FE_PHN1243_raw2_21
XFE_PHC1241_raw2_23 BUF1CK $PINS O=raw2[23] I=FE_PHN1241_raw2_23
XFE_PHC1240_raw2_16 BUF1CK $PINS O=raw2[16] I=FE_PHN1240_raw2_16
XFE_PHC1239_raw_a_24 BUF1CK $PINS O=raw_a[24] I=FE_PHN1239_raw_a_24
XFE_PHC1238_raw_a_26 BUF1CK $PINS O=raw_a[26] I=FE_PHN1238_raw_a_26
XFE_PHC1236_raw2_26 BUF1CK $PINS O=raw2[26] I=FE_PHN1236_raw2_26
XFE_PHC1234_raw_a_28 BUF1CK $PINS O=raw_a[28] I=FE_PHN1234_raw_a_28
XFE_PHC1230_raw_a_29 BUF1CK $PINS O=raw_a[29] I=FE_PHN1230_raw_a_29
XFE_PHC1229_raw_a_27 BUF1CK $PINS O=raw_a[27] I=FE_PHN1229_raw_a_27
XFE_PHC1228_raw2_25 BUF1CK $PINS O=raw2[25] I=FE_PHN1228_raw2_25
XFE_PHC1227_raw2_24 BUF1CK $PINS O=FE_PHN1227_raw2_24 I=raw2[24]
XFE_PHC1223_raw_a_25 BUF1CK $PINS O=raw_a[25] I=FE_PHN1223_raw_a_25
XFE_PHC1222_raw_a_17 BUF1CK $PINS O=raw_a[17] I=FE_PHN1222_raw_a_17
XFE_PHC1221_raw2_27 BUF1CK $PINS O=raw2[27] I=FE_PHN1221_raw2_27
XFE_PHC1220_raw_a_18 BUF1CK $PINS O=raw_a[18] I=FE_PHN1220_raw_a_18
XFE_PHC1218_raw_a_19 BUF1CK $PINS O=raw_a[19] I=FE_PHN1218_raw_a_19
XFE_PHC1216_raw2_17 BUF1CK $PINS O=FE_PHN1216_raw2_17 I=raw2[17]
XFE_PHC1214_raw_a_22 BUF1CK $PINS O=FE_PHN1214_raw_a_22 I=raw_a[22]
XFE_PHC1210_raw2_19 BUF1S $PINS O=FE_PHN1210_raw2_19 I=raw2[19]
XFE_PHC1209_raw2_22 BUF1S $PINS O=FE_PHN1209_raw2_22 I=raw2[22]
XFE_PHC1208_raw_a_20 BUF1CK $PINS O=FE_PHN1208_raw_a_20 I=raw_a[20]
XFE_PHC1207_raw2_18 BUF1S $PINS O=raw2[18] I=FE_PHN1207_raw2_18
XFE_PHC1206_raw_a_21 BUF1S $PINS O=FE_PHN1206_raw_a_21 I=raw_a[21]
XFE_PHC1204_raw2_20 BUF1S $PINS O=raw2[20] I=FE_PHN1204_raw2_20
XFE_PHC1203_raw_a_23 BUF1CK $PINS O=FE_PHN1203_raw_a_23 I=raw_a[23]
XFE_PHC1193_raw_a_31 BUF1CK $PINS O=FE_PHN1193_raw_a_31 I=raw_a[31]
XFE_PHC1183_raw_prime_2 BUF1CK $PINS O=FE_PHN1183_raw_prime_2 I=raw_prime[2]
XFE_PHC1149_raw1_8 BUF1CK $PINS O=FE_PHN1149_raw1_8 I=raw1[8]
XFE_PHC1147_raw1_4 BUF1CK $PINS O=FE_PHN1147_raw1_4 I=raw1[4]
XFE_PHC1135_raw1_6 BUF1CK $PINS O=FE_PHN1135_raw1_6 I=raw1[6]
XFE_PHC1134_raw1_28 BUF1CK $PINS O=FE_PHN1134_raw1_28 I=raw1[28]
XFE_PHC1131_raw1_16 BUF1CK $PINS O=FE_PHN1131_raw1_16 I=raw1[16]
XFE_PHC1121_raw1_12 BUF1CK $PINS O=FE_PHN1121_raw1_12 I=raw1[12]
XFE_PHC1114_raw1_2 BUF1CK $PINS O=FE_PHN1114_raw1_2 I=raw1[2]
XFE_PHC1111_raw_k_26 BUF1 $PINS O=FE_PHN1111_raw_k_26 I=raw_k[26]
XFE_PHC1109_raw1_10 BUF1CK $PINS O=FE_PHN1109_raw1_10 I=raw1[10]
XFE_PHC1103_raw1_24 BUF1CK $PINS O=FE_PHN1103_raw1_24 I=raw1[24]
XFE_PHC1102_raw1_5 BUF1CK $PINS O=FE_PHN1102_raw1_5 I=raw1[5]
XFE_PHC1098_raw_k_2 BUF1S $PINS O=FE_PHN1098_raw_k_2 I=FE_PHN1490_raw_k_2
XFE_PHC1097_raw1_11 BUF1CK $PINS O=FE_PHN1097_raw1_11 I=raw1[11]
XFE_PHC1094_raw1_7 BUF1CK $PINS O=FE_PHN1094_raw1_7 I=raw1[7]
XFE_PHC1091_raw1_18 BUF1CK $PINS O=FE_PHN1091_raw1_18 I=raw1[18]
XFE_PHC1089_raw_k_10 BUF2CK $PINS O=FE_PHN1089_raw_k_10 I=raw_k[10]
XFE_PHC1086_raw_k_1 BUF2CK $PINS O=FE_PHN1086_raw_k_1 I=raw_k[1]
XFE_PHC1082_raw_k_6 BUF2CK $PINS O=FE_PHN1082_raw_k_6 I=raw_k[6]
XFE_PHC1081_raw1_26 BUF1CK $PINS O=FE_PHN1081_raw1_26 I=raw1[26]
XFE_PHC1076_raw1_1 BUF1CK $PINS O=FE_PHN1076_raw1_1 I=raw1[1]
XFE_PHC1069_raw1_27 BUF1CK $PINS O=FE_PHN1069_raw1_27 I=raw1[27]
XFE_PHC1062_raw1_9 BUF1CK $PINS O=FE_PHN1062_raw1_9 I=raw1[9]
XFE_PHC1060_raw1_25 BUF1CK $PINS O=FE_PHN1060_raw1_25 I=raw1[25]
XFE_PHC1056_raw1_20 BUF1CK $PINS O=FE_PHN1056_raw1_20 I=raw1[20]
XFE_PHC1053_raw1_3 BUF1CK $PINS O=FE_PHN1053_raw1_3 I=raw1[3]
XFE_PHC1050_raw1_30 BUF1CK $PINS O=FE_PHN1050_raw1_30 I=raw1[30]
XFE_PHC1044_raw1_13 BUF1CK $PINS O=FE_PHN1044_raw1_13 I=raw1[13]
XFE_PHC1043_raw_k_30 DELA $PINS O=FE_PHN1043_raw_k_30 I=raw_k[30]
XFE_PHC1040_raw_k_17 DELA $PINS O=FE_PHN1040_raw_k_17 I=raw_k[17]
XFE_PHC1038_raw1_29 BUF1CK $PINS O=FE_PHN1038_raw1_29 I=raw1[29]
XFE_PHC1035_raw_k_24 DELA $PINS O=FE_PHN1035_raw_k_24 I=raw_k[24]
XFE_PHC1032_raw_k_12 DELA $PINS O=FE_PHN1032_raw_k_12 I=raw_k[12]
XFE_PHC1030_raw_k_0 DELA $PINS O=FE_PHN1030_raw_k_0 I=raw_k[0]
XFE_PHC1029_raw1_21 BUF1CK $PINS O=FE_PHN1029_raw1_21 I=raw1[21]
XFE_PHC1027_raw_k_21 DELA $PINS O=FE_PHN1027_raw_k_21 I=raw_k[21]
XFE_PHC1024_raw_k_27 DELA $PINS O=FE_PHN1024_raw_k_27 I=raw_k[27]
XFE_PHC1023_raw_k_31 DELA $PINS O=FE_PHN1023_raw_k_31 I=raw_k[31]
XFE_PHC1022_raw_k_22 DELA $PINS O=FE_PHN1022_raw_k_22 I=raw_k[22]
XFE_PHC1021_raw_k_23 DELA $PINS O=FE_PHN1021_raw_k_23 I=raw_k[23]
XFE_PHC1020_raw_k_13 DELA $PINS O=FE_PHN1020_raw_k_13 I=raw_k[13]
XFE_PHC1019_raw1_19 BUF1CK $PINS O=FE_PHN1019_raw1_19 I=raw1[19]
XFE_PHC1018_raw_k_16 DELA $PINS O=FE_PHN1018_raw_k_16 I=raw_k[16]
XFE_PHC1016_raw_k_20 DELA $PINS O=FE_PHN1016_raw_k_20 I=raw_k[20]
XFE_PHC1015_raw_k_25 DELA $PINS O=FE_PHN1015_raw_k_25 I=raw_k[25]
XFE_PHC1013_raw_k_14 DELA $PINS O=FE_PHN1013_raw_k_14 I=raw_k[14]
XFE_PHC1010_raw_k_19 DELA $PINS O=FE_PHN1010_raw_k_19 I=raw_k[19]
XFE_PHC1009_raw_k_9 DELA $PINS O=FE_PHN1009_raw_k_9 I=raw_k[9]
XFE_PHC1008_raw_k_28 DELA $PINS O=FE_PHN1008_raw_k_28 I=raw_k[28]
XFE_PHC1007_raw_k_3 DELA $PINS O=FE_PHN1007_raw_k_3 I=raw_k[3]
XFE_PHC1005_raw_k_15 DELA $PINS O=FE_PHN1005_raw_k_15 I=raw_k[15]
XFE_PHC1004_raw_k_29 DELA $PINS O=FE_PHN1004_raw_k_29 I=raw_k[29]
XFE_PHC1003_raw_k_7 DELA $PINS O=FE_PHN1003_raw_k_7 I=raw_k[7]
XFE_PHC1002_raw_k_18 DELA $PINS O=FE_PHN1002_raw_k_18 I=raw_k[18]
XFE_PHC999_raw_k_4 DELA $PINS O=FE_PHN999_raw_k_4 I=raw_k[4]
XFE_PHC998_raw1_15 BUF1CK $PINS O=FE_PHN998_raw1_15 I=raw1[15]
XFE_PHC997_raw_k_8 DELA $PINS O=FE_PHN997_raw_k_8 I=raw_k[8]
XFE_PHC995_raw_k_11 DELA $PINS O=FE_PHN995_raw_k_11 I=raw_k[11]
XFE_PHC994_raw_k_5 DELA $PINS O=FE_PHN994_raw_k_5 I=raw_k[5]
XFE_PHC990_raw1_17 BUF1CK $PINS O=FE_PHN990_raw1_17 I=raw1[17]
XFE_PHC984_raw1_14 BUF1CK $PINS O=FE_PHN984_raw1_14 I=raw1[14]
XFE_PHC973_raw1_22 BUF1CK $PINS O=FE_PHN973_raw1_22 I=raw1[22]
XFE_PHC970_raw2_31 BUF1CK $PINS O=FE_PHN970_raw2_31 I=raw2[31]
XFE_PHC962_raw1_23 BUF1CK $PINS O=FE_PHN962_raw1_23 I=raw1[23]
XFE_PHC860_raw1_31 BUF1CK $PINS O=FE_PHN860_raw1_31 I=raw1[31]
XCTS_ccl_a_INV_i_clk_G0_L7_20 INV12CK $PINS O=CTS_87 I=CTS_88
XCTS_ccl_a_INV_i_clk_G0_L7_19 INV12CK $PINS O=CTS_86 I=CTS_88
XCTS_ccl_a_INV_i_clk_G0_L6_8 INV6CK $PINS O=CTS_88 I=CTS_89
XCTS_ccl_a_INV_i_clk_G0_L5_4 INV8CK $PINS O=CTS_89 I=CTS_90
XCTS_ccl_a_INV_i_clk_G0_L7_17 INV12CK $PINS O=CTS_83 I=CTS_84
XCTS_ccl_a_INV_i_clk_G0_L7_16 INV12CK $PINS O=CTS_82 I=CTS_84
XCTS_ccl_a_INV_i_clk_G0_L6_7 INV12CK $PINS O=CTS_84 I=CTS_85
XCTS_ccl_a_INV_i_clk_G0_L7_15 INV12CK $PINS O=CTS_80 I=CTS_81
XCTS_ccl_a_INV_i_clk_G0_L7_14 INV12CK $PINS O=CTS_79 I=CTS_81
XCTS_ccl_a_INV_i_clk_G0_L7_13 INV12CK $PINS O=CTS_78 I=CTS_81
XCTS_ccl_a_INV_i_clk_G0_L6_6 INV12CK $PINS O=CTS_81 I=CTS_85
XCTS_ccl_a_INV_i_clk_G0_L5_3 INV12CK $PINS O=CTS_85 I=CTS_90
XCTS_ccl_a_INV_i_clk_G0_L4_2 INV12CK $PINS O=CTS_90 I=CTS_91
XCTS_ccl_a_INV_i_clk_G0_L7_9 INV12CK $PINS O=CTS_74 I=CTS_75
XCTS_ccl_a_INV_i_clk_G0_L6_4 INV8CK $PINS O=CTS_75 I=CTS_76
XCTS_ccl_a_INV_i_clk_G0_L5_2 INV12CK $PINS O=CTS_76 I=CTS_77
XCTS_ccl_a_INV_i_clk_G0_L7_3 INV12CK $PINS O=CTS_71 I=CTS_72
XCTS_ccl_a_INV_i_clk_G0_L7_2 INV12CK $PINS O=CTS_70 I=CTS_72
XCTS_ccl_a_INV_i_clk_G0_L6_1 INV12CK $PINS O=CTS_72 I=CTS_73
XCTS_ccl_a_INV_i_clk_G0_L5_1 INV12CK $PINS O=CTS_73 I=CTS_77
XCTS_ccl_a_INV_i_clk_G0_L4_1 INV12CK $PINS O=CTS_77 I=CTS_91
XCTS_ccl_a_INV_i_clk_G0_L3_1 INV12CK $PINS O=CTS_91 I=CTS_92
XCTS_ccl_a_INV_i_clk_G0_L2_1 INV8CK $PINS O=CTS_92 I=i_clk
XFE_OFC581_FE_DBTN1_i_i_rst BUF1 $PINS O=FE_OFN614_n I=FE_OFN613_n
XFE_OFC580_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN613_n I=FE_OFN611_n
XFE_OFC579_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN612_n I=FE_OFN611_n
XFE_OFC578_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN611_n
+ I=FE_OFN21_FE_DBTN1_i_i_rst
XFE_OFC577_FE_DBTN1_i_i_rst INV2 $PINS O=FE_OFN610_n I=FE_OFN608_n
XFE_OFC576_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN609_n I=FE_OFN608_n
XFE_OFC575_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN608_n I=FE_OFN607_n
XFE_OFC574_FE_DBTN1_i_i_rst BUF1 $PINS O=FE_OFN607_n
+ I=FE_OFN22_FE_DBTN1_i_i_rst
XFE_OFC573_FE_DBTN1_i_i_rst BUF1 $PINS O=FE_OFN606_n I=FE_OFN603_n
XFE_OFC572_FE_DBTN1_i_i_rst BUF1 $PINS O=FE_OFN605_n I=FE_OFN603_n
XFE_OFC571_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN604_n I=FE_OFN602_n
XFE_OFC570_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN603_n I=FE_OFN602_n
XFE_OFC569_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN602_n
+ I=FE_OFN23_FE_DBTN1_i_i_rst
XFE_OFC567_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN600_n I=FE_OFN598_n
XFE_OFC565_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN598_n
+ I=FE_OFN24_FE_DBTN1_i_i_rst
XFE_OFC554_raw_prime_15 BUF1 $PINS O=FE_OFN587_n I=raw_prime[15]
XFE_OFC553_raw_prime_15 BUF1 $PINS O=FE_OFN586_n I=raw_prime[15]
XFE_OFC461_n343 BUF1 $PINS O=FE_OFN494_n343 I=n343
XFE_OFC460_n300 BUF1 $PINS O=FE_OFN493_n300 I=n300
XFE_OFC459_n299 BUF1 $PINS O=FE_OFN492_n299 I=n299
XFE_OFC458_n298 BUF1 $PINS O=FE_OFN491_n298 I=n298
XFE_OFC457_n297 BUF1 $PINS O=FE_OFN490_n297 I=n297
XFE_OFC456_n296 BUF1 $PINS O=FE_OFN489_n296 I=n296
XFE_OFC455_n44 BUF1 $PINS O=FE_OFN488_n44 I=n44
XFE_OFC454_FE_DBTN0_n295 BUF1 $PINS O=FE_OFN487_FE_DBTN0_n295 I=FE_DBTN0_n295
XFE_OFC440_FE_OFN4_FE_DBTN1_i_i_rst BUF1 $PINS
+ O=FE_OFN473_FE_OFN4_FE_DBTN1_i_i_rst I=FE_OFN472_FE_OFN4_FE_DBTN1_i_i_rst
XFE_OFC439_FE_OFN4_FE_DBTN1_i_i_rst BUF1 $PINS
+ O=FE_OFN472_FE_OFN4_FE_DBTN1_i_i_rst I=FE_OFN4_FE_DBTN1_i_i_rst
XFE_OFC438_FE_OFN5_FE_DBTN1_i_i_rst INV1S $PINS
+ O=FE_OFN471_FE_OFN5_FE_DBTN1_i_i_rst I=FE_OFN469_FE_OFN5_FE_DBTN1_i_i_rst
XFE_OFC436_FE_OFN5_FE_DBTN1_i_i_rst INV1S $PINS
+ O=FE_OFN469_FE_OFN5_FE_DBTN1_i_i_rst I=FE_OFN468_FE_OFN5_FE_DBTN1_i_i_rst
XFE_OFC435_FE_OFN5_FE_DBTN1_i_i_rst BUF1 $PINS
+ O=FE_OFN468_FE_OFN5_FE_DBTN1_i_i_rst I=FE_OFN5_FE_DBTN1_i_i_rst
XFE_OFC431_FE_OFN7_FE_DBTN1_i_i_rst BUF1 $PINS
+ O=FE_OFN464_FE_OFN7_FE_DBTN1_i_i_rst I=FE_OFN7_FE_DBTN1_i_i_rst
XFE_OFC409_FE_OFN31_raw_prime_31 BUF2CK $PINS O=FE_OFN442_FE_OFN31_raw_prime_31
+ I=FE_OFN441_FE_OFN31_raw_prime_31
XFE_OFC408_FE_OFN31_raw_prime_31 BUF1 $PINS O=FE_OFN441_FE_OFN31_raw_prime_31
+ I=FE_OFN31_raw_prime_31
XFE_OFC406_FE_OFN32_raw_prime_30 BUF2CK $PINS O=FE_OFN439_FE_OFN32_raw_prime_30
+ I=FE_OFN32_raw_prime_30
XFE_OFC403_FE_OFN33_raw_prime_29 INV1S $PINS O=FE_OFN436_FE_OFN33_raw_prime_29
+ I=FE_OFN33_raw_prime_29
XFE_OFC401_FE_OFN34_raw_prime_28 BUF1 $PINS O=FE_OFN434_FE_OFN34_raw_prime_28
+ I=FE_OFN34_raw_prime_28
XFE_OFC399_FE_OFN35_raw_prime_27 BUF2CK $PINS O=FE_OFN432_FE_OFN35_raw_prime_27
+ I=FE_OFN35_raw_prime_27
XFE_OFC397_FE_OFN36_raw_prime_26 BUF1 $PINS O=FE_OFN430_FE_OFN36_raw_prime_26
+ I=FE_OFN36_raw_prime_26
XFE_OFC395_FE_OFN37_raw_prime_25 BUF1 $PINS O=FE_OFN428_FE_OFN37_raw_prime_25
+ I=FE_OFN37_raw_prime_25
XFE_OFC393_FE_OFN38_raw_prime_24 BUF1 $PINS O=FE_OFN426_FE_OFN38_raw_prime_24
+ I=FE_OFN38_raw_prime_24
XFE_OFC391_FE_OFN39_raw_prime_23 BUF2CK $PINS O=FE_OFN424_FE_OFN39_raw_prime_23
+ I=FE_OFN39_raw_prime_23
XFE_OFC389_FE_OFN40_raw_prime_22 BUF2CK $PINS O=FE_OFN422_FE_OFN40_raw_prime_22
+ I=FE_OFN40_raw_prime_22
XFE_OFC388_FE_OFN41_raw_prime_21 BUF2CK $PINS O=FE_OFN421_FE_OFN41_raw_prime_21
+ I=FE_OFN420_FE_OFN41_raw_prime_21
XFE_OFC387_FE_OFN41_raw_prime_21 BUF1 $PINS O=FE_OFN420_FE_OFN41_raw_prime_21
+ I=FE_OFN41_raw_prime_21
XFE_OFC385_FE_OFN42_raw_prime_20 BUF2CK $PINS O=FE_OFN418_FE_OFN42_raw_prime_20
+ I=FE_OFN42_raw_prime_20
XFE_OFC382_FE_OFN43_raw_prime_19 BUF1 $PINS O=FE_OFN415_FE_OFN43_raw_prime_19
+ I=FE_OFN43_raw_prime_19
XFE_OFC380_FE_OFN44_raw_prime_18 BUF1 $PINS O=FE_OFN413_FE_OFN44_raw_prime_18
+ I=FE_OFN44_raw_prime_18
XFE_OFC378_FE_OFN45_raw_prime_17 BUF1 $PINS O=FE_OFN411_FE_OFN45_raw_prime_17
+ I=FE_OFN45_raw_prime_17
XFE_OFC374_FE_OFN46_raw_prime_16 INV1S $PINS O=FE_OFN407_FE_OFN46_raw_prime_16
+ I=FE_OFN46_raw_prime_16
XFE_OFC372_FE_OFN49_raw_prime_13 BUF1 $PINS O=FE_OFN405_FE_OFN49_raw_prime_13
+ I=FE_OFN49_raw_prime_13
XFE_OFC367_FE_OFN51_raw_prime_11 INV1S $PINS O=FE_OFN400_FE_OFN51_raw_prime_11
+ I=FE_OFN51_raw_prime_11
XFE_OFC365_FE_OFN52_raw_prime_10 BUF1 $PINS O=FE_OFN398_FE_OFN52_raw_prime_10
+ I=raw_prime[10]
XFE_OFC362_FE_OFN53_raw_prime_9 BUF1 $PINS O=FE_OFN395_FE_OFN53_raw_prime_9
+ I=raw_prime[9]
XFE_OFC361_FE_OFN55_raw_prime_7 BUF1 $PINS O=FE_OFN394_FE_OFN55_raw_prime_7
+ I=raw_prime[7]
XFE_OFC358_FE_OFN56_raw_prime_6 BUF2CK $PINS O=FE_OFN391_FE_OFN56_raw_prime_6
+ I=raw_prime[6]
XFE_OCPC348_n310 BUF6 $PINS O=FE_OCPN348_n310 I=n310
XFE_OFC300_raw_prime_2 INV6 $PINS O=FE_OFN317_n I=FE_OFN60_raw_prime_2
XFE_OFC275_raw_prime_3 BUF2 $PINS O=FE_OFN96_raw_prime_3 I=raw_prime[3]
XFE_OFC274_raw_prime_3 BUF4 $PINS O=FE_OFN59_raw_prime_3 I=raw_prime[3]
XFE_OFC267_raw_prime_2 BUF1 $PINS O=FE_OFN324_n I=FE_OFN60_raw_prime_2
XFE_OFC210_raw_prime_5 BUF2 $PINS O=FE_OFN101_raw_prime_5 I=raw_prime[5]
XFE_OFC128_raw_prime_2 BUF6 $PINS O=FE_OFN60_raw_prime_2 I=raw_prime[2]
XFE_OFC120_raw_prime_8 INV1S $PINS O=FE_OFN90_raw_prime_8
+ I=FE_OFN54_raw_prime_8
XFE_OFC118_raw_prime_8 BUF1 $PINS O=FE_OFN88_raw_prime_8 I=raw_prime[8]
XFE_OFC117_raw_prime_8 INV1S $PINS O=FE_OFN54_raw_prime_8 I=raw_prime[8]
XFE_OFC101_n312 BUF6 $PINS O=FE_OFN86_n312 I=n312
XFE_OFC86_raw_prime_4 BUF2 $PINS O=FE_OFN58_raw_prime_4 I=raw_prime[4]
XFE_OFC49_raw_prime_11 BUF1CK $PINS O=FE_OFN51_raw_prime_11 I=raw_prime[11]
XFE_OFC48_raw_prime_12 BUF1CK $PINS O=FE_OFN50_raw_prime_12 I=raw_prime[12]
XFE_OFC47_raw_prime_13 BUF1CK $PINS O=FE_OFN49_raw_prime_13 I=raw_prime[13]
XFE_OFC46_raw_prime_14 BUF1CK $PINS O=FE_OFN48_raw_prime_14 I=raw_prime[14]
XFE_OFC44_raw_prime_16 BUF1CK $PINS O=FE_OFN46_raw_prime_16 I=raw_prime[16]
XFE_OFC43_raw_prime_17 BUF1CK $PINS O=FE_OFN45_raw_prime_17 I=raw_prime[17]
XFE_OFC42_raw_prime_18 BUF1CK $PINS O=FE_OFN44_raw_prime_18 I=raw_prime[18]
XFE_OFC41_raw_prime_19 BUF1CK $PINS O=FE_OFN43_raw_prime_19 I=raw_prime[19]
XFE_OFC40_raw_prime_20 BUF1CK $PINS O=FE_OFN42_raw_prime_20 I=raw_prime[20]
XFE_OFC39_raw_prime_21 BUF1CK $PINS O=FE_OFN41_raw_prime_21 I=raw_prime[21]
XFE_OFC38_raw_prime_22 BUF1CK $PINS O=FE_OFN40_raw_prime_22 I=raw_prime[22]
XFE_OFC37_raw_prime_23 BUF1CK $PINS O=FE_OFN39_raw_prime_23 I=raw_prime[23]
XFE_OFC36_raw_prime_24 BUF1CK $PINS O=FE_OFN38_raw_prime_24 I=raw_prime[24]
XFE_OFC35_raw_prime_25 BUF1CK $PINS O=FE_OFN37_raw_prime_25 I=raw_prime[25]
XFE_OFC34_raw_prime_26 BUF1CK $PINS O=FE_OFN36_raw_prime_26 I=raw_prime[26]
XFE_OFC33_raw_prime_27 BUF1CK $PINS O=FE_OFN35_raw_prime_27 I=raw_prime[27]
XFE_OFC32_raw_prime_28 BUF1CK $PINS O=FE_OFN34_raw_prime_28 I=raw_prime[28]
XFE_OFC31_raw_prime_29 BUF1CK $PINS O=FE_OFN33_raw_prime_29 I=raw_prime[29]
XFE_OFC30_raw_prime_30 BUF1CK $PINS O=FE_OFN32_raw_prime_30 I=raw_prime[30]
XFE_OFC29_raw_prime_31 BUF1CK $PINS O=FE_OFN31_raw_prime_31 I=raw_prime[31]
XFE_OFC22_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN24_FE_DBTN1_i_i_rst
+ I=FE_OFN17_FE_DBTN1_i_i_rst
XFE_OFC21_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN23_FE_DBTN1_i_i_rst
+ I=FE_OFN16_FE_DBTN1_i_i_rst
XFE_OFC20_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN22_FE_DBTN1_i_i_rst
+ I=FE_OFN16_FE_DBTN1_i_i_rst
XFE_OFC19_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN21_FE_DBTN1_i_i_rst
+ I=FE_OFN16_FE_DBTN1_i_i_rst
XFE_OFC16_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN17_FE_DBTN1_i_i_rst
+ I=FE_OFN4_FE_DBTN1_i_i_rst
XFE_OFC15_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN16_FE_DBTN1_i_i_rst
+ I=FE_OFN473_FE_OFN4_FE_DBTN1_i_i_rst
XFE_OFC7_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN7_FE_DBTN1_i_i_rst
+ I=FE_OFN0_FE_DBTN1_i_i_rst
XFE_OFC6_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN6_FE_DBTN1_i_i_rst
+ I=FE_OFN0_FE_DBTN1_i_i_rst
XFE_OFC5_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN5_FE_DBTN1_i_i_rst
+ I=FE_OFN0_FE_DBTN1_i_i_rst
XFE_OFC4_FE_DBTN1_i_i_rst INV1S $PINS O=FE_OFN4_FE_DBTN1_i_i_rst
+ I=FE_OFN0_FE_DBTN1_i_i_rst
XFE_OFC0_FE_DBTN1_i_i_rst INV2 $PINS O=FE_OFN0_FE_DBTN1_i_i_rst I=i_rst
XFE_DBTC0_n295 INV1S $PINS O=FE_DBTN0_n295 I=n295
XU285 AN3B2S $PINS O=n49 I1=n53 B1=n380 B2=n384
XU286 AN3B2S $PINS O=n58 I1=n299 B1=n60 B2=n380
XU288 AN3 $PINS O=n62 I1=FE_OFN490_n297 I2=n300 I3=n299
XU289 AN3 $PINS O=n56 I1=n298 I2=n296 I3=n65
XU290 ND2 $PINS O=n37 I1=n69 I2=n385
XU295 AN3B2S $PINS O=n61 I1=n77 B1=n294 B2=n317
XU299 ND2 $PINS O=n66 I1=n73 I2=n82
XU303 AN2B1S $PINS O=n124 I1=state[1] B1=state[4]
Xcontrol_0 Control $PINS i_rst=FE_OFN0_FE_DBTN1_i_i_rst
+ GFAU_done_to_control=GFAU_done_to_control keyshift_done_to_control=n389
+ key_from_key_shift[1]=key_from_key_shift[1]
+ key_from_key_shift[0]=key_from_key_shift[0] raw1[31]=raw1[31] raw1[30]=raw1[30]
+ raw1[29]=raw1[29] raw1[28]=raw1[28] raw1[27]=raw1[27] raw1[26]=raw1[26]
+ raw1[25]=raw1[25] raw1[24]=raw1[24] raw1[23]=raw1[23] raw1[22]=raw1[22]
+ raw1[21]=raw1[21] raw1[20]=raw1[20] raw1[19]=raw1[19] raw1[18]=raw1[18]
+ raw1[17]=raw1[17] raw1[16]=raw1[16] raw1[15]=raw1[15] raw1[14]=raw1[14]
+ raw1[13]=raw1[13] raw1[12]=raw1[12] raw1[11]=raw1[11] raw1[10]=raw1[10]
+ raw1[9]=raw1[9] raw1[8]=raw1[8] raw1[7]=raw1[7] raw1[6]=raw1[6] raw1[5]=raw1[5]
+ raw1[4]=raw1[4] raw1[3]=raw1[3] raw1[2]=raw1[2] raw1[1]=raw1[1]
+ raw1[0]=FE_PHN1338_raw1_0 raw2[31]=raw2[31] raw2[30]=raw2[30] raw2[29]=raw2[29]
+ raw2[28]=FE_PHN1255_raw2_28 raw2[27]=raw2[27] raw2[26]=raw2[26]
+ raw2[25]=raw2[25] raw2[24]=FE_PHN1227_raw2_24 raw2[23]=raw2[23]
+ raw2[22]=FE_PHN1209_raw2_22 raw2[21]=raw2[21] raw2[20]=raw2[20]
+ raw2[19]=FE_PHN1210_raw2_19 raw2[18]=raw2[18] raw2[17]=FE_PHN1216_raw2_17
+ raw2[16]=raw2[16] raw2[15]=FE_PHN1264_raw2_15 raw2[14]=raw2[14]
+ raw2[13]=FE_PHN1285_raw2_13 raw2[12]=raw2[12] raw2[11]=raw2[11]
+ raw2[10]=raw2[10] raw2[9]=FE_PHN1286_raw2_9 raw2[8]=FE_PHN1299_raw2_8
+ raw2[7]=raw2[7] raw2[6]=raw2[6] raw2[5]=FE_PHN1313_raw2_5 raw2[4]=raw2[4]
+ raw2[3]=raw2[3] raw2[2]=FE_PHN1292_raw2_2 raw2[1]=raw2[1] raw2[0]=raw2[0]
+ raw_prime[31]=raw_prime[31] raw_prime[30]=raw_prime[30]
+ raw_prime[29]=raw_prime[29] raw_prime[28]=raw_prime[28]
+ raw_prime[27]=raw_prime[27] raw_prime[26]=raw_prime[26]
+ raw_prime[25]=raw_prime[25] raw_prime[24]=raw_prime[24]
+ raw_prime[23]=raw_prime[23] raw_prime[22]=raw_prime[22]
+ raw_prime[21]=raw_prime[21] raw_prime[20]=raw_prime[20]
+ raw_prime[19]=raw_prime[19] raw_prime[18]=raw_prime[18]
+ raw_prime[17]=raw_prime[17] raw_prime[16]=raw_prime[16]
+ raw_prime[15]=raw_prime[15] raw_prime[14]=raw_prime[14]
+ raw_prime[13]=raw_prime[13] raw_prime[12]=raw_prime[12]
+ raw_prime[11]=raw_prime[11] raw_prime[10]=raw_prime[10]
+ raw_prime[9]=raw_prime[9] raw_prime[8]=raw_prime[8] raw_prime[7]=raw_prime[7]
+ raw_prime[6]=raw_prime[6] raw_prime[5]=raw_prime[5] raw_prime[4]=raw_prime[4]
+ raw_prime[3]=FE_OFN59_raw_prime_3 raw_prime[2]=raw_prime[2] raw_prime[1]=n312
+ raw_prime[0]=n310 raw_a[31]=raw_a[31] raw_a[30]=raw_a[30] raw_a[29]=raw_a[29]
+ raw_a[28]=raw_a[28] raw_a[27]=raw_a[27] raw_a[26]=raw_a[26] raw_a[25]=raw_a[25]
+ raw_a[24]=raw_a[24] raw_a[23]=raw_a[23] raw_a[22]=FE_PHN1214_raw_a_22
+ raw_a[21]=FE_PHN1206_raw_a_21 raw_a[20]=FE_PHN1208_raw_a_20 raw_a[19]=raw_a[19]
+ raw_a[18]=raw_a[18] raw_a[17]=raw_a[17] raw_a[16]=FE_PHN1266_raw_a_16
+ raw_a[15]=FE_PHN1280_raw_a_15 raw_a[14]=raw_a[14] raw_a[13]=raw_a[13]
+ raw_a[12]=raw_a[12] raw_a[11]=raw_a[11] raw_a[10]=FE_PHN1296_raw_a_10
+ raw_a[9]=raw_a[9] raw_a[8]=FE_PHN1288_raw_a_8 raw_a[7]=raw_a[7]
+ raw_a[6]=raw_a[6] raw_a[5]=FE_PHN1303_raw_a_5 raw_a[4]=raw_a[4]
+ raw_a[3]=raw_a[3] raw_a[2]=raw_a[2] raw_a[1]=raw_a[1]
+ raw_a[0]=FE_PHN1295_raw_a_0 load_done=load_done GFAU_out[31]=GFAU_out[31]
+ GFAU_out[30]=GFAU_out[30] GFAU_out[29]=GFAU_out[29] GFAU_out[28]=GFAU_out[28]
+ GFAU_out[27]=GFAU_out[27] GFAU_out[26]=GFAU_out[26] GFAU_out[25]=GFAU_out[25]
+ GFAU_out[24]=GFAU_out[24] GFAU_out[23]=GFAU_out[23] GFAU_out[22]=GFAU_out[22]
+ GFAU_out[21]=GFAU_out[21] GFAU_out[20]=GFAU_out[20] GFAU_out[19]=GFAU_out[19]
+ GFAU_out[18]=GFAU_out[18] GFAU_out[17]=GFAU_out[17] GFAU_out[16]=GFAU_out[16]
+ GFAU_out[15]=GFAU_out[15] GFAU_out[14]=GFAU_out[14] GFAU_out[13]=GFAU_out[13]
+ GFAU_out[12]=GFAU_out[12] GFAU_out[11]=GFAU_out[11] GFAU_out[10]=GFAU_out[10]
+ GFAU_out[9]=GFAU_out[9] GFAU_out[8]=GFAU_out[8] GFAU_out[7]=GFAU_out[7]
+ GFAU_out[6]=GFAU_out[6] GFAU_out[5]=GFAU_out[5] GFAU_out[4]=GFAU_out[4]
+ GFAU_out[3]=GFAU_out[3] GFAU_out[2]=GFAU_out[2] GFAU_out[1]=GFAU_out[1]
+ GFAU_out[0]=GFAU_out[0] Px_mont[31]=Px_mont[31] Px_mont[30]=Px_mont[30]
+ Px_mont[29]=Px_mont[29] Px_mont[28]=Px_mont[28] Px_mont[27]=Px_mont[27]
+ Px_mont[26]=Px_mont[26] Px_mont[25]=Px_mont[25] Px_mont[24]=Px_mont[24]
+ Px_mont[23]=Px_mont[23] Px_mont[22]=Px_mont[22] Px_mont[21]=Px_mont[21]
+ Px_mont[20]=Px_mont[20] Px_mont[19]=Px_mont[19] Px_mont[18]=Px_mont[18]
+ Px_mont[17]=Px_mont[17] Px_mont[16]=Px_mont[16] Px_mont[15]=Px_mont[15]
+ Px_mont[14]=Px_mont[14] Px_mont[13]=Px_mont[13] Px_mont[12]=Px_mont[12]
+ Px_mont[11]=Px_mont[11] Px_mont[10]=Px_mont[10] Px_mont[9]=Px_mont[9]
+ Px_mont[8]=Px_mont[8] Px_mont[7]=Px_mont[7] Px_mont[6]=Px_mont[6]
+ Px_mont[5]=Px_mont[5] Px_mont[4]=Px_mont[4] Px_mont[3]=Px_mont[3]
+ Px_mont[2]=Px_mont[2] Px_mont[1]=Px_mont[1] Px_mont[0]=Px_mont[0]
+ Py_mont[31]=Py_mont[31] Py_mont[30]=Py_mont[30] Py_mont[29]=Py_mont[29]
+ Py_mont[28]=Py_mont[28] Py_mont[27]=Py_mont[27] Py_mont[26]=Py_mont[26]
+ Py_mont[25]=Py_mont[25] Py_mont[24]=Py_mont[24] Py_mont[23]=Py_mont[23]
+ Py_mont[22]=Py_mont[22] Py_mont[21]=Py_mont[21] Py_mont[20]=Py_mont[20]
+ Py_mont[19]=Py_mont[19] Py_mont[18]=Py_mont[18] Py_mont[17]=Py_mont[17]
+ Py_mont[16]=Py_mont[16] Py_mont[15]=Py_mont[15] Py_mont[14]=Py_mont[14]
+ Py_mont[13]=Py_mont[13] Py_mont[12]=Py_mont[12] Py_mont[11]=Py_mont[11]
+ Py_mont[10]=Py_mont[10] Py_mont[9]=Py_mont[9] Py_mont[8]=Py_mont[8]
+ Py_mont[7]=Py_mont[7] Py_mont[6]=Py_mont[6] Py_mont[5]=Py_mont[5]
+ Py_mont[4]=Py_mont[4] Py_mont[3]=Py_mont[3] Py_mont[2]=Py_mont[2]
+ Py_mont[1]=Py_mont[1] Py_mont[0]=Py_mont[0]
+ operation_select[1]=operation_select[1] operation_select[0]=operation_select[0]
+ key_shift_done_from_control=key_shift_done_from_control
+ GFAU_done_from_control=GFAU_done_from_control
+ final_output_1[31]=final_output_1[31] final_output_1[30]=final_output_1[30]
+ final_output_1[29]=final_output_1[29] final_output_1[28]=final_output_1[28]
+ final_output_1[27]=final_output_1[27] final_output_1[26]=final_output_1[26]
+ final_output_1[25]=final_output_1[25] final_output_1[24]=final_output_1[24]
+ final_output_1[23]=final_output_1[23] final_output_1[22]=final_output_1[22]
+ final_output_1[21]=final_output_1[21] final_output_1[20]=final_output_1[20]
+ final_output_1[19]=final_output_1[19] final_output_1[18]=final_output_1[18]
+ final_output_1[17]=final_output_1[17] final_output_1[16]=final_output_1[16]
+ final_output_1[15]=final_output_1[15] final_output_1[14]=final_output_1[14]
+ final_output_1[13]=final_output_1[13] final_output_1[12]=final_output_1[12]
+ final_output_1[11]=final_output_1[11] final_output_1[10]=final_output_1[10]
+ final_output_1[9]=final_output_1[9] final_output_1[8]=final_output_1[8]
+ final_output_1[7]=final_output_1[7] final_output_1[6]=final_output_1[6]
+ final_output_1[5]=final_output_1[5] final_output_1[4]=final_output_1[4]
+ final_output_1[3]=final_output_1[3] final_output_1[2]=final_output_1[2]
+ final_output_1[1]=final_output_1[1] final_output_1[0]=final_output_1[0]
+ final_output_2[31]=final_output_2[31] final_output_2[30]=final_output_2[30]
+ final_output_2[29]=final_output_2[29] final_output_2[28]=final_output_2[28]
+ final_output_2[27]=final_output_2[27] final_output_2[26]=final_output_2[26]
+ final_output_2[25]=final_output_2[25] final_output_2[24]=final_output_2[24]
+ final_output_2[23]=final_output_2[23] final_output_2[22]=final_output_2[22]
+ final_output_2[21]=final_output_2[21] final_output_2[20]=final_output_2[20]
+ final_output_2[19]=final_output_2[19] final_output_2[18]=final_output_2[18]
+ final_output_2[17]=final_output_2[17] final_output_2[16]=final_output_2[16]
+ final_output_2[15]=final_output_2[15] final_output_2[14]=final_output_2[14]
+ final_output_2[13]=final_output_2[13] final_output_2[12]=final_output_2[12]
+ final_output_2[11]=final_output_2[11] final_output_2[10]=final_output_2[10]
+ final_output_2[9]=final_output_2[9] final_output_2[8]=final_output_2[8]
+ final_output_2[7]=final_output_2[7] final_output_2[6]=final_output_2[6]
+ final_output_2[5]=final_output_2[5] final_output_2[4]=final_output_2[4]
+ final_output_2[3]=final_output_2[3] final_output_2[2]=final_output_2[2]
+ final_output_2[1]=final_output_2[1] final_output_2[0]=final_output_2[0]
+ final_done=done FE_OFN40_FE_DBTN1_i_i_rst=FE_OFN24_FE_DBTN1_i_i_rst
+ FE_OFN35_FE_DBTN1_i_i_rst=FE_OFN22_FE_DBTN1_i_i_rst
+ FE_OFN33_FE_DBTN1_i_i_rst=FE_OFN612_n
+ FE_OFN19_FE_DBTN1_i_i_rst=FE_OFN464_FE_OFN7_FE_DBTN1_i_i_rst
+ FE_OFN16_FE_DBTN1_i_i_rst=FE_OFN6_FE_DBTN1_i_i_rst
+ FE_OFN12_FE_DBTN1_i_i_rst=FE_OFN471_FE_OFN5_FE_DBTN1_i_i_rst
+ FE_OFN6_FE_DBTN1_i_i_rst=FE_OFN472_FE_OFN4_FE_DBTN1_i_i_rst
+ FE_OFN47_raw_prime_31=FE_OFN31_raw_prime_31
+ FE_OFN49_raw_prime_30=FE_OFN32_raw_prime_30
+ FE_OFN53_raw_prime_29=FE_OFN33_raw_prime_29
+ FE_OFN57_raw_prime_28=FE_OFN34_raw_prime_28
+ FE_OFN59_raw_prime_27=FE_OFN35_raw_prime_27
+ FE_OFN63_raw_prime_26=FE_OFN36_raw_prime_26
+ FE_OFN67_raw_prime_25=FE_OFN37_raw_prime_25
+ FE_OFN71_raw_prime_24=FE_OFN38_raw_prime_24
+ FE_OFN73_raw_prime_23=FE_OFN39_raw_prime_23
+ FE_OFN77_raw_prime_22=FE_OFN40_raw_prime_22
+ FE_OFN81_raw_prime_21=FE_OFN41_raw_prime_21
+ FE_OFN85_raw_prime_20=FE_OFN42_raw_prime_20
+ FE_OFN87_raw_prime_19=FE_OFN43_raw_prime_19
+ FE_OFN91_raw_prime_18=FE_OFN44_raw_prime_18
+ FE_OFN95_raw_prime_17=FE_OFN45_raw_prime_17
+ FE_OFN99_raw_prime_16=FE_OFN46_raw_prime_16
+ FE_OFN103_raw_prime_15=raw_prime[15]
+ FE_OFN106_raw_prime_14=FE_OFN48_raw_prime_14
+ FE_OFN109_raw_prime_13=FE_OFN49_raw_prime_13
+ FE_OFN112_raw_prime_12=FE_OFN50_raw_prime_12
+ FE_OFN116_raw_prime_11=FE_OFN51_raw_prime_11
+ FE_OFN119_raw_prime_10=FE_OFN398_FE_OFN52_raw_prime_10
+ FE_OFN122_raw_prime_9=raw_prime[9] FE_OFN124_raw_prime_7=raw_prime[7]
+ FE_OFN126_raw_prime_6=raw_prime[6] FE_OFN129_raw_prime_4=FE_OFN58_raw_prime_4
+ FE_OFN131_n312=FE_OFN86_n312 FE_OFN141_raw_prime_8=FE_OFN90_raw_prime_8
+ FE_OFN137_raw_prime_8=FE_OFN88_raw_prime_8
+ FE_OFN135_raw_prime_8=FE_OFN54_raw_prime_8
+ FE_OFN146_raw_prime_2=FE_OFN60_raw_prime_2
+ FE_OFN148_raw_prime_3=FE_OFN96_raw_prime_3
+ FE_OFN153_raw_prime_5=FE_OFN101_raw_prime_5 FE_OFN156_raw_prime_8=raw_prime[8]
+ FE_OFN165_n=FE_OFN324_n FE_OFN160_n=FE_OFN317_n
+ FE_OFN190_FE_OFN56_raw_prime_6=FE_OFN391_FE_OFN56_raw_prime_6
+ FE_OFN196_FE_OFN55_raw_prime_7=FE_OFN394_FE_OFN55_raw_prime_7
+ FE_OFN200_FE_OFN53_raw_prime_9=FE_OFN395_FE_OFN53_raw_prime_9
+ FE_OFN209_FE_OFN51_raw_prime_11=FE_OFN400_FE_OFN51_raw_prime_11
+ FE_OFN214_FE_OFN49_raw_prime_13=FE_OFN405_FE_OFN49_raw_prime_13
+ FE_OFN220_FE_OFN46_raw_prime_16=FE_OFN407_FE_OFN46_raw_prime_16
+ FE_OFN221_FE_OFN45_raw_prime_17=FE_OFN411_FE_OFN45_raw_prime_17
+ FE_OFN222_FE_OFN44_raw_prime_18=FE_OFN413_FE_OFN44_raw_prime_18
+ FE_OFN224_FE_OFN43_raw_prime_19=FE_OFN415_FE_OFN43_raw_prime_19
+ FE_OFN229_FE_OFN42_raw_prime_20=FE_OFN418_FE_OFN42_raw_prime_20
+ FE_OFN236_FE_OFN41_raw_prime_21=FE_OFN421_FE_OFN41_raw_prime_21
+ FE_OFN234_FE_OFN41_raw_prime_21=FE_OFN420_FE_OFN41_raw_prime_21
+ FE_OFN239_FE_OFN40_raw_prime_22=FE_OFN422_FE_OFN40_raw_prime_22
+ FE_OFN240_FE_OFN39_raw_prime_23=FE_OFN424_FE_OFN39_raw_prime_23
+ FE_OFN242_FE_OFN38_raw_prime_24=FE_OFN426_FE_OFN38_raw_prime_24
+ FE_OFN247_FE_OFN37_raw_prime_25=FE_OFN428_FE_OFN37_raw_prime_25
+ FE_OFN249_FE_OFN36_raw_prime_26=FE_OFN430_FE_OFN36_raw_prime_26
+ FE_OFN256_FE_OFN35_raw_prime_27=FE_OFN432_FE_OFN35_raw_prime_27
+ FE_OFN259_FE_OFN34_raw_prime_28=FE_OFN434_FE_OFN34_raw_prime_28
+ FE_OFN263_FE_OFN33_raw_prime_29=FE_OFN436_FE_OFN33_raw_prime_29
+ FE_OFN265_FE_OFN32_raw_prime_30=FE_OFN439_FE_OFN32_raw_prime_30
+ FE_OFN270_FE_OFN31_raw_prime_31=FE_OFN442_FE_OFN31_raw_prime_31
+ FE_OFN268_FE_OFN31_raw_prime_31=FE_OFN441_FE_OFN31_raw_prime_31
+ FE_OFN304_FE_OFN4_FE_DBTN1_i_i_rst=FE_OFN473_FE_OFN4_FE_DBTN1_i_i_rst
+ FE_OFN323_n=FE_OFN587_n FE_OFN321_n=FE_OFN586_n FE_OFN336_n=FE_OFN600_n
+ FE_OFN334_n=FE_OFN598_n FE_OFN340_n=FE_OFN609_n FE_OFN344_n=FE_OFN614_n
+ FE_OFN342_n=FE_OFN613_n i_clk_clone1=CTS_86 i_clk_clone10=CTS_70
+ i_clk_clone9=CTS_71 i_clk_clone11=CTS_72 i_clk_clone8=CTS_73
+ i_clk_clone7=CTS_74 i_clk_clone6=CTS_76 i_clk_clone5=CTS_79 i_clk_clone4=CTS_82
+ i_clk_clone3=CTS_83 i_clk_clone2=CTS_84 i_clk=CTS_87 p1=FE_PHN1203_raw_a_23
+ p2=FE_PHN1317_raw2_4
XGFAU_0 GFAU $PINS i_rst=FE_OFN0_FE_DBTN1_i_i_rst in_0[31]=Px_mont[31]
+ in_0[30]=Px_mont[30] in_0[29]=Px_mont[29] in_0[28]=Px_mont[28]
+ in_0[27]=Px_mont[27] in_0[26]=Px_mont[26] in_0[25]=Px_mont[25]
+ in_0[24]=Px_mont[24] in_0[23]=Px_mont[23] in_0[22]=Px_mont[22]
+ in_0[21]=Px_mont[21] in_0[20]=Px_mont[20] in_0[19]=Px_mont[19]
+ in_0[18]=Px_mont[18] in_0[17]=Px_mont[17] in_0[16]=Px_mont[16]
+ in_0[15]=Px_mont[15] in_0[14]=Px_mont[14] in_0[13]=Px_mont[13]
+ in_0[12]=Px_mont[12] in_0[11]=Px_mont[11] in_0[10]=Px_mont[10]
+ in_0[9]=Px_mont[9] in_0[8]=Px_mont[8] in_0[7]=Px_mont[7] in_0[6]=Px_mont[6]
+ in_0[5]=Px_mont[5] in_0[4]=Px_mont[4] in_0[3]=Px_mont[3] in_0[2]=Px_mont[2]
+ in_0[1]=Px_mont[1] in_0[0]=Px_mont[0] in_1[31]=Py_mont[31] in_1[30]=Py_mont[30]
+ in_1[29]=Py_mont[29] in_1[28]=Py_mont[28] in_1[27]=Py_mont[27]
+ in_1[26]=Py_mont[26] in_1[25]=Py_mont[25] in_1[24]=Py_mont[24]
+ in_1[23]=Py_mont[23] in_1[22]=Py_mont[22] in_1[21]=Py_mont[21]
+ in_1[20]=Py_mont[20] in_1[19]=Py_mont[19] in_1[18]=Py_mont[18]
+ in_1[17]=Py_mont[17] in_1[16]=Py_mont[16] in_1[15]=Py_mont[15]
+ in_1[14]=Py_mont[14] in_1[13]=Py_mont[13] in_1[12]=Py_mont[12]
+ in_1[11]=Py_mont[11] in_1[10]=Py_mont[10] in_1[9]=Py_mont[9] in_1[8]=Py_mont[8]
+ in_1[7]=Py_mont[7] in_1[6]=Py_mont[6] in_1[5]=Py_mont[5] in_1[4]=Py_mont[4]
+ in_1[3]=Py_mont[3] in_1[2]=Py_mont[2] in_1[1]=Py_mont[1] in_1[0]=Py_mont[0]
+ prime[31]=FE_OFN31_raw_prime_31 prime[30]=raw_prime[30] prime[29]=raw_prime[29]
+ prime[28]=FE_OFN434_FE_OFN34_raw_prime_28 prime[27]=raw_prime[27]
+ prime[26]=raw_prime[26] prime[25]=raw_prime[25]
+ prime[24]=FE_OFN426_FE_OFN38_raw_prime_24 prime[23]=raw_prime[23]
+ prime[22]=raw_prime[22] prime[21]=raw_prime[21] prime[20]=FE_OFN42_raw_prime_20
+ prime[19]=raw_prime[19] prime[18]=raw_prime[18] prime[17]=raw_prime[17]
+ prime[16]=raw_prime[16] prime[15]=FE_OFN586_n prime[14]=FE_OFN48_raw_prime_14
+ prime[13]=FE_OFN49_raw_prime_13 prime[12]=raw_prime[12]
+ prime[11]=FE_OFN51_raw_prime_11 prime[10]=raw_prime[10] prime[9]=raw_prime[9]
+ prime[8]=FE_OFN88_raw_prime_8 prime[7]=raw_prime[7]
+ prime[6]=FE_OFN391_FE_OFN56_raw_prime_6 prime[5]=raw_prime[5]
+ prime[4]=FE_OFN58_raw_prime_4 prime[3]=FE_OFN96_raw_prime_3
+ prime[2]=FE_OFN60_raw_prime_2 prime[1]=FE_OFN86_n312 prime[0]=FE_OCPN348_n310
+ operation_select[1]=operation_select[1] operation_select[0]=operation_select[0]
+ GFAU_done_from_control=GFAU_done_from_control result[31]=GFAU_out[31]
+ result[30]=GFAU_out[30] result[29]=GFAU_out[29] result[28]=GFAU_out[28]
+ result[27]=GFAU_out[27] result[26]=GFAU_out[26] result[25]=GFAU_out[25]
+ result[24]=GFAU_out[24] result[23]=GFAU_out[23] result[22]=GFAU_out[22]
+ result[21]=GFAU_out[21] result[20]=GFAU_out[20] result[19]=GFAU_out[19]
+ result[18]=GFAU_out[18] result[17]=GFAU_out[17] result[16]=GFAU_out[16]
+ result[15]=GFAU_out[15] result[14]=GFAU_out[14] result[13]=GFAU_out[13]
+ result[12]=GFAU_out[12] result[11]=GFAU_out[11] result[10]=GFAU_out[10]
+ result[9]=GFAU_out[9] result[8]=GFAU_out[8] result[7]=GFAU_out[7]
+ result[6]=GFAU_out[6] result[5]=GFAU_out[5] result[4]=GFAU_out[4]
+ result[3]=GFAU_out[3] result[2]=GFAU_out[2] result[1]=GFAU_out[1]
+ result[0]=GFAU_out[0] GFAU_done_to_control=GFAU_done_to_control
+ FE_OFN38_FE_DBTN1_i_i_rst=FE_OFN24_FE_DBTN1_i_i_rst
+ FE_OFN17_FE_DBTN1_i_i_rst=FE_OFN7_FE_DBTN1_i_i_rst
+ FE_OFN13_FE_DBTN1_i_i_rst=FE_OFN6_FE_DBTN1_i_i_rst
+ FE_OFN7_FE_DBTN1_i_i_rst=FE_OFN5_FE_DBTN1_i_i_rst
+ FE_OFN4_FE_DBTN1_i_i_rst=FE_OFN4_FE_DBTN1_i_i_rst
+ FE_OFN51_raw_prime_30=FE_OFN439_FE_OFN32_raw_prime_30
+ FE_OFN55_raw_prime_29=FE_OFN436_FE_OFN33_raw_prime_29
+ FE_OFN61_raw_prime_27=FE_OFN432_FE_OFN35_raw_prime_27
+ FE_OFN65_raw_prime_26=FE_OFN36_raw_prime_26
+ FE_OFN69_raw_prime_25=FE_OFN428_FE_OFN37_raw_prime_25
+ FE_OFN75_raw_prime_23=FE_OFN424_FE_OFN39_raw_prime_23
+ FE_OFN79_raw_prime_22=FE_OFN422_FE_OFN40_raw_prime_22
+ FE_OFN83_raw_prime_21=FE_OFN421_FE_OFN41_raw_prime_21
+ FE_OFN89_raw_prime_19=FE_OFN415_FE_OFN43_raw_prime_19
+ FE_OFN93_raw_prime_18=FE_OFN413_FE_OFN44_raw_prime_18
+ FE_OFN97_raw_prime_17=FE_OFN411_FE_OFN45_raw_prime_17
+ FE_OFN101_raw_prime_16=FE_OFN407_FE_OFN46_raw_prime_16
+ FE_OFN114_raw_prime_12=FE_OFN50_raw_prime_12
+ FE_OFN142_raw_prime_8=FE_OFN90_raw_prime_8 FE_OFN166_n=FE_OFN324_n
+ FE_OFN161_n=FE_OFN317_n
+ FE_OFN198_FE_OFN55_raw_prime_7=FE_OFN394_FE_OFN55_raw_prime_7
+ FE_OFN202_FE_OFN53_raw_prime_9=FE_OFN395_FE_OFN53_raw_prime_9
+ FE_OFN205_FE_OFN52_raw_prime_10=FE_OFN398_FE_OFN52_raw_prime_10
+ FE_OFN210_FE_OFN51_raw_prime_11=FE_OFN400_FE_OFN51_raw_prime_11
+ FE_OFN216_FE_OFN49_raw_prime_13=FE_OFN405_FE_OFN49_raw_prime_13
+ FE_OFN232_FE_OFN42_raw_prime_20=FE_OFN418_FE_OFN42_raw_prime_20
+ FE_OFN252_FE_OFN36_raw_prime_26=FE_OFN430_FE_OFN36_raw_prime_26
+ FE_OFN273_FE_OFN31_raw_prime_31=FE_OFN442_FE_OFN31_raw_prime_31
+ FE_OFN292_FE_OFN7_FE_DBTN1_i_i_rst=FE_OFN464_FE_OFN7_FE_DBTN1_i_i_rst
+ FE_OFN302_FE_OFN5_FE_DBTN1_i_i_rst=FE_OFN471_FE_OFN5_FE_DBTN1_i_i_rst
+ FE_OFN299_FE_OFN5_FE_DBTN1_i_i_rst=FE_OFN469_FE_OFN5_FE_DBTN1_i_i_rst
+ FE_OFN296_FE_OFN5_FE_DBTN1_i_i_rst=FE_OFN468_FE_OFN5_FE_DBTN1_i_i_rst
+ FE_OFN325_n=FE_OFN587_n i_clk_clone5=CTS_74 i_clk_clone6=CTS_75
+ i_clk_clone4=CTS_79 i_clk_clone3=CTS_82 i_clk_clone2=CTS_86 i_clk_clone1=CTS_87
+ i_clk=CTS_89
Xkey_shift_0 key_shift $PINS i_rst=FE_OFN605_n k[31]=raw_k[31] k[30]=raw_k[30]
+ k[29]=raw_k[29] k[28]=raw_k[28] k[27]=raw_k[27] k[26]=raw_k[26] k[25]=raw_k[25]
+ k[24]=raw_k[24] k[23]=raw_k[23] k[22]=raw_k[22] k[21]=raw_k[21] k[20]=raw_k[20]
+ k[19]=raw_k[19] k[18]=raw_k[18] k[17]=raw_k[17] k[16]=raw_k[16] k[15]=raw_k[15]
+ k[14]=raw_k[14] k[13]=raw_k[13] k[12]=raw_k[12] k[11]=raw_k[11] k[10]=raw_k[10]
+ k[9]=raw_k[9] k[8]=raw_k[8] k[7]=raw_k[7] k[6]=raw_k[6] k[5]=raw_k[5]
+ k[4]=raw_k[4] k[3]=raw_k[3] k[2]=raw_k[2] k[1]=raw_k[1] k[0]=raw_k[0]
+ key_shift_done_from_control=key_shift_done_from_control
+ k_out[1]=key_from_key_shift[1] k_out[0]=key_from_key_shift[0]
+ FE_OFN339_n=FE_OFN606_n i_clk=CTS_78
Xraw1_r_reg[31] QDFFRBN $PINS Q=raw1[31] D=n151 CK=CTS_80 RB=FE_OFN613_n
Xraw1_r_reg[29] QDFFRBN $PINS Q=raw1[29] D=n153 CK=CTS_80 RB=FE_OFN613_n
Xraw2_r_reg[29] QDFFRBN $PINS Q=FE_PHN1251_raw2_29 D=n157 CK=CTS_70
+ RB=FE_OFN607_n
Xraw1_r_reg[26] QDFFRBN $PINS Q=raw1[26] D=n233 CK=CTS_83 RB=FE_OFN612_n
Xraw1_r_reg[28] QDFFRBN $PINS Q=raw1[28] D=n154 CK=CTS_80 RB=FE_OFN613_n
Xraw2_r_reg[26] QDFFRBN $PINS Q=FE_PHN1236_raw2_26 D=n229 CK=CTS_70
+ RB=FE_OFN607_n
Xraw1_r_reg[30] QDFFRBN $PINS Q=raw1[30] D=n152 CK=CTS_80 RB=FE_OFN613_n
Xraw2_r_reg[28] QDFFRBN $PINS Q=raw2[28] D=n158 CK=CTS_70 RB=FE_OFN607_n
Xraw2_r_reg[30] QDFFRBN $PINS Q=FE_PHN1256_raw2_30 D=n156 CK=CTS_70
+ RB=FE_OFN607_n
Xraw_a_r_reg[29] QDFFRBN $PINS Q=FE_PHN1230_raw_a_29 D=n165 CK=CTS_80
+ RB=FE_OFN23_FE_DBTN1_i_i_rst
Xraw_a_r_reg[26] QDFFRBN $PINS Q=FE_PHN1238_raw_a_26 D=n169 CK=CTS_80
+ RB=FE_OFN23_FE_DBTN1_i_i_rst
Xraw_a_r_reg[28] QDFFRBN $PINS Q=FE_PHN1234_raw_a_28 D=n164 CK=CTS_80
+ RB=FE_OFN23_FE_DBTN1_i_i_rst
Xraw_a_r_reg[30] QDFFRBN $PINS Q=FE_PHN1252_raw_a_30 D=n166 CK=CTS_80
+ RB=FE_OFN23_FE_DBTN1_i_i_rst
Xk_r_reg[10] QDFFRBN $PINS Q=raw_k[10] D=n198 CK=CTS_70 RB=FE_OFN607_n
Xk_r_reg[11] QDFFRBN $PINS Q=raw_k[11] D=n199 CK=CTS_78 RB=FE_OFN606_n
Xk_r_reg[7] QDFFRBN $PINS Q=raw_k[7] D=n206 CK=CTS_70 RB=FE_OFN607_n
Xk_r_reg[6] QDFFRBN $PINS Q=raw_k[6] D=n207 CK=CTS_78 RB=FE_OFN606_n
Xk_r_reg[14] QDFFRBN $PINS Q=raw_k[14] D=n285 CK=CTS_78 RB=FE_OFN607_n
Xk_r_reg[15] QDFFRBN $PINS Q=raw_k[15] D=n286 CK=CTS_78 RB=FE_OFN606_n
Xk_r_reg[31] QDFFRBN $PINS Q=raw_k[31] D=n147 CK=CTS_78 RB=FE_OFN603_n
Xk_r_reg[30] QDFFRBN $PINS Q=raw_k[30] D=n148 CK=CTS_78 RB=FE_OFN605_n
Xk_r_reg[3] QDFFRBN $PINS Q=raw_k[3] D=n128 CK=CTS_78 RB=FE_OFN606_n
Xk_r_reg[2] QDFFRBN $PINS Q=raw_k[2] D=n129 CK=CTS_78 RB=FE_OFN606_n
Xk_r_reg[26] QDFFRBN $PINS Q=raw_k[26] D=n237 CK=CTS_78 RB=FE_OFN603_n
Xk_r_reg[27] QDFFRBN $PINS Q=raw_k[27] D=n238 CK=CTS_78 RB=FE_OFN603_n
Xk_r_reg[22] QDFFRBN $PINS Q=raw_k[22] D=n253 CK=CTS_78 RB=FE_OFN605_n
Xk_r_reg[23] QDFFRBN $PINS Q=raw_k[23] D=n254 CK=CTS_78 RB=FE_OFN605_n
Xk_r_reg[18] QDFFRBN $PINS Q=raw_k[18] D=n269 CK=CTS_78 RB=FE_OFN605_n
Xk_r_reg[19] QDFFRBN $PINS Q=raw_k[19] D=n270 CK=CTS_78 RB=FE_OFN605_n
Xk_r_reg[8] QDFFRBN $PINS Q=raw_k[8] D=n196 CK=CTS_78 RB=FE_OFN606_n
Xk_r_reg[9] QDFFRBN $PINS Q=raw_k[9] D=n197 CK=CTS_78 RB=FE_OFN607_n
Xk_r_reg[5] QDFFRBN $PINS Q=raw_k[5] D=n208 CK=CTS_70 RB=FE_OFN607_n
Xk_r_reg[4] QDFFRBN $PINS Q=raw_k[4] D=n209 CK=CTS_78 RB=FE_OFN606_n
Xk_r_reg[12] QDFFRBN $PINS Q=raw_k[12] D=n283 CK=CTS_78 RB=FE_OFN607_n
Xk_r_reg[13] QDFFRBN $PINS Q=raw_k[13] D=n284 CK=CTS_78 RB=FE_OFN606_n
Xk_r_reg[29] QDFFRBN $PINS Q=raw_k[29] D=n149 CK=CTS_78 RB=FE_OFN605_n
Xk_r_reg[28] QDFFRBN $PINS Q=raw_k[28] D=n150 CK=CTS_78 RB=FE_OFN603_n
Xk_r_reg[1] QDFFRBN $PINS Q=raw_k[1] D=n130 CK=CTS_78 RB=FE_OFN606_n
Xk_r_reg[0] QDFFRBN $PINS Q=raw_k[0] D=n131 CK=CTS_78 RB=FE_OFN606_n
Xk_r_reg[24] QDFFRBN $PINS Q=raw_k[24] D=n235 CK=CTS_78 RB=FE_OFN603_n
Xk_r_reg[25] QDFFRBN $PINS Q=raw_k[25] D=n236 CK=CTS_78 RB=FE_OFN603_n
Xk_r_reg[20] QDFFRBN $PINS Q=raw_k[20] D=n251 CK=CTS_78 RB=FE_OFN605_n
Xk_r_reg[21] QDFFRBN $PINS Q=raw_k[21] D=n252 CK=CTS_78 RB=FE_OFN605_n
Xk_r_reg[16] QDFFRBN $PINS Q=raw_k[16] D=n267 CK=CTS_78 RB=FE_OFN605_n
Xk_r_reg[17] QDFFRBN $PINS Q=raw_k[17] D=n268 CK=CTS_78 RB=FE_OFN605_n
Xraw1_r_reg[25] QDFFRBN $PINS Q=raw1[25] D=n232 CK=CTS_83 RB=FE_OFN600_n
Xraw1_r_reg[27] QDFFRBN $PINS Q=raw1[27] D=n234 CK=CTS_83 RB=FE_OFN612_n
Xraw1_r_reg[23] QDFFRBN $PINS Q=raw1[23] D=n250 CK=CTS_83 RB=FE_OFN612_n
Xstate_reg[3] QDFFRBN $PINS Q=state[3] D=n290 CK=CTS_70
+ RB=FE_OFN22_FE_DBTN1_i_i_rst
Xstate_reg[4] QDFFRBN $PINS Q=state[4] D=n291 CK=CTS_70
+ RB=FE_OFN22_FE_DBTN1_i_i_rst
Xraw2_r_reg[25] QDFFRBN $PINS Q=FE_PHN1228_raw2_25 D=n228 CK=CTS_70
+ RB=FE_OFN607_n
Xraw2_r_reg[27] QDFFRBN $PINS Q=FE_PHN1221_raw2_27 D=n230 CK=CTS_70
+ RB=FE_OFN607_n
Xraw2_r_reg[23] QDFFRBN $PINS Q=FE_PHN1241_raw2_23 D=n246 CK=CTS_71
+ RB=FE_OFN610_n
Xraw1_r_reg[24] QDFFRBN $PINS Q=raw1[24] D=n231 CK=CTS_83 RB=FE_OFN612_n
Xraw2_r_reg[24] QDFFRBN $PINS Q=raw2[24] D=n227 CK=CTS_78 RB=FE_OFN607_n
Xraw2_r_reg[22] QDFFRBN $PINS Q=raw2[22] D=n245 CK=CTS_78 RB=FE_OFN610_n
Xstate_reg[1] QDFFRBN $PINS Q=state[1] D=n288 CK=CTS_70
+ RB=FE_OFN22_FE_DBTN1_i_i_rst
Xstate_reg[0] QDFFRBN $PINS Q=state[0] D=n287 CK=CTS_70
+ RB=FE_OFN22_FE_DBTN1_i_i_rst
Xstate_reg[2] QDFFRBN $PINS Q=state[2] D=n289 CK=CTS_70
+ RB=FE_OFN22_FE_DBTN1_i_i_rst
Xraw_prime_r_reg[31] QDFFRBN $PINS Q=raw_prime[31] D=n159 CK=CTS_78
+ RB=FE_OFN604_n
Xraw_prime_r_reg[30] QDFFRBN $PINS Q=raw_prime[30] D=n160 CK=CTS_78
+ RB=FE_OFN604_n
Xraw_prime_r_reg[29] QDFFRBN $PINS Q=raw_prime[29] D=n161 CK=CTS_78
+ RB=FE_OFN604_n
Xraw_prime_r_reg[28] QDFFRBN $PINS Q=raw_prime[28] D=n162 CK=CTS_80
+ RB=FE_OFN613_n
Xraw_prime_r_reg[24] QDFFRBN $PINS Q=raw_prime[24] D=n223 CK=CTS_83
+ RB=FE_OFN612_n
Xraw_prime_r_reg[25] QDFFRBN $PINS Q=raw_prime[25] D=n224 CK=CTS_78
+ RB=FE_OFN604_n
Xraw_prime_r_reg[26] QDFFRBN $PINS Q=raw_prime[26] D=n225 CK=CTS_80
+ RB=FE_OFN604_n
Xraw_prime_r_reg[27] QDFFRBN $PINS Q=raw_prime[27] D=n226 CK=CTS_78
+ RB=FE_OFN604_n
Xraw_a_r_reg[25] QDFFRBN $PINS Q=FE_PHN1223_raw_a_25 D=n168 CK=CTS_80
+ RB=FE_OFN23_FE_DBTN1_i_i_rst
Xraw_a_r_reg[27] QDFFRBN $PINS Q=FE_PHN1229_raw_a_27 D=n170 CK=CTS_80
+ RB=FE_OFN23_FE_DBTN1_i_i_rst
Xraw_a_r_reg[23] QDFFRBN $PINS Q=raw_a[23] D=n174 CK=CTS_80
+ RB=FE_OFN473_FE_OFN4_FE_DBTN1_i_i_rst
Xraw_a_r_reg[24] QDFFRBN $PINS Q=FE_PHN1239_raw_a_24 D=n167 CK=CTS_80
+ RB=FE_OFN23_FE_DBTN1_i_i_rst
Xraw1_r_reg[21] QDFFRBN $PINS Q=raw1[21] D=n248 CK=CTS_83 RB=FE_OFN612_n
Xraw1_r_reg[19] QDFFRBN $PINS Q=raw1[19] D=n266 CK=CTS_80 RB=FE_OFN612_n
Xraw2_r_reg[21] QDFFRBN $PINS Q=FE_PHN1243_raw2_21 D=n244 CK=CTS_78
+ RB=FE_OFN610_n
Xraw2_r_reg[19] QDFFRBN $PINS Q=raw2[19] D=n262 CK=CTS_71 RB=FE_OFN610_n
Xraw1_r_reg[22] QDFFRBN $PINS Q=raw1[22] D=n249 CK=CTS_83 RB=FE_OFN612_n
Xraw1_r_reg[20] QDFFRBN $PINS Q=raw1[20] D=n247 CK=CTS_80 RB=FE_OFN612_n
Xraw2_r_reg[20] QDFFRBN $PINS Q=FE_PHN1204_raw2_20 D=n243 CK=CTS_71
+ RB=FE_OFN609_n
Xraw_prime_r_reg[21] QDFFRBN $PINS Q=raw_prime[21] D=n240 CK=CTS_78
+ RB=FE_OFN604_n
Xraw_prime_r_reg[22] QDFFRBN $PINS Q=raw_prime[22] D=n241 CK=CTS_78
+ RB=FE_OFN604_n
Xraw_prime_r_reg[23] QDFFRBN $PINS Q=raw_prime[23] D=n242 CK=CTS_78
+ RB=FE_OFN604_n
Xraw_a_r_reg[21] QDFFRBN $PINS Q=raw_a[21] D=n172 CK=CTS_80
+ RB=FE_OFN473_FE_OFN4_FE_DBTN1_i_i_rst
Xraw_a_r_reg[19] QDFFRBN $PINS Q=FE_PHN1218_raw_a_19 D=n178 CK=CTS_80
+ RB=FE_OFN473_FE_OFN4_FE_DBTN1_i_i_rst
Xraw_a_r_reg[22] QDFFRBN $PINS Q=raw_a[22] D=n173 CK=CTS_80
+ RB=FE_OFN473_FE_OFN4_FE_DBTN1_i_i_rst
Xraw_a_r_reg[20] QDFFRBN $PINS Q=raw_a[20] D=n171 CK=CTS_80
+ RB=FE_OFN473_FE_OFN4_FE_DBTN1_i_i_rst
Xraw1_r_reg[17] QDFFRBN $PINS Q=raw1[17] D=n264 CK=CTS_80 RB=FE_OFN612_n
Xraw2_r_reg[17] QDFFRBN $PINS Q=raw2[17] D=n260 CK=CTS_71 RB=FE_OFN610_n
Xraw1_r_reg[18] QDFFRBN $PINS Q=raw1[18] D=n265 CK=CTS_80 RB=FE_OFN612_n
Xraw2_r_reg[18] QDFFRBN $PINS Q=FE_PHN1207_raw2_18 D=n261 CK=CTS_71
+ RB=FE_OFN610_n
Xraw1_r_reg[16] QDFFRBN $PINS Q=raw1[16] D=n263 CK=CTS_80 RB=FE_OFN613_n
Xraw_prime_r_reg[18] QDFFRBN $PINS Q=raw_prime[18] D=n257 CK=CTS_78
+ RB=FE_OFN604_n
Xraw2_r_reg[16] QDFFRBN $PINS Q=FE_PHN1240_raw2_16 D=n259 CK=CTS_71
+ RB=FE_OFN610_n
Xraw_prime_r_reg[20] QDFFRBN $PINS Q=raw_prime[20] D=n239 CK=CTS_83
+ RB=FE_OFN612_n
Xraw_prime_r_reg[19] QDFFRBN $PINS Q=raw_prime[19] D=n258 CK=CTS_78
+ RB=FE_OFN605_n
Xraw_a_r_reg[17] QDFFRBN $PINS Q=FE_PHN1222_raw_a_17 D=n176 CK=CTS_80
+ RB=FE_OFN473_FE_OFN4_FE_DBTN1_i_i_rst
Xraw_a_r_reg[18] QDFFRBN $PINS Q=FE_PHN1220_raw_a_18 D=n177 CK=CTS_80
+ RB=FE_OFN473_FE_OFN4_FE_DBTN1_i_i_rst
Xraw_a_r_reg[16] QDFFRBN $PINS Q=raw_a[16] D=n175 CK=CTS_80
+ RB=FE_OFN473_FE_OFN4_FE_DBTN1_i_i_rst
Xraw1_r_reg[13] QDFFRBN $PINS Q=raw1[13] D=n280 CK=CTS_80 RB=FE_OFN613_n
Xraw2_r_reg[13] QDFFRBN $PINS Q=raw2[13] D=n276 CK=CTS_71 RB=FE_OFN610_n
Xraw2_r_reg[15] QDFFRBN $PINS Q=raw2[15] D=n278 CK=CTS_71 RB=FE_OFN610_n
Xraw1_r_reg[12] QDFFRBN $PINS Q=raw1[12] D=n279 CK=CTS_80 RB=FE_OFN614_n
Xraw1_r_reg[14] QDFFRBN $PINS Q=raw1[14] D=n281 CK=CTS_80 RB=FE_OFN614_n
Xraw2_r_reg[12] QDFFRBN $PINS Q=FE_PHN1304_raw2_12 D=n275 CK=CTS_71
+ RB=FE_OFN610_n
Xraw2_r_reg[14] QDFFRBN $PINS Q=FE_PHN1272_raw2_14 D=n277 CK=CTS_71
+ RB=FE_OFN610_n
Xraw_prime_r_reg[14] QDFFRBN $PINS Q=raw_prime[14] D=n273 CK=CTS_78
+ RB=FE_OFN606_n
Xraw_prime_r_reg[15] QDFFRBN $PINS Q=raw_prime[15] D=n274 CK=CTS_78
+ RB=FE_OFN606_n
Xraw_prime_r_reg[16] QDFFRBN $PINS Q=raw_prime[16] D=n255 CK=CTS_80
+ RB=FE_OFN613_n
Xraw_prime_r_reg[17] QDFFRBN $PINS Q=raw_prime[17] D=n256 CK=CTS_78
+ RB=FE_OFN604_n
Xraw_a_r_reg[13] QDFFRBN $PINS Q=FE_PHN1265_raw_a_13 D=n180 CK=CTS_80
+ RB=FE_OFN21_FE_DBTN1_i_i_rst
Xraw_a_r_reg[15] QDFFRBN $PINS Q=raw_a[15] D=n182 CK=CTS_80
+ RB=FE_OFN21_FE_DBTN1_i_i_rst
Xraw_a_r_reg[12] QDFFRBN $PINS Q=FE_PHN1279_raw_a_12 D=n179 CK=CTS_80
+ RB=FE_OFN21_FE_DBTN1_i_i_rst
Xraw_a_r_reg[14] QDFFRBN $PINS Q=FE_PHN1278_raw_a_14 D=n181 CK=CTS_80
+ RB=FE_OFN473_FE_OFN4_FE_DBTN1_i_i_rst
Xraw1_r_reg[9] QDFFRBN $PINS Q=raw1[9] D=n193 CK=CTS_80 RB=FE_OFN614_n
Xraw1_r_reg[11] QDFFRBN $PINS Q=raw1[11] D=n195 CK=CTS_80 RB=FE_OFN614_n
Xraw2_r_reg[9] QDFFRBN $PINS Q=raw2[9] D=n189 CK=CTS_71 RB=FE_OFN610_n
Xraw2_r_reg[11] QDFFRBN $PINS Q=FE_PHN1291_raw2_11 D=n191 CK=CTS_71
+ RB=FE_OFN610_n
Xraw1_r_reg[10] QDFFRBN $PINS Q=raw1[10] D=n194 CK=CTS_80 RB=FE_OFN614_n
Xraw2_r_reg[10] QDFFRBN $PINS Q=FE_PHN1283_raw2_10 D=n190 CK=CTS_71
+ RB=FE_OFN610_n
Xraw_prime_r_reg[11] QDFFRBN $PINS Q=raw_prime[11] D=n187 CK=CTS_71
+ RB=FE_OFN610_n
Xraw_prime_r_reg[12] QDFFRBN $PINS Q=raw_prime[12] D=n271 CK=CTS_80
+ RB=FE_OFN21_FE_DBTN1_i_i_rst
Xraw_prime_r_reg[13] QDFFRBN $PINS Q=raw_prime[13] D=n272 CK=CTS_71
+ RB=FE_OFN610_n
Xraw_a_r_reg[11] QDFFRBN $PINS Q=FE_PHN1281_raw_a_11 D=n183 CK=CTS_80
+ RB=FE_OFN21_FE_DBTN1_i_i_rst
Xraw_a_r_reg[9] QDFFRBN $PINS Q=FE_PHN1284_raw_a_9 D=n201 CK=CTS_80
+ RB=FE_OFN21_FE_DBTN1_i_i_rst
Xraw_a_r_reg[10] QDFFRBN $PINS Q=raw_a[10] D=n202 CK=CTS_80
+ RB=FE_OFN21_FE_DBTN1_i_i_rst
Xraw1_r_reg[7] QDFFRBN $PINS Q=raw1[7] D=n210 CK=CTS_80 RB=FE_OFN614_n
Xraw2_r_reg[7] QDFFRBN $PINS Q=FE_PHN1318_raw2_7 D=n214 CK=CTS_70
+ RB=FE_OFN610_n
Xraw2_r_reg[5] QDFFRBN $PINS Q=raw2[5] D=n216 CK=CTS_70 RB=FE_OFN609_n
Xraw1_r_reg[8] QDFFRBN $PINS Q=raw1[8] D=n192 CK=CTS_80 RB=FE_OFN614_n
Xraw2_r_reg[8] QDFFRBN $PINS Q=raw2[8] D=n188 CK=CTS_71 RB=FE_OFN610_n
Xraw1_r_reg[6] QDFFRBN $PINS Q=raw1[6] D=n211 CK=CTS_70 RB=FE_OFN614_n
Xraw2_r_reg[6] QDFFRBN $PINS Q=FE_PHN1321_raw2_6 D=n215 CK=CTS_70
+ RB=FE_OFN607_n
Xraw_prime_r_reg[8] QDFFRBN $PINS Q=raw_prime[8] D=n184 CK=CTS_80
+ RB=FE_OFN614_n
Xraw_prime_r_reg[9] QDFFRBN $PINS Q=raw_prime[9] D=n185 CK=CTS_71
+ RB=FE_OFN610_n
Xraw_prime_r_reg[10] QDFFRBN $PINS Q=raw_prime[10] D=n186 CK=CTS_71
+ RB=FE_OFN610_n
Xraw_prime_r_reg[7] QDFFRBN $PINS Q=raw_prime[7] D=n218 CK=CTS_78
+ RB=FE_OFN604_n
Xraw_a_r_reg[7] QDFFRBN $PINS Q=FE_PHN1330_raw_a_7 D=n222 CK=CTS_80
+ RB=FE_OFN21_FE_DBTN1_i_i_rst
Xraw_a_r_reg[8] QDFFRBN $PINS Q=raw_a[8] D=n200 CK=CTS_80
+ RB=FE_OFN21_FE_DBTN1_i_i_rst
Xraw_a_r_reg[6] QDFFRBN $PINS Q=raw_a[6] D=n203 CK=CTS_80
+ RB=FE_OFN21_FE_DBTN1_i_i_rst
Xraw1_r_reg[5] QDFFRBN $PINS Q=raw1[5] D=n212 CK=CTS_70 RB=FE_OFN614_n
Xraw1_r_reg[3] QDFFRBN $PINS Q=raw1[3] D=n143 CK=CTS_78 RB=FE_OFN614_n
Xraw1_r_reg[1] QDFFRBN $PINS Q=raw1[1] D=n145 CK=CTS_78 RB=FE_OFN614_n
Xraw2_r_reg[3] QDFFRBN $PINS Q=FE_PHN1311_raw2_3 D=n139 CK=CTS_70
+ RB=FE_OFN607_n
Xraw2_r_reg[1] QDFFRBN $PINS Q=FE_PHN1289_raw2_1 D=n141 CK=CTS_70
+ RB=FE_OFN22_FE_DBTN1_i_i_rst
Xraw1_r_reg[4] QDFFRBN $PINS Q=raw1[4] D=n213 CK=CTS_70
+ RB=FE_OFN22_FE_DBTN1_i_i_rst
Xraw1_r_reg[2] QDFFRBN $PINS Q=raw1[2] D=n144 CK=CTS_78 RB=FE_OFN614_n
Xraw2_r_reg[4] QDFFRBN $PINS Q=raw2[4] D=n217 CK=CTS_70 RB=FE_OFN607_n
Xraw2_r_reg[2] QDFFRBN $PINS Q=raw2[2] D=n140 CK=CTS_78 RB=FE_OFN607_n
Xraw_prime_r_reg[6] QDFFRBN $PINS Q=raw_prime[6] D=n219 CK=CTS_78
+ RB=FE_OFN603_n
Xraw_prime_r_reg[5] QDFFRBN $PINS Q=raw_prime[5] D=n220 CK=CTS_78
+ RB=FE_OFN603_n
Xraw_a_r_reg[5] QDFFRBN $PINS Q=raw_a[5] D=n204 CK=CTS_80
+ RB=FE_OFN21_FE_DBTN1_i_i_rst
Xraw_a_r_reg[3] QDFFRBN $PINS Q=FE_PHN1307_raw_a_3 D=n132 CK=CTS_80
+ RB=FE_OFN23_FE_DBTN1_i_i_rst
Xraw_a_r_reg[4] QDFFRBN $PINS Q=FE_PHN1332_raw_a_4 D=n205 CK=CTS_80
+ RB=FE_OFN23_FE_DBTN1_i_i_rst
Xraw_prime_r_reg[1] QDFFRBP $PINS Q=n312 D=n138 CK=CTS_78 RB=FE_OFN606_n
Xraw_prime_r_reg[0] DFFRBT $PINS Q=n310 QB=n309 D=n292 CK=CTS_80 RB=FE_OFN614_n
Xraw_a_r_reg[31] QDFFRBS $PINS Q=raw_a[31] D=n163 CK=CTS_78
+ RB=FE_OFN23_FE_DBTN1_i_i_rst
Xraw_prime_r_reg[4] QDFFRBN $PINS Q=raw_prime[4] D=n221 CK=CTS_78
+ RB=FE_OFN614_n
Xraw_a_r_reg[2] QDFFRBN $PINS Q=FE_PHN1316_raw_a_2 D=n133 CK=CTS_78
+ RB=FE_OFN614_n
Xraw_a_r_reg[1] QDFFRBN $PINS Q=FE_PHN1302_raw_a_1 D=n134 CK=CTS_80
+ RB=FE_OFN21_FE_DBTN1_i_i_rst
Xraw_a_r_reg[0] QDFFRBN $PINS Q=raw_a[0] D=n135 CK=CTS_80 RB=FE_OFN614_n
Xraw_prime_r_reg[3] QDFFRBN $PINS Q=raw_prime[3] D=n136 CK=CTS_78
+ RB=FE_OFN603_n
Xraw2_r_reg[0] QDFFRBN $PINS Q=FE_PHN1287_raw2_0 D=n142 CK=CTS_70
+ RB=FE_OFN22_FE_DBTN1_i_i_rst
Xraw1_r_reg[0] QDFFRBN $PINS Q=raw1[0] D=n146 CK=CTS_78 RB=FE_OFN614_n
Xraw2_r_reg[31] QDFFRBN $PINS Q=raw2[31] D=n155 CK=CTS_70 RB=FE_OFN607_n
Xraw1_r_reg[15] QDFFRBN $PINS Q=raw1[15] D=n282 CK=CTS_80 RB=FE_OFN613_n
Xraw_prime_r_reg[2] QDFFRBT $PINS Q=raw_prime[2] D=n137 CK=CTS_78
+ RB=FE_OFN603_n
XU309 AN2 $PINS O=n293 I1=n80 I2=n123
XU310 AN2 $PINS O=n294 I1=n71 I2=n82
XU311 AN3 $PINS O=n295 I1=n381 I2=n383 I3=n68
XU312 ND2 $PINS O=n296 I1=n72 I2=n73
XU313 ND2 $PINS O=n297 I1=n70 I2=n73
XU314 ND2 $PINS O=n298 I1=n72 I2=n71
XU315 ND2 $PINS O=n299 I1=n72 I2=n80
XU316 ND2 $PINS O=n300 I1=n69 I2=state[0]
XU317 OR3 $PINS O=kPx[0] I1=n330 I2=n331 I3=n332
XU318 OR3 $PINS O=kPy[0] I1=n318 I2=n319 I3=n320
XU319 OR3 $PINS O=kPy[1] I1=n321 I2=n322 I3=n323
XU320 OR3 $PINS O=kPy[2] I1=n324 I2=n325 I3=n326
XU321 OR3 $PINS O=kPy[3] I1=n327 I2=n328 I3=n329
XU322 OR3 $PINS O=kPx[1] I1=n333 I2=n334 I3=n335
XU323 OR3 $PINS O=kPx[2] I1=n336 I2=n337 I3=n338
XU324 OR3 $PINS O=kPx[3] I1=n339 I2=n340 I3=n341
XU325 INV1S $PINS O=n311 I=n309
XU328 ND2S $PINS O=n57 I1=done I2=load_done
XU329 INV1S $PINS O=n383 I=n55
XU330 NR3 $PINS O=n51 I1=n380 I2=n384 I3=n52
XU331 ND3 $PINS O=n43 I1=FE_OFN491_n298 I2=FE_OFN490_n297 I3=n51
XU332 ND3 $PINS O=n41 I1=FE_OFN491_n298 I2=FE_OFN489_n296 I3=n51
XU333 ND3 $PINS O=n39 I1=FE_OFN490_n297 I2=FE_OFN489_n296 I3=n51
XU334 ND3 $PINS O=n55 I1=FE_OFN490_n297 I2=FE_OFN489_n296 I3=FE_OFN491_n298
XU335 INV1S $PINS O=n381 I=n52
XU336 ND3 $PINS O=n50 I1=FE_OFN488_n44 I2=FE_OFN492_n299 I3=n49
XU337 INV1S $PINS O=n382 I=n44
XU338 NR2 $PINS O=n53 I1=n54 I2=n55
XU339 NR2 $PINS O=n77 I1=n78 I2=n60
XU340 OR2 $PINS O=n345 I1=FE_OFN487_FE_DBTN0_n295 I2=n37
XU341 OR2 $PINS O=n344 I1=FE_DBTN0_n295 I2=n37
XU342 OR2 $PINS O=n33 I1=FE_DBTN0_n295 I2=n37
XU343 ND3 $PINS O=n52 I1=n299 I2=FE_OFN493_n300 I3=n74
XU344 NR2 $PINS O=n74 I1=n382 I2=n54
XU345 ND3 $PINS O=n36 I1=n383 I2=n37 I3=n381
XU346 ND3 $PINS O=n45 I1=FE_OFN492_n299 I2=FE_OFN493_n300 I3=n49
XU347 ND3 $PINS O=n47 I1=FE_OFN488_n44 I2=FE_OFN493_n300 I3=n49
XU349 INV1S $PINS O=n384 I=n343
XU350 INV1S $PINS O=n380 I=n37
XU351 NR2 $PINS O=n65 I1=n386 I2=n294
XU352 ND3 $PINS O=n288 I1=n61 I2=n298 I3=n62
XU353 ND3 $PINS O=n290 I1=n61 I2=n66 I3=n67
XU354 NR3 $PINS O=n67 I1=n293 I2=n384 I3=load_done
XU358 INV1S $PINS O=n386 I=n66
XU359 ND3 $PINS O=n289 I1=n56 I2=n297 I3=n63
XU360 NR3 $PINS O=n63 I1=n317 I2=n382 I3=n293
XU367 AOI13HS $PINS O=n287 A1=n59 B1=n56 B2=n57 B3=n58
XU368 AN2 $PINS O=n60 I1=n80 I2=n82
XU369 AN2 $PINS O=n78 I1=n123 I2=n81
XU370 ND3 $PINS O=n54 I1=n75 I2=n61 I3=n76
XU371 NR2 $PINS O=n75 I1=n291 I2=n79
XU372 NR3 $PINS O=n76 I1=n386 I2=load_done I3=n293
XU373 AN2 $PINS O=n317 I1=n73 I2=n123
XU374 NR2 $PINS O=n123 I1=n385 I2=n387
XU375 AN2 $PINS O=n80 I1=n124 I2=n388
XU376 AN2 $PINS O=load_done I1=n81 I2=n82
XU377 NR2 $PINS O=n68 I1=n384 I2=n59
XU379 AN2 $PINS O=n291 I1=n71 I2=n123
XU380 ND2 $PINS O=n44 I1=n70 I2=n80
XU382 AN2 $PINS O=n69 I1=n81 I2=n387
XU383 ND2 $PINS O=n343 I1=n70 I2=n71
XU384 NR3 $PINS O=n73 I1=state[1] I2=state[4] I3=n388
XU385 NR3 $PINS O=n81 I1=state[2] I2=state[4] I3=state[1]
XU386 NR2 $PINS O=n82 I1=n387 I2=state[0]
XU387 AN2 $PINS O=n71 I1=state[2] I2=n124
XU388 MOAI1S $PINS O=n270 A1=n368 A2=FE_OFN489_n296 B1=FE_PHN1010_raw_k_19
+ B2=n43
XU389 MOAI1S $PINS O=n269 A1=n369 A2=FE_OFN489_n296 B1=FE_PHN1002_raw_k_18
+ B2=n43
XU390 MOAI1S $PINS O=n268 A1=n370 A2=FE_OFN489_n296 B1=FE_PHN1040_raw_k_17
+ B2=n43
XU391 MOAI1S $PINS O=n267 A1=n371 A2=FE_OFN489_n296 B1=FE_PHN1018_raw_k_16
+ B2=n43
XU392 MOAI1S $PINS O=n266 A1=n372 A2=n296 B1=FE_PHN1019_raw1_19 B2=n43
XU393 MOAI1S $PINS O=n265 A1=n373 A2=n296 B1=FE_PHN1091_raw1_18 B2=n43
XU394 MOAI1S $PINS O=n264 A1=n374 A2=n296 B1=FE_PHN990_raw1_17 B2=n43
XU395 MOAI1S $PINS O=n263 A1=n375 A2=n296 B1=FE_PHN1131_raw1_16 B2=n43
XU396 MOAI1S $PINS O=n262 A1=n376 A2=FE_OFN489_n296 B1=FE_PHN1210_raw2_19
+ B2=n43
XU397 MOAI1S $PINS O=n261 A1=n377 A2=FE_OFN489_n296 B1=raw2[18] B2=n43
XU398 MOAI1S $PINS O=n260 A1=n378 A2=FE_OFN489_n296 B1=FE_PHN1216_raw2_17
+ B2=n43
XU399 MOAI1S $PINS O=n259 A1=n379 A2=FE_OFN489_n296 B1=raw2[16] B2=n43
XU400 MOAI1S $PINS O=n258 A1=n364 A2=FE_OFN489_n296 B1=FE_OFN43_raw_prime_19
+ B2=n43
XU401 MOAI1S $PINS O=n257 A1=n365 A2=FE_OFN489_n296 B1=FE_OFN44_raw_prime_18
+ B2=n43
XU402 MOAI1S $PINS O=n256 A1=n366 A2=FE_OFN489_n296 B1=FE_OFN45_raw_prime_17
+ B2=n43
XU403 MOAI1S $PINS O=n178 A1=n360 A2=n296 B1=raw_a[19] B2=n43
XU404 MOAI1S $PINS O=n177 A1=n361 A2=n296 B1=raw_a[18] B2=n43
XU405 MOAI1S $PINS O=n176 A1=n362 A2=n296 B1=raw_a[17] B2=n43
XU406 MOAI1S $PINS O=n175 A1=n363 A2=n296 B1=FE_PHN1266_raw_a_16 B2=n43
XU407 MOAI1S $PINS O=n254 A1=n368 A2=FE_OFN490_n297 B1=FE_PHN1021_raw_k_23
+ B2=n41
XU408 MOAI1S $PINS O=n253 A1=n369 A2=FE_OFN490_n297 B1=FE_PHN1022_raw_k_22
+ B2=n41
XU409 MOAI1S $PINS O=n252 A1=n370 A2=FE_OFN490_n297 B1=FE_PHN1027_raw_k_21
+ B2=n41
XU410 MOAI1S $PINS O=n251 A1=n371 A2=FE_OFN490_n297 B1=FE_PHN1016_raw_k_20
+ B2=n41
XU411 MOAI1S $PINS O=n250 A1=n372 A2=FE_OFN490_n297 B1=FE_PHN962_raw1_23 B2=n41
XU412 MOAI1S $PINS O=n249 A1=n373 A2=FE_OFN490_n297 B1=FE_PHN973_raw1_22 B2=n41
XU413 MOAI1S $PINS O=n248 A1=n374 A2=FE_OFN490_n297 B1=FE_PHN1029_raw1_21
+ B2=n41
XU414 MOAI1S $PINS O=n247 A1=n375 A2=FE_OFN490_n297 B1=FE_PHN1056_raw1_20
+ B2=n41
XU415 MOAI1S $PINS O=n246 A1=n376 A2=n297 B1=raw2[23] B2=n41
XU416 MOAI1S $PINS O=n245 A1=n377 A2=n297 B1=FE_PHN1209_raw2_22 B2=n41
XU417 MOAI1S $PINS O=n244 A1=n378 A2=n297 B1=raw2[21] B2=n41
XU418 MOAI1S $PINS O=n243 A1=n379 A2=n297 B1=raw2[20] B2=n41
XU419 MOAI1S $PINS O=n242 A1=n364 A2=FE_OFN490_n297 B1=FE_OFN39_raw_prime_23
+ B2=n41
XU420 MOAI1S $PINS O=n241 A1=n365 A2=FE_OFN490_n297 B1=raw_prime[22] B2=n41
XU421 MOAI1S $PINS O=n240 A1=n366 A2=FE_OFN490_n297 B1=FE_OFN41_raw_prime_21
+ B2=n41
XU422 MOAI1S $PINS O=n174 A1=n360 A2=FE_OFN490_n297 B1=FE_PHN1203_raw_a_23
+ B2=n41
XU423 MOAI1S $PINS O=n173 A1=n361 A2=FE_OFN490_n297 B1=FE_PHN1214_raw_a_22
+ B2=n41
XU424 MOAI1S $PINS O=n172 A1=n362 A2=FE_OFN490_n297 B1=FE_PHN1206_raw_a_21
+ B2=n41
XU425 MOAI1S $PINS O=n171 A1=n363 A2=FE_OFN490_n297 B1=FE_PHN1208_raw_a_20
+ B2=n41
XU426 MOAI1S $PINS O=n238 A1=n368 A2=FE_OFN491_n298 B1=FE_PHN1024_raw_k_27
+ B2=n39
XU427 MOAI1S $PINS O=n237 A1=n369 A2=FE_OFN491_n298 B1=FE_PHN1487_raw_k_26
+ B2=n39
XU428 MOAI1S $PINS O=n236 A1=n370 A2=FE_OFN491_n298 B1=FE_PHN1015_raw_k_25
+ B2=n39
XU429 MOAI1S $PINS O=n235 A1=n371 A2=FE_OFN491_n298 B1=FE_PHN1035_raw_k_24
+ B2=n39
XU430 MOAI1S $PINS O=n234 A1=n372 A2=n298 B1=FE_PHN1069_raw1_27 B2=n39
XU431 MOAI1S $PINS O=n233 A1=n373 A2=n298 B1=FE_PHN1081_raw1_26 B2=n39
XU432 MOAI1S $PINS O=n232 A1=n374 A2=n298 B1=FE_PHN1060_raw1_25 B2=n39
XU433 MOAI1S $PINS O=n231 A1=n375 A2=n298 B1=FE_PHN1103_raw1_24 B2=n39
XU434 MOAI1S $PINS O=n230 A1=n376 A2=FE_OFN491_n298 B1=raw2[27] B2=n39
XU435 MOAI1S $PINS O=n229 A1=n377 A2=FE_OFN491_n298 B1=raw2[26] B2=n39
XU436 MOAI1S $PINS O=n228 A1=n378 A2=FE_OFN491_n298 B1=raw2[25] B2=n39
XU437 MOAI1S $PINS O=n227 A1=n379 A2=FE_OFN491_n298 B1=FE_PHN1227_raw2_24
+ B2=n39
XU438 MOAI1S $PINS O=n226 A1=n364 A2=FE_OFN491_n298 B1=raw_prime[27] B2=n39
XU439 MOAI1S $PINS O=n225 A1=n365 A2=FE_OFN491_n298 B1=raw_prime[26] B2=n39
XU440 MOAI1S $PINS O=n224 A1=n366 A2=FE_OFN491_n298 B1=FE_OFN37_raw_prime_25
+ B2=n39
XU441 MOAI1S $PINS O=n170 A1=n360 A2=FE_OFN491_n298 B1=raw_a[27] B2=n39
XU442 MOAI1S $PINS O=n169 A1=n361 A2=FE_OFN491_n298 B1=raw_a[26] B2=n39
XU443 MOAI1S $PINS O=n168 A1=n362 A2=FE_OFN491_n298 B1=raw_a[25] B2=n39
XU444 MOAI1S $PINS O=n167 A1=n363 A2=FE_OFN491_n298 B1=raw_a[24] B2=n39
XU445 MOAI1S $PINS O=n166 A1=n361 A2=FE_OFN494_n343 B1=raw_a[30] B2=n36
XU446 MOAI1S $PINS O=n165 A1=n362 A2=FE_OFN494_n343 B1=raw_a[29] B2=n36
XU447 MOAI1S $PINS O=n164 A1=n363 A2=FE_OFN494_n343 B1=raw_a[28] B2=n36
XU448 MOAI1S $PINS O=n163 A1=n360 A2=FE_OFN494_n343 B1=FE_PHN1193_raw_a_31
+ B2=n36
XU449 MOAI1S $PINS O=n161 A1=n366 A2=FE_OFN494_n343 B1=FE_OFN33_raw_prime_29
+ B2=n36
XU450 MOAI1S $PINS O=n160 A1=n365 A2=FE_OFN494_n343 B1=raw_prime[30] B2=n36
XU451 MOAI1S $PINS O=n159 A1=n364 A2=FE_OFN494_n343 B1=raw_prime[31] B2=n36
XU452 MOAI1S $PINS O=n158 A1=n379 A2=FE_OFN494_n343 B1=FE_PHN1255_raw2_28
+ B2=n36
XU453 MOAI1S $PINS O=n157 A1=n378 A2=FE_OFN494_n343 B1=raw2[29] B2=n36
XU454 MOAI1S $PINS O=n156 A1=n377 A2=FE_OFN494_n343 B1=raw2[30] B2=n36
XU455 MOAI1S $PINS O=n155 A1=n376 A2=FE_OFN494_n343 B1=FE_PHN970_raw2_31 B2=n36
XU456 MOAI1S $PINS O=n154 A1=n375 A2=n343 B1=FE_PHN1134_raw1_28 B2=n36
XU457 MOAI1S $PINS O=n153 A1=n374 A2=n343 B1=FE_PHN1038_raw1_29 B2=n36
XU458 MOAI1S $PINS O=n152 A1=n373 A2=n343 B1=FE_PHN1050_raw1_30 B2=n36
XU459 MOAI1S $PINS O=n151 A1=n372 A2=n343 B1=FE_PHN860_raw1_31 B2=n36
XU460 MOAI1S $PINS O=n150 A1=n371 A2=FE_OFN494_n343 B1=FE_PHN1008_raw_k_28
+ B2=n36
XU461 MOAI1S $PINS O=n149 A1=n370 A2=FE_OFN494_n343 B1=FE_PHN1004_raw_k_29
+ B2=n36
XU462 MOAI1S $PINS O=n148 A1=n369 A2=FE_OFN494_n343 B1=FE_PHN1043_raw_k_30
+ B2=n36
XU463 MOAI1S $PINS O=n147 A1=n368 A2=FE_OFN494_n343 B1=FE_PHN1023_raw_k_31
+ B2=n36
XU464 MOAI1S $PINS O=n286 A1=n368 A2=FE_OFN488_n44 B1=FE_PHN1005_raw_k_15
+ B2=n45
XU465 MOAI1S $PINS O=n285 A1=n369 A2=FE_OFN488_n44 B1=FE_PHN1013_raw_k_14
+ B2=n45
XU466 MOAI1S $PINS O=n284 A1=n370 A2=FE_OFN488_n44 B1=FE_PHN1020_raw_k_13
+ B2=n45
XU467 MOAI1S $PINS O=n283 A1=n371 A2=FE_OFN488_n44 B1=FE_PHN1032_raw_k_12
+ B2=n45
XU468 MOAI1S $PINS O=n282 A1=n372 A2=n44 B1=FE_PHN998_raw1_15 B2=n45
XU469 MOAI1S $PINS O=n281 A1=n373 A2=n44 B1=FE_PHN984_raw1_14 B2=n45
XU470 MOAI1S $PINS O=n280 A1=n374 A2=n44 B1=FE_PHN1044_raw1_13 B2=n45
XU471 MOAI1S $PINS O=n279 A1=n375 A2=n44 B1=FE_PHN1121_raw1_12 B2=n45
XU472 MOAI1S $PINS O=n278 A1=n376 A2=FE_OFN488_n44 B1=FE_PHN1264_raw2_15 B2=n45
XU473 MOAI1S $PINS O=n277 A1=n377 A2=FE_OFN488_n44 B1=raw2[14] B2=n45
XU474 MOAI1S $PINS O=n276 A1=n378 A2=FE_OFN488_n44 B1=FE_PHN1285_raw2_13 B2=n45
XU475 MOAI1S $PINS O=n275 A1=n379 A2=FE_OFN488_n44 B1=raw2[12] B2=n45
XU476 MOAI1S $PINS O=n274 A1=n364 A2=FE_OFN488_n44 B1=raw_prime[15] B2=n45
XU477 MOAI1S $PINS O=n273 A1=n365 A2=FE_OFN488_n44 B1=raw_prime[14] B2=n45
XU478 MOAI1S $PINS O=n272 A1=n366 A2=FE_OFN488_n44 B1=raw_prime[13] B2=n45
XU479 MOAI1S $PINS O=n182 A1=n360 A2=n44 B1=FE_PHN1280_raw_a_15 B2=n45
XU480 MOAI1S $PINS O=n181 A1=n361 A2=n44 B1=raw_a[14] B2=n45
XU481 MOAI1S $PINS O=n180 A1=n362 A2=n44 B1=raw_a[13] B2=n45
XU482 MOAI1S $PINS O=n179 A1=n363 A2=n44 B1=raw_a[12] B2=n45
XU483 MOAI1S $PINS O=n222 A1=n360 A2=FE_OFN493_n300 B1=raw_a[7] B2=n50
XU484 MOAI1S $PINS O=n220 A1=n366 A2=FE_OFN493_n300 B1=FE_OFN101_raw_prime_5
+ B2=n50
XU485 MOAI1S $PINS O=n219 A1=n365 A2=FE_OFN493_n300 B1=raw_prime[6] B2=n50
XU486 MOAI1S $PINS O=n218 A1=n364 A2=FE_OFN493_n300 B1=raw_prime[7] B2=n50
XU487 MOAI1S $PINS O=n217 A1=n379 A2=n300 B1=FE_PHN1317_raw2_4 B2=n50
XU488 MOAI1S $PINS O=n216 A1=n378 A2=n300 B1=FE_PHN1313_raw2_5 B2=n50
XU489 MOAI1S $PINS O=n215 A1=n377 A2=n300 B1=raw2[6] B2=n50
XU490 MOAI1S $PINS O=n214 A1=n376 A2=n300 B1=raw2[7] B2=n50
XU491 MOAI1S $PINS O=n213 A1=n375 A2=FE_OFN493_n300 B1=FE_PHN1147_raw1_4 B2=n50
XU492 MOAI1S $PINS O=n212 A1=n374 A2=FE_OFN493_n300 B1=FE_PHN1102_raw1_5 B2=n50
XU493 MOAI1S $PINS O=n211 A1=n373 A2=FE_OFN493_n300 B1=FE_PHN1135_raw1_6 B2=n50
XU494 MOAI1S $PINS O=n210 A1=n372 A2=FE_OFN493_n300 B1=FE_PHN1094_raw1_7 B2=n50
XU495 MOAI1S $PINS O=n209 A1=n371 A2=n300 B1=FE_PHN999_raw_k_4 B2=n50
XU496 MOAI1S $PINS O=n208 A1=n370 A2=n300 B1=FE_PHN994_raw_k_5 B2=n50
XU497 MOAI1S $PINS O=n207 A1=n369 A2=n300 B1=FE_PHN1505_raw_k_6 B2=n50
XU498 MOAI1S $PINS O=n206 A1=n368 A2=n300 B1=FE_PHN1003_raw_k_7 B2=n50
XU499 MOAI1S $PINS O=n205 A1=n363 A2=FE_OFN493_n300 B1=raw_a[4] B2=n50
XU500 MOAI1S $PINS O=n204 A1=n362 A2=FE_OFN493_n300 B1=FE_PHN1303_raw_a_5
+ B2=n50
XU501 MOAI1S $PINS O=n203 A1=n361 A2=FE_OFN493_n300 B1=raw_a[6] B2=n50
XU502 MOAI1S $PINS O=n202 A1=n361 A2=n299 B1=FE_PHN1296_raw_a_10 B2=n47
XU503 MOAI1S $PINS O=n201 A1=n362 A2=n299 B1=raw_a[9] B2=n47
XU504 MOAI1S $PINS O=n200 A1=n363 A2=n299 B1=FE_PHN1288_raw_a_8 B2=n47
XU505 MOAI1S $PINS O=n199 A1=n368 A2=FE_OFN492_n299 B1=FE_PHN995_raw_k_11
+ B2=n47
XU506 MOAI1S $PINS O=n198 A1=n369 A2=FE_OFN492_n299 B1=FE_PHN1495_raw_k_10
+ B2=n47
XU507 MOAI1S $PINS O=n197 A1=n370 A2=FE_OFN492_n299 B1=FE_PHN1009_raw_k_9
+ B2=n47
XU508 MOAI1S $PINS O=n196 A1=n371 A2=FE_OFN492_n299 B1=FE_PHN997_raw_k_8 B2=n47
XU509 MOAI1S $PINS O=n195 A1=n372 A2=n299 B1=FE_PHN1097_raw1_11 B2=n47
XU510 MOAI1S $PINS O=n194 A1=n373 A2=n299 B1=FE_PHN1109_raw1_10 B2=n47
XU511 MOAI1S $PINS O=n193 A1=n374 A2=n299 B1=FE_PHN1062_raw1_9 B2=n47
XU512 MOAI1S $PINS O=n192 A1=n375 A2=n299 B1=FE_PHN1149_raw1_8 B2=n47
XU513 MOAI1S $PINS O=n191 A1=n376 A2=FE_OFN492_n299 B1=raw2[11] B2=n47
XU514 MOAI1S $PINS O=n190 A1=n377 A2=FE_OFN492_n299 B1=raw2[10] B2=n47
XU515 MOAI1S $PINS O=n189 A1=n378 A2=FE_OFN492_n299 B1=FE_PHN1286_raw2_9 B2=n47
XU516 MOAI1S $PINS O=n188 A1=n379 A2=FE_OFN492_n299 B1=FE_PHN1299_raw2_8 B2=n47
XU517 MOAI1S $PINS O=n187 A1=n364 A2=FE_OFN492_n299 B1=raw_prime[11] B2=n47
XU518 MOAI1S $PINS O=n186 A1=n365 A2=FE_OFN492_n299 B1=raw_prime[10] B2=n47
XU519 MOAI1S $PINS O=n185 A1=n366 A2=FE_OFN492_n299 B1=raw_prime[9] B2=n47
XU520 MOAI1S $PINS O=n183 A1=n360 A2=n299 B1=raw_a[11] B2=n47
XU521 MOAI1S $PINS O=n255 A1=n367 A2=n296 B1=raw_prime[16] B2=n43
XU522 MOAI1S $PINS O=n239 A1=n367 A2=FE_OFN490_n297 B1=FE_OFN42_raw_prime_20
+ B2=n41
XU523 MOAI1S $PINS O=n223 A1=n367 A2=n298 B1=raw_prime[24] B2=n39
XU524 MOAI1S $PINS O=n271 A1=n367 A2=n44 B1=raw_prime[12] B2=n45
XU525 MOAI1S $PINS O=n221 A1=n367 A2=FE_OFN493_n300 B1=FE_OFN58_raw_prime_4
+ B2=n50
XU526 MOAI1S $PINS O=n184 A1=n367 A2=n299 B1=raw_prime[8] B2=n47
XU527 INV1S $PINS O=n385 I=state[0]
XU528 MOAI1S $PINS O=n146 A1=n345 A2=n375 B1=FE_PHN1338_raw1_0 B2=FE_DBTN0_n295
XU529 MOAI1S $PINS O=n145 A1=n33 A2=n374 B1=FE_PHN1076_raw1_1 B2=FE_DBTN0_n295
XU530 MOAI1S $PINS O=n144 A1=n344 A2=n373 B1=FE_PHN1114_raw1_2 B2=FE_DBTN0_n295
XU531 MOAI1S $PINS O=n143 A1=n345 A2=n372 B1=FE_PHN1053_raw1_3 B2=FE_DBTN0_n295
XU532 MOAI1S $PINS O=n142 A1=n33 A2=n379 B1=raw2[0] B2=FE_OFN487_FE_DBTN0_n295
XU533 MOAI1S $PINS O=n141 A1=n344 A2=n378 B1=raw2[1] B2=FE_OFN487_FE_DBTN0_n295
XU534 MOAI1S $PINS O=n140 A1=n345 A2=n377 B1=FE_PHN1292_raw2_2
+ B2=FE_OFN487_FE_DBTN0_n295
XU535 MOAI1S $PINS O=n139 A1=n33 A2=n376 B1=raw2[3] B2=FE_OFN487_FE_DBTN0_n295
XU536 MOAI1S $PINS O=n138 A1=n344 A2=n366 B1=FE_OFN86_n312
+ B2=FE_OFN487_FE_DBTN0_n295
XU537 MOAI1S $PINS O=n137 A1=n345 A2=n365 B1=FE_PHN1183_raw_prime_2
+ B2=FE_OFN487_FE_DBTN0_n295
XU538 MOAI1S $PINS O=n136 A1=n33 A2=n364 B1=FE_OFN59_raw_prime_3
+ B2=FE_OFN487_FE_DBTN0_n295
XU539 MOAI1S $PINS O=n135 A1=n344 A2=n363 B1=FE_PHN1295_raw_a_0
+ B2=FE_DBTN0_n295
XU540 MOAI1S $PINS O=n134 A1=n345 A2=n362 B1=raw_a[1] B2=FE_DBTN0_n295
XU541 MOAI1S $PINS O=n133 A1=n33 A2=n361 B1=raw_a[2] B2=FE_DBTN0_n295
XU542 MOAI1S $PINS O=n132 A1=n344 A2=n360 B1=raw_a[3] B2=FE_DBTN0_n295
XU543 MOAI1S $PINS O=n131 A1=n345 A2=n371 B1=FE_PHN1030_raw_k_0
+ B2=FE_OFN487_FE_DBTN0_n295
XU544 MOAI1S $PINS O=n130 A1=n33 A2=n370 B1=FE_PHN1503_raw_k_1
+ B2=FE_OFN487_FE_DBTN0_n295
XU545 MOAI1S $PINS O=n129 A1=n344 A2=n369 B1=FE_PHN1098_raw_k_2
+ B2=FE_OFN487_FE_DBTN0_n295
XU546 MOAI1S $PINS O=n128 A1=n345 A2=n368 B1=FE_PHN1007_raw_k_3
+ B2=FE_OFN487_FE_DBTN0_n295
XU547 MOAI1S $PINS O=n162 A1=n343 A2=n367 B1=raw_prime[28] B2=n36
XU548 INV1S $PINS O=n387 I=state[3]
XU549 INV1S $PINS O=n388 I=state[2]
XU550 NR2 $PINS O=n70 I1=n385 I2=state[3]
XU551 AN3 $PINS O=n79 I1=state[4] I2=n72 I3=n125
XU552 NR2 $PINS O=n125 I1=state[2] I2=state[1]
XU553 NR2 $PINS O=n59 I1=i_start I2=n37
XU554 NR2 $PINS O=n72 I1=state[3] I2=state[0]
XU555 INV1S $PINS O=n361 I=a[2]
XU556 INV1S $PINS O=n362 I=a[1]
XU557 INV1S $PINS O=n363 I=a[0]
XU558 INV1S $PINS O=n368 I=k[3]
XU559 INV1S $PINS O=n369 I=k[2]
XU560 INV1S $PINS O=n370 I=k[1]
XU561 INV1S $PINS O=n371 I=k[0]
XU562 INV1S $PINS O=n372 I=Px[3]
XU563 INV1S $PINS O=n373 I=Px[2]
XU564 INV1S $PINS O=n374 I=Px[1]
XU565 INV1S $PINS O=n375 I=Px[0]
XU566 INV1S $PINS O=n376 I=Py[3]
XU567 INV1S $PINS O=n377 I=Py[2]
XU568 INV1S $PINS O=n378 I=Py[1]
XU569 INV1S $PINS O=n379 I=Py[0]
XU570 INV1S $PINS O=n364 I=prime[3]
XU571 INV1S $PINS O=n365 I=prime[2]
XU572 INV1S $PINS O=n366 I=prime[1]
XU573 INV1S $PINS O=n360 I=a[3]
XU574 INV1S $PINS O=n367 I=prime[0]
XU575 AO22 $PINS O=n318 A1=final_output_2[20] A2=n294 B1=final_output_2[16]
+ B2=n317
XU576 AO22 $PINS O=n319 A1=final_output_2[28] A2=n79 B1=final_output_2[24]
+ B2=n291
XU577 ND2 $PINS O=n320 I1=n101 I2=n102
XU578 AO22 $PINS O=n321 A1=final_output_2[21] A2=n294 B1=final_output_2[17]
+ B2=n317
XU579 AO22 $PINS O=n322 A1=final_output_2[29] A2=n79 B1=final_output_2[25]
+ B2=n291
XU580 ND2 $PINS O=n323 I1=n96 I2=n97
XU581 AO22 $PINS O=n324 A1=final_output_2[22] A2=n294 B1=final_output_2[18]
+ B2=n317
XU582 AO22 $PINS O=n325 A1=final_output_2[30] A2=n79 B1=final_output_2[26]
+ B2=n291
XU583 ND2 $PINS O=n326 I1=n91 I2=n92
XU584 AO22 $PINS O=n327 A1=final_output_2[23] A2=n294 B1=final_output_2[19]
+ B2=n317
XU585 AO22 $PINS O=n328 A1=final_output_2[31] A2=n79 B1=final_output_2[27]
+ B2=n291
XU586 ND2 $PINS O=n329 I1=n86 I2=n87
XU587 AO22 $PINS O=n330 A1=final_output_1[20] A2=n294 B1=final_output_1[16]
+ B2=n317
XU588 AO22 $PINS O=n331 A1=final_output_1[28] A2=n79 B1=final_output_1[24]
+ B2=n291
XU589 ND2 $PINS O=n332 I1=n121 I2=n122
XU590 AO22 $PINS O=n333 A1=final_output_1[21] A2=n294 B1=final_output_1[17]
+ B2=n317
XU591 AO22 $PINS O=n334 A1=final_output_1[29] A2=n79 B1=final_output_1[25]
+ B2=n291
XU592 ND2 $PINS O=n335 I1=n116 I2=n117
XU593 AO22 $PINS O=n336 A1=final_output_1[22] A2=n294 B1=final_output_1[18]
+ B2=n317
XU594 AO22 $PINS O=n337 A1=final_output_1[30] A2=n79 B1=final_output_1[26]
+ B2=n291
XU595 ND2 $PINS O=n338 I1=n111 I2=n112
XU596 AO22 $PINS O=n339 A1=final_output_1[23] A2=n294 B1=final_output_1[19]
+ B2=n317
XU597 AO22 $PINS O=n340 A1=final_output_1[31] A2=n79 B1=final_output_1[27]
+ B2=n291
XU598 ND2 $PINS O=n341 I1=n106 I2=n107
XU600 AOI22S $PINS O=n101 A1=final_output_2[4] A2=n60 B1=final_output_2[0]
+ B2=n78
XU601 AOI22S $PINS O=n96 A1=final_output_2[5] A2=n60 B1=final_output_2[1]
+ B2=n78
XU602 AOI22S $PINS O=n91 A1=final_output_2[6] A2=n60 B1=final_output_2[2]
+ B2=n78
XU603 AOI22S $PINS O=n86 A1=final_output_2[7] A2=n60 B1=final_output_2[3]
+ B2=n78
XU604 AOI22S $PINS O=n121 A1=final_output_1[4] A2=n60 B1=final_output_1[0]
+ B2=n78
XU605 AOI22S $PINS O=n116 A1=final_output_1[5] A2=n60 B1=final_output_1[1]
+ B2=n78
XU606 AOI22S $PINS O=n111 A1=final_output_1[6] A2=n60 B1=final_output_1[2]
+ B2=n78
XU607 AOI22S $PINS O=n106 A1=final_output_1[7] A2=n60 B1=final_output_1[3]
+ B2=n78
XU608 AOI22S $PINS O=n102 A1=final_output_2[12] A2=n386 B1=final_output_2[8]
+ B2=n293
XU609 AOI22S $PINS O=n97 A1=final_output_2[13] A2=n386 B1=final_output_2[9]
+ B2=n293
XU610 AOI22S $PINS O=n92 A1=final_output_2[14] A2=n386 B1=final_output_2[10]
+ B2=n293
XU611 AOI22S $PINS O=n87 A1=final_output_2[15] A2=n386 B1=final_output_2[11]
+ B2=n293
XU612 AOI22S $PINS O=n122 A1=final_output_1[12] A2=n386 B1=final_output_1[8]
+ B2=n293
XU613 AOI22S $PINS O=n117 A1=final_output_1[13] A2=n386 B1=final_output_1[9]
+ B2=n293
XU614 AOI22S $PINS O=n112 A1=final_output_1[14] A2=n386 B1=final_output_1[10]
+ B2=n293
XU615 AOI22S $PINS O=n107 A1=final_output_1[15] A2=n386 B1=final_output_1[11]
+ B2=n293
XU617 MOAI1S $PINS O=n292 A1=n344 A2=n367 B1=n311 B2=FE_DBTN0_n295
.ENDS

.SUBCKT CHIP i_clk i_rst i_start a[3] a[2] a[1] a[0] prime[3] prime[2] prime[1]
+ prime[0] Px[3] Px[2] Px[1] Px[0] Py[3] Py[2] Py[1] Py[0] k[3] k[2] k[1] k[0]
+ kPx[3] kPx[2] kPx[1] kPx[0] kPy[3] kPy[2] kPy[1] kPy[0] done
XFE_OFC585_n_logic0 BUF2CK $PINS O=FE_OFN618_n_logic0 I=n_logic0
XFE_OFC411_FE_OFN29_n_logic0 BUF1 $PINS O=FE_OFN444_FE_OFN29_n_logic0
+ I=FE_OFN29_n_logic0
XFE_OFC410_FE_OFN30_n_logic0 BUF1 $PINS O=FE_OFN443_FE_OFN30_n_logic0
+ I=FE_OFN30_n_logic0
XFE_OFC28_n_logic0 BUF1 $PINS O=FE_OFN30_n_logic0 I=FE_OFN618_n_logic0
XFE_OFC27_n_logic0 BUF1 $PINS O=FE_OFN29_n_logic0 I=n_logic0
XFE_DBTC1_i_i_rst INV1S $PINS O=FE_DBTN1_i_i_rst I=i_i_rst
Xtop0 ECC_Lookup $PINS i_rst=FE_DBTN1_i_i_rst i_clk=i_i_clk i_start=i_i_start
+ a[3]=i_a[3] a[2]=i_a[2] a[1]=i_a[1] a[0]=i_a[0] prime[3]=i_prime[3]
+ prime[2]=i_prime[2] prime[1]=i_prime[1] prime[0]=i_prime[0] k[3]=i_k[3]
+ k[2]=i_k[2] k[1]=i_k[1] k[0]=i_k[0] Px[3]=i_px[3] Px[2]=i_px[2] Px[1]=i_px[1]
+ Px[0]=i_px[0] Py[3]=i_py[3] Py[2]=i_py[2] Py[1]=i_py[1] Py[0]=i_py[0]
+ kPx[3]=i_kpx[3] kPx[2]=i_kpx[2] kPx[1]=i_kpx[1] kPx[0]=i_kpx[0] kPy[3]=i_kpy[3]
+ kPy[2]=i_kpy[2] kPy[1]=i_kpy[1] kPy[0]=i_kpy[0] done=i_done
Xipad_n_logic0 TIE0 $PINS O=n_logic0
Xipad_n_logic1 TIE1 $PINS O=n_logic1
Xipad_i_clk XMD $PINS O=i_i_clk I=i_clk PU=FE_OFN30_n_logic0
+ PD=FE_OFN30_n_logic0 SMT=FE_OFN30_n_logic0
Xipad_i_rst XMD $PINS O=i_i_rst I=i_rst PU=FE_OFN30_n_logic0
+ PD=FE_OFN30_n_logic0 SMT=FE_OFN30_n_logic0
Xipad_i_start XMD $PINS O=i_i_start I=i_start PU=FE_OFN443_FE_OFN30_n_logic0
+ PD=FE_OFN443_FE_OFN30_n_logic0 SMT=FE_OFN443_FE_OFN30_n_logic0
Xipad_a_i_0 XMD $PINS O=i_a[0] I=a[0] PU=FE_OFN443_FE_OFN30_n_logic0
+ PD=FE_OFN443_FE_OFN30_n_logic0 SMT=FE_OFN443_FE_OFN30_n_logic0
Xipad_a_i_1 XMD $PINS O=i_a[1] I=a[1] PU=FE_OFN443_FE_OFN30_n_logic0
+ PD=FE_OFN443_FE_OFN30_n_logic0 SMT=FE_OFN30_n_logic0
Xipad_a_i_2 XMD $PINS O=i_a[2] I=a[2] PU=FE_OFN30_n_logic0 PD=FE_OFN30_n_logic0
+ SMT=FE_OFN30_n_logic0
Xipad_a_i_3 XMD $PINS O=i_a[3] I=a[3] PU=FE_OFN30_n_logic0 PD=FE_OFN30_n_logic0
+ SMT=FE_OFN30_n_logic0
Xipad_prime_i_0 XMD $PINS O=i_prime[0] I=prime[0] PU=FE_OFN30_n_logic0
+ PD=FE_OFN30_n_logic0 SMT=FE_OFN30_n_logic0
Xipad_prime_i_1 XMD $PINS O=i_prime[1] I=prime[1]
+ PU=FE_OFN444_FE_OFN29_n_logic0 PD=FE_OFN444_FE_OFN29_n_logic0
+ SMT=FE_OFN444_FE_OFN29_n_logic0
Xipad_prime_i_2 XMD $PINS O=i_prime[2] I=prime[2]
+ PU=FE_OFN444_FE_OFN29_n_logic0 PD=FE_OFN444_FE_OFN29_n_logic0
+ SMT=FE_OFN444_FE_OFN29_n_logic0
Xipad_prime_i_3 XMD $PINS O=i_prime[3] I=prime[3]
+ PU=FE_OFN444_FE_OFN29_n_logic0 PD=FE_OFN444_FE_OFN29_n_logic0
+ SMT=FE_OFN444_FE_OFN29_n_logic0
Xipad_px_i_0 XMD $PINS O=i_px[0] I=Px[0] PU=FE_OFN444_FE_OFN29_n_logic0
+ PD=FE_OFN444_FE_OFN29_n_logic0 SMT=FE_OFN444_FE_OFN29_n_logic0
Xipad_px_i_1 XMD $PINS O=i_px[1] I=Px[1] PU=FE_OFN443_FE_OFN30_n_logic0
+ PD=FE_OFN443_FE_OFN30_n_logic0 SMT=FE_OFN443_FE_OFN30_n_logic0
Xipad_px_i_2 XMD $PINS O=i_px[2] I=Px[2] PU=FE_OFN443_FE_OFN30_n_logic0
+ PD=FE_OFN443_FE_OFN30_n_logic0 SMT=FE_OFN443_FE_OFN30_n_logic0
Xipad_px_i_3 XMD $PINS O=i_px[3] I=Px[3] PU=FE_OFN443_FE_OFN30_n_logic0
+ PD=FE_OFN443_FE_OFN30_n_logic0 SMT=FE_OFN443_FE_OFN30_n_logic0
Xipad_py_i_0 XMD $PINS O=i_py[0] I=Py[0] PU=FE_OFN443_FE_OFN30_n_logic0
+ PD=FE_OFN443_FE_OFN30_n_logic0 SMT=FE_OFN443_FE_OFN30_n_logic0
Xipad_py_i_1 XMD $PINS O=i_py[1] I=Py[1] PU=FE_OFN444_FE_OFN29_n_logic0
+ PD=FE_OFN444_FE_OFN29_n_logic0 SMT=FE_OFN444_FE_OFN29_n_logic0
Xipad_py_i_2 XMD $PINS O=i_py[2] I=Py[2] PU=FE_OFN444_FE_OFN29_n_logic0
+ PD=FE_OFN444_FE_OFN29_n_logic0 SMT=FE_OFN444_FE_OFN29_n_logic0
Xipad_py_i_3 XMD $PINS O=i_py[3] I=Py[3] PU=FE_OFN444_FE_OFN29_n_logic0
+ PD=FE_OFN29_n_logic0 SMT=FE_OFN444_FE_OFN29_n_logic0
Xipad_k_i_0 XMD $PINS O=i_k[0] I=k[0] PU=FE_OFN29_n_logic0 PD=FE_OFN29_n_logic0
+ SMT=FE_OFN29_n_logic0
Xipad_k_i_1 XMD $PINS O=i_k[1] I=k[1] PU=FE_OFN29_n_logic0 PD=FE_OFN29_n_logic0
+ SMT=FE_OFN29_n_logic0
Xipad_k_i_2 XMD $PINS O=i_k[2] I=k[2] PU=FE_OFN29_n_logic0 PD=FE_OFN29_n_logic0
+ SMT=FE_OFN29_n_logic0
Xipad_k_i_3 XMD $PINS O=i_k[3] I=k[3] PU=FE_OFN29_n_logic0 PD=FE_OFN29_n_logic0
+ SMT=FE_OFN29_n_logic0
Xipad_kpx_0 YA2GSD $PINS O=kPx[0] I=i_kpx[0] E=n_logic1 E2=FE_OFN29_n_logic0
+ E4=FE_OFN29_n_logic0 E8=FE_OFN29_n_logic0 SR=FE_OFN29_n_logic0
Xipad_kpx_1 YA2GSD $PINS O=kPx[1] I=i_kpx[1] E=n_logic1 E2=n_logic0 E4=n_logic0
+ E8=n_logic0 SR=n_logic0
Xipad_kpx_2 YA2GSD $PINS O=kPx[2] I=i_kpx[2] E=n_logic1 E2=n_logic0 E4=n_logic0
+ E8=n_logic0 SR=n_logic0
Xipad_kpx_3 YA2GSD $PINS O=kPx[3] I=i_kpx[3] E=n_logic1 E2=n_logic0 E4=n_logic0
+ E8=n_logic0 SR=n_logic0
Xipad_kpy_0 YA2GSD $PINS O=kPy[0] I=i_kpy[0] E=n_logic1 E2=n_logic0 E4=n_logic0
+ E8=n_logic0 SR=FE_OFN618_n_logic0
Xipad_kpy_1 YA2GSD $PINS O=kPy[1] I=i_kpy[1] E=n_logic1 E2=FE_OFN618_n_logic0
+ E4=FE_OFN618_n_logic0 E8=FE_OFN618_n_logic0 SR=FE_OFN618_n_logic0
Xipad_kpy_2 YA2GSD $PINS O=kPy[2] I=i_kpy[2] E=n_logic1 E2=FE_OFN618_n_logic0
+ E4=FE_OFN618_n_logic0 E8=FE_OFN618_n_logic0 SR=FE_OFN618_n_logic0
Xipad_kpy_3 YA2GSD $PINS O=kPy[3] I=i_kpy[3] E=n_logic1 E2=FE_OFN618_n_logic0
+ E4=FE_OFN618_n_logic0 E8=FE_OFN618_n_logic0 SR=FE_OFN618_n_logic0
Xipad_done YA2GSD $PINS O=done I=i_done E=n_logic1 E2=FE_OFN618_n_logic0
+ E4=FE_OFN618_n_logic0 E8=FE_OFN618_n_logic0 SR=FE_OFN618_n_logic0
.ENDS
